# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Nets (continued)
N1553121: C962.1 R721.1 R723.1 U77.1
N1553157: C963.1 R722.1 R724.1 U78.1
N1703298: C1008.2 R228.2 R237.1 U23.12
N1703311: C1009.2 R229.2 R234.1 U23.13
N1703324: C1010.2 R230.2 R235.1 U23.10
N1703337: C1011.2 R231.2 R236.1 U23.11
N1703797: C352.2 FB12.1 R228.1 R229.1 R230.1 R231.1
N1706943: R238.1 U24.1
N1707033: R240.1 U24.3
N1707243: R239.2 U23.41
N1762439: R241.1 R256.2 U23.33
N1762443: R257.2 U23.34
N1918614: R107.1 U10.3
N1965215: R591.2 R594.2 U65.34
N1965219: R592.2 R595.2 U65.32
N1965255: C764.1 R593.2 R594.1 R595.1 U65.30
N1965465: R598.1 U65.35
N1965499: C767.1 U65.36
N1980839: R583.2 R586.2 U64.34
N1980841: R584.2 R587.2 U64.32
N1980849: C746.1 R585.2 R586.1 R587.1 U64.30
N1980893: R590.1 U64.35
N1980897: C749.1 U64.36
N1982757: R575.2 R578.2 U63.34
N1982759: R576.2 R579.2 U63.32
N1982767: C728.1 R577.2 R578.1 R579.1 U63.30
N1982811: R582.1 U63.35
N1982815: C731.1 U63.36
N1984675: R567.2 R570.2 U62.34
N1984677: R568.2 R571.2 U62.32
N1984685: C710.1 R569.2 R570.1 R571.1 U62.30
N1984729: R574.1 U62.35
N1984733: C713.1 U62.36
N1987677: R546.2 U61.44
N1989130: R544.2 U61.48
N1989134: R545.2 U61.47
N1993333: C693.1 R531.2 U61.32
N1995084: R542.1 U61.21
N1995190: R548.1 U61.8
N1995248: R554.2 U61.22
N1995256: R555.2 U61.27
N1995356: R556.1 R558.2 U61.12
N1995388: R557.2 R559.1 U61.13
N1995426: R561.1 R562.2 U61.34
N1995468: R565.1 R566.2 U61.35
N1997388: C697.1 U61.10
N1997392: C699.1 U61.9
N2007530: R549.1 U61.39
N2008530: C467.2 R370.2 U36.7(VREF2) U36.8
N2089040: R536.2 U61.17
N2153801: R173.2 U19.B9(ZQ)
N2166287: D1.C(CATHODE) Q1.3
N2166291: D1.A R82.1
N2171307: R599.2 R602.2 U66.34
N2171311: R600.2 R603.2 U66.32
N2171371: C782.1 R601.2 R602.1 R603.1 U66.30
N2171693: R606.1 U66.35
N2171731: C785.1 U66.36
N2530657: C698.1 U61.37
N2530661: C700.1 U61.38
N2608710: D17.2 J13.4
N2746722: J2.3(TACH) R89.1
N2760104: R464.2 SW5.4
N2760122: R466.2 SW5.6
N2766693: D3.C(CATHODE) Q8.3
N2766701: D3.A R400.1
N2766729: D6.C(CATHODE) Q9.3
N2766737: D6.A R401.1
N2801539: D4.C(CATHODE) Q10.3
N2801547: D4.A R402.1
N2801575: D7.C(CATHODE) Q11.3
N2801583: D7.A R403.1
N2830778: R79.1 U5.A8
N2830869: R69.2 U5.J11
N2830873: R70.2 U5.J12
N2830995: R52.1 U5.H5
N2830997: R54.1 U5.B2
N2831098: R53.1 U5.N2
N2831570: R71.1 U5.K14
N2975570: J5.1 J5.145 R147.2 R148.2
N2979144: J5.288 R161.2
N3089983: C624.1 R473.2
N4269052: U8.J47 U8.K48
N5229121: C977.1 R742.1 R743.1 U80.3
N5229137: C981.1 U80.6
N5229211: R609.1 R614.2 R620.2 U80.7
N5238722: C983.1 R745.1 R746.1 U81.3
N5238738: C987.1 U81.6
N5254399: C413.2 C417.1 FB37.2 U25.5
N5254403: C414.2 C418.1 FB38.2 U25.6
N5254415: C988.2 C990.1 FB39.2 U25.31
N5402274: C1003.2 R766.1
N5872472: R358.1 U88.9
N5919185: R123.1 U91.4(Y)
N5919260: R839.1 U91.1
N6052446: J3.2 R88.1
N6060143: R845.1 U8.G45
N6228318: R637.2 R6833.1 R6835.2 U93.C1
N6231213: C1081.2 L11.1 R6883.2 U93.F9 U93.N1 U93.N2 U93.N3 U93.N4 U93.N5 U93.P1 U93.P2 U93.P3 U93.P4 U93.P5
N6231502: C1080.2 L10.1 R6853.2 U93.C10 U93.N6 U93.N7 U93.N8 U93.N9 U93.N10 U93.P6 U93.P7 U93.P8 U93.P9 U93.P10
N6293185: R852.2 R6834.1 R6836.2 U93.C2
N6294472: R6844.1 U93.E3
N6295710: C1212.1 R6851.2 R6853.1 U93.B6
N6295719: C1212.2 R6851.1 R6852.1 U93.A6
N6295800: R6857.1 U93.A9
N6296034: R854.2 U93.B1
N6296038: R855.2 U93.A1
N6296130: R6860.2 U93.E7
N6296322: C1213.2 R6855.1 R6884.1 U93.B8
N6296326: R6859.1 U93.F7
N6296367: C1213.1 R6883.1 R6884.2 U93.A8
N6296487: R856.1 U93.A4
N6298711: C1092.1 D18.2 D19.2 U93.E10
N6299162: C1208.1 U93.D9
N6302987: R858.1 R6794.1 U93.D1
N6302998: R857.1 R6797.1 U93.E1
N6310318: C1103.2 U94.A2
N6310354: C1201.2 C1202.2 R868.2 R6877.2 U94.B1
N6310567: R866.2 U94.A4
N6362776: C1123.2 R869.1 U95.H8
N6365028: C1125.1 C1126.2 R1004.2 U95.D5 U95.D7
N6365040: U95.E6 U95.E7
N6365052: C1124.2 U95.D8 U95.E5
N6365353: C1126.1 ST32.1 U95.E8
N6365365: ST33.1 U95.E9
N6366094: R6879.1 ST33.2
N6366537: R6878.1 ST32.2
N6366923: C1125.2 U95.C5 U95.F8
N6369590: R6880.2 U95.C6
N6369792: R1005.2 U95.J6
N6372269: C1127.2 R1006.1 U93.D8
N6382900: C1149.1 U93.E6
N6383007: C1211.1 U93.B7
N6384083: C1210.1 U93.E5
N6384284: C1209.1 U93.A7
N6438706: R6858.2 U93.A10
N6440564: C1220.1 Q21.1(EMITTER) U93.A5
N6440883: C1221.1 Q22.1(EMITTER) U93.B5
N6626632: R1008.2 R6798.1 U93.D2
N6626636: R6791.1 R6799.1 U93.F1
N6626640: R6845.1 R6846.1 U93.E2
N6626644: R6847.1 R6848.1 U93.F2
N6645972: C1154.1 D20.2 D21.2 U96.E10
N6646134: C1157.2 R6802.1 U96.D8
N6646306: C1216.1 U96.D9
N6646832: C1158.1 D20.1(C) R6867.2
N6646840: C1158.2 L12.1 R6861.2 U96.C10 U96.N6 U96.N7 U96.N8 U96.N9 U96.N10 U96.P6 U96.P7 U96.P8 U96.P9 U96.P10
N6647874: R6870.2 U96.A10
N6648020: C1222.1 Q23.1(EMITTER) U96.A5
N6648054: C1178.1 U96.A7
N6648084: C1179.1 U96.B7
N6648272: R6808.2 R6830.1 R6831.2 U96.C1
N6648296: C1180.1 D21.1(C) R6868.2
N6648304: C1180.2 L13.1 R6885.2 U96.F9 U96.N1 U96.N2 U96.N3 U96.N4 U96.N5 U96.P1 U96.P2 U96.P3 U96.P4 U96.P5
N6648338: R6809.2 R6828.1 R6829.2 U96.C2
N6648554: R6810.1 U96.A4
N6649026: R6811.2 U96.A1
N6649122: R6818.2 U96.B1
N6649146: R6812.1 R6819.2 U96.D1
N6649150: R6813.1 R6821.1 U96.E1
N6649154: R6814.1 R6832.2 U96.D2
N6649158: R6815.1 R6822.1 U96.F1
N6649162: R6873.1 R6874.1 U96.E2
N6649166: R6875.1 R6876.1 U96.F2
N6649352: R6872.2 U96.E7
N6649458: R6825.2 U96.E3
N6649494: C1223.1 Q24.1(EMITTER) U96.B5
N6649576: C1191.1 U96.E5
N6649610: C1193.1 U96.E6
N6658100: C865.1 R666.2 R668.1 U70.3
N6658116: C869.1 U70.6
N6731924: C1031.1 C1194.1 C1195.1 C1196.1 C1197.2 C1198.1 FB41.2 X1.9(VCC33) X2.8 X2.9(VDD33)
N6732170: C1199.2 X2.7
N6732230: R6837.1 X1.5 X2.6
N6843686: C1200.1 R6838.2 U94.A1
N6844906: C1203.1 R6839.1 U94.C5
N6923756: C1080.1 D18.1(C) R6849.2
N6924340: R6850.1 U93.F10
N6924392: C1081.1 D19.1(C) R6850.2
N6992519: C1214.1 R6861.1 R6863.2 U96.B6
N6992523: C1214.2 R6862.1 R6863.1 U96.A6
N6993090: C1215.1 R6885.1 R6886.1 U96.A8
N6993094: C1215.2 R6865.1 R6886.2 U96.B8
N6995373: R6867.1 U96.C9
N6996186: R6868.1 U96.F10
N6998281: R6869.1 U96.A9
N6999941: R6871.1 U96.F7
N7012506: C1218.1 U95.J7
N7118059: D22.2 D23.2 J107.4
N7208051: D24.C(CATHODE) Q19.3
N7208055: D24.A R6888.1
N7208455: D25.C(CATHODE) Q20.3
N7208459: D25.A R6890.1
N7393705: R6893.1 U97.1
N7393712: R6892.1 U97.2
N7393719: R6891.1 U97.3
N8086837: D26.3 D27.3 R6903.1
N62271684: R6849.1 U93.C9

Pads without a net: D26 2; D27 2; D28 1 2 3 7 8; J3 7 8; J4 144 205 227; J5 144 205 227; J7 46 47 49 50 65 66 69; J9 A8 A9 A20 A21 A23 A24 A26 A27 A30 A32 A33 A35 A36 B8 B9 B20 B21 B23 B24 B26 B27 B32 B33 B35 B36; MTH1 1; MTH3 1; MTH5 1; MTH8 1; MTH9 1; MTH10 1; NOREF#9 1; NOREF#18 1; NOREF#19 1; NOREF#24 1; NOREF#27 1; NOREF#35 1; NOREF#36 1; NOREF#37 1; NOREF#43 1; NOREF#44 1; NOREF#45 1; SW5 1 2 3; U3 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U4 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U5 A14 A15 B8 B10 B13 E4 E9 E10 F9 F10 F11 F12; U8 A11 A13 A15 A17 A19 A21 A23 A25 A27 A29 A31 A33 AA17 AB4 AB16 AB42 AC41 AC47 AD46 AG15 AJ15 AK48 B12 B14 B16 B18 B20 B22 B24 B26 B28 B30 B32 B34 BA49 BL7 BR41 BT42 BT44 BW41 BW43 BY44 CB8 CD12 CE7 CE13 CF14 CF42 CF50 CG7 CG11 CH10 CH16 CH42 CH50 CJ9 CJ15 CJ53 CK10 CK12 CK14 CK16 CK20 CK22 CK26 CK28 CK52 CL13 CL15 CL17 CL21 CL23 CL27 CL29 CN13 CN15 CN17 CN19 CN21 CN23 CN25 CN27 CP12 CP14 CP16 CP18 CP20 CP22 CP26 CR11 CR13 CR15 CR17 CT12 CT14 CT54 CV12 CV14 CV16 CW11 CW13 CW15 CW17 D8 D12 D14 D16 D18 D20 D22 D24 D26 D28 D30 D32 D34 D50 D52 DA7 DC3 DC5 DC7 DD4 DD6 DE31 DE33 DE41 DE43 DE45 DF30 DF32 DF40 DF42 DF44 DH30 DH40 DH42 DH44 DJ29 DJ31 DJ41 DJ43 DJ45 E11 E13 E15 E17 E19 E21 E23 E25 E27 E29 E31 E33 E51 E53 F14 F16 F18 F20 F22 F24 F26 F28 F30 F32 F34 F36 F38 F40 F42 G13 G15 G17 G19 G21 G23 G25 G27 G29 G31 G33 G35 G37 G39 G41 J13 J15 J17 J19 J21 J23 J25 J27 J29 J31 J33 J35 J37 J39 J41 J55 K4 K10 K14 K16 K18 K20 K22 K24 K26 K28 K30 K32 K34 K36 K38 K40 K42 L13 L15 L17 L19 L21 L23 L25 L27 L29 L31 L33 L35 L37 L39 L41 L43 L45 L47 L55 M10 M14 M16 M18 M20 M22 M24 M26 M28 M30 M32 M34 M36 M40 M42 M44 M46 M48 M54 P4 P10 P14 P16 P18 P20 P22 P24 P26 P28 P30 P32 P34 P36 P38 P40 P42 P44 P46 R7 R13 R15 R17 R19 R21 R23 R25 R27 R29 R31 R33 R35 R37 R39 R41 R43 R45 T14 T16 T18 T20 T22 T24 T26 T28 T30 T32 T34 T36 T38 T40 T42 U13 U15 U17 U19 U21 U23 U25 U27 U29 U31 U33 U35 U39 U41 W13 W15 W17 W19 W21 W23 W25 W27 W29 W31 W33 W35 W37 W39 W41 Y14 Y16 Y18 Y20 Y22 Y24 Y26 Y28 Y30 Y32 Y34 Y36 Y38 Y40; U9 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U15 A3 F2 G2 G8 N7; U16 A3 F2 G2 G8 N7; U17 A3 F2 G2 G8 N7; U18 A3 F2 G2 G8 N7; U19 A3 F2 G2 G8 N7; U22 3 4 5 6 9 10 11 12; U23 5 6 7 9 32 40 42; U25 20 25 26 28 30; U26 5 6 10 21 22 23 24 25 26 27 28 29 30 33 34 35 38 39 40; U27 5 6 10 21 22 23 24 25 26 27 28 29 30 33 34 35 38 39 40; U33 7 8 9 12 13 14; U49 54; U52 5; U53 3 7; U56 8; U57 8; U58 8; U61 45 46 49; U62 23 24 25 26; U63 23 24 25 26; U64 23 24 25 26; U65 23 24 25 26; U66 23 24 25 26; U70 8; U74 8; U75 8; U76 8; U80 8; U81 8; U89 2 5 7 10; U90 2 5 7 10; U93 B2 B4 E8 E9 F5 F6; U94 A5 B5; U95 C8 G2 G4 G5 G11; U96 B2 B4 E8 E9 F5 F6; X1 1 2 3 6 7 8 10; X2 1 2 3

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 5727 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 674 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 1317 vias
v4: diameter 0.406, hole 0.254, TOP to L03_SIG1, 210 vias
v5: diameter 0.762, hole 0.508, TOP to BOTTOM, 375 vias
v6: diameter 0.406, hole 0.254, L16_SIG6 to BOTTOM, 33 vias
v7: diameter 0.406, hole 0.254, TOP to L02_GND1, 17 vias
v8: diameter 0.406, hole 0.254, L17_GND8 to BOTTOM, 28 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0V6_DDR4_VREF_COMP: length 2.8
  TOP w0.255: U78.6 63.13,19.51
  TOP w0.381: U19.J1 v1(73.26,20.96) ; C961.1 63.38,20.4 v3(63.25,20.27) 63.13,20.14 63.13,19.51
  vias: v1(86.38,20.96) v1(98.57,20.96) v1(110.76,20.96) v1(122.96,20.96)
0V6_DDR4_VREF_DIMM: length 160
  TOP w0.279: U77.6 189.89,99.28 189.68,99.08
  TOP w0.508: v1(49.88,100.66) 49.21,101.34 49.21,108.08 49.54,108.41 v1(49.88,108.41) 50.65,109.17 177.32,109.17 v1(178.95,107.55) ; v3(188.02,98.76) 189.36,98.76 189.68,99.08 ; J5.146 v1(50.94,107.6)
  BOTTOM w0.381: v1(49.88,100.66) C157.1 C152.1 ; C187.1 C191.1 v1(49.88,108.41)
  BOTTOM w0.508: v3(188.02,98.76) 185.94,98.76 183.59,101.1 181.78,101.1 178.95,103.94 v1(178.95,107.55)
  vias: v1(50.94,99.98)
0V6_DDR4_VTT_COMP: length 24.8
  TOP w0.254: U78.3 67.06,18.11
  TOP w0.279: U78.5 66.18,19.51 v1(66.05,19.64)
  BOTTOM w0.254: 82.3,13.69 82.3,12.4 82.05,12.14 69.22,12.14 66.5,14.86 66.5,19.18 v1(66.05,19.64)
  vias: v1(106.55,50.89) v2(84.82,26.88) v2(93.71,26.77) v3(67.95,20.65) v3(67.95,19.64) v3(67.95,18.49)
0V6_DDR4_VTT_DIMM: length 109.8
  TOP w0.254: U77.3 190.89,103.58
  TOP w0.279: v1(188.53,103.14) 188.54,103.14 188.98,102.7 U77.5
  L05_SIG2 w0.254: v1(108.14,72.97) 108.17,72.94 109.1,72.94 109.3,73.06 110.12,74.47 110.12,74.75 113.28,77.92 113.28,78.21 113.54,78.47 113.85,78.47 114.35,78.97 114.7,78.97 115.16,79.43 115.5,79.43 115.93,79.85 116.3,79.85 116.77,79.38 120.63,79.38 121.56,78.45 121.86,78.45 121.86,78.44 121.88,78.44 122.26,78.07 122.61,78.07 123.1,77.57 123.45,77.57 125.53,75.49 128.18,75.49
  L05_SIG2 w0.381: v1(188.53,103.14) 187.93,102.54 185.78,102.54 184.66,101.43 176.26,101.43 175.65,100.82 174.11,100.82 172.68,99.39 168.03,99.39 166.11,97.48 166.11,96.59 164.14,94.62 160.48,94.62 159.11,93.25 147.15,93.25 146.84,92.94 144.53,92.94 144.23,92.64 144.23,87.53 143.2,86.5 143.2,84.9 142.56,84.27 142.56,81.83 142.27,81.54 141.66,81.54 141.29,81.17 141.29,75.96 140.91,75.58 135.83,75.58 134.86,74.61 130.98,74.61 130.23,73.86 129.8,73.86 128.18,75.49
  vias: v1(98.58,72.97) v1(101.77,72.97) v1(104.96,72.97) v1(114.69,102.95) v1(114.69,101.68) v1(114.69,99.9) v1(114.69,98.63) v1(114.69,95.33) v1(114.78,94.06) v2(114.69,107.52) v2(114.69,106.25) v2(185.94,104.85) v2(185.94,103.2) v2(187.21,104.85) v2(187.21,103.2) v3(188.7,104.85) v3(190.38,104.85)
1V8_SI53254_1: length 15.2
  BOTTOM w0.254: U26.18 23.23,30.64 23.91,31.32 24.39,31.32 24.57,31.5 24.57,31.94 C996.1 v1(25.53,32.02) ; 18.43,24.6 18.71,24.88 U26.1 ; C994.1 C424.2 ; U26.9 18.45,28.88 18.26,29.07 ; U26.4 18.32,26.38 ; U26.15 21.73,30.84
  BOTTOM w0.305: v1(17.09,23.45) C995.1 18.17,24.34 18.43,24.6 ; v1(17.09,27.26) C997.1 17.1,26.38 18.32,26.38 ; v1(17.09,30.18) C993.1 18.04,29.29 18.26,29.07 ; 21.73,30.84 21.73,31.9 C994.1
  vias: v1(16.14,32.08) v1(16.14,31.19) v1(17.03,32.08) v1(17.03,31.19) v1(20.9,32.02)
1V8_SI53254_2: length 15
  BOTTOM w0.254: U27.18 23.23,46.71 23.91,46.03 ; 17.33,51.46 17.57,51.22 U27.1 ; 21.98,51.89 21.57,51.49 U27.9 ; U27.4 19.07,51.82 ; U27.15 23.58,48.21 ; C1000.1 v1(24.71,44.4)
  BOTTOM w0.305: C998.1 17.03,51.77 17.33,51.46 ; C1000.1 24.52,45.29 23.91,45.9 23.91,46.03 ; 19.07,51.82 19.07,52.84 C999.1 ; 23.58,48.21 24.59,48.21 C1001.1
  BOTTOM w0.381: 21.98,51.89 C1002.1 v1(22.87,52.85) ; v1(19.95,52.85) C999.1 ; C1001.1 v1(24.71,48.97) ; v1(16.14,52.85) C998.1
  vias: v1(23.88,52.78) v1(23.88,51.89) v1(24.71,52.78) v1(24.71,51.89)
2V5_DDR4_COMP: length 9.6
  TOP w0.381: R716.2 C929.2 135.73,15.45 135.52,15.66 135.52,16.21
  L07_SIG3 w0.254: 129.67,18.49 129.61,18.56 v1(129.36,18.56)
  BOTTOM w0.381: v1(80.59,18.56) 80.63,18.6 C290.1
  vias: v1(74.19,26.56) v1(76.59,25.76) v1(86.38,26.56) v1(88.78,27.46) v1(92.78,18.56) v1(98.57,26.56) v1(100.97,27.46) v1(104.97,18.56) v1(110.76,26.56) v1(113.16,27.46) v1(117.16,18.56) v1(122.96,26.56) v1(125.36,27.36) v3(135.52,17.35) v3(136.53,17.35) v3(137.68,17.35) v3(139.2,17.35) v3(140.72,17.35)
2V5_DDR4_DIMM: length 24.9
  TOP w0.381: C932.2 188.86,97.36 188.6,97.61 186.57,97.61 186.06,97.11 C928.2 R715.2
  BOTTOM w0.254: v1(175.89,98.63) 176.25,98.63 R145.1 ; R161.1 176.25,106.25 v1(175.89,106.25) ; 72.14,97.48 U38.2
  BOTTOM w0.305: v2(175.89,95.06) 175.89,94.27 175.6,93.98 v2(175.11,93.98) ; R134.2 v1(127.42,97.95) ; v2(175.11,101.6) 175.6,101.6 175.89,101.89 v2(175.89,102.68) ; R377.2 74.68,95.96 ; R383.2 74.68,105.74 ; R384.2 74.66,104.88 ; R376.2 74.68,96.98 ; R150.2 v1(127.42,105.58)
  BOTTOM w0.381: 74.87,98.06 R6897.1 C470.1 72.46,97.48 72.14,97.48 ; R385.1 74.18,103.27 C473.2 ; R152.2 173.35,103.64 v2(173.39,103.68)
  vias: v1(81.29,105.6) v1(82.43,105.6) v1(119.64,101.68) v1(120.64,93.09) v1(134.24,108.49) v1(135.09,108.49) v1(135.94,108.49) v1(175.04,106.25) v1(175.04,98.63) v2(173.34,106.25) v2(173.34,105.25) v2(173.34,98.63) v2(173.34,97.63) v2(175.04,102.68) v2(175.04,95.06) v3(187.27,96.66) v3(187.27,95.39) v3(188.03,96.66) v3(188.03,95.39) v3(188.79,96.66) v3(188.79,95.39)
3V3_AGND: length 13.6
  TOP w0.381: U95.C7 182.13,35.13 v2(181.49,34.5) ; v2(184.03,31.96) 184.67,32.59
  BOTTOM w0.381: R1004.1 181.2,37.04 181.87,37.04 181.87,34.88 v2(181.49,34.5) ; ST31.1 v2(184.03,31.96)
  BOTTOM w0.508: v2(181.49,34.5) 181.5,34.48 v5(181.5,31.96) v2(184.03,31.96)
3V3_STBY: length 214.8
  TOP w0.203: R241.2 55.67,54.53 55.67,52.94 R264.2
  TOP w0.254: EU2.1 90.22,36.74 90.09,36.87 v1(90.09,37.54) ; v1(71.84,55.2) 71.84,55.55 71.3,56.09 R739.1 ; v1(30.87,65.86) 30.8,65.8 R6890.2 ; EU1.1 63.3,78.87 63.2,78.77 v1(63.2,78.72) ; R243.2 55.61,42.09 55.38,41.86 55.38,40.34 56.01,39.7 58.05,39.7 v1(58.17,39.83) ; R264.2 v1(56.2,51.57) ; R849.1 38.68,65.48 v1(38.68,65.48) R6888.2 ; 28.9,100.22 28.9,100.98 29.08,101.16 U56.7 ; v1(56.14,46.18) R245.2 R244.2 ; v1(62.36,18.61) U78.7 ; v1(190.39,98.88) U77.7 ; R847.1 28.26,96.92
  TOP w0.305: v1(58.17,39.83) R242.2 ; v3(61.48,14.81) 61.48,13.92 63.74,11.66 R12.1
  L09_PWR1 w0.508: 19.69,104.2 19.69,102.21
  L10_PWR2 w0.508: 19.69,102.21 19.69,104.2
  L12_SIG4 w0.508: 19.69,102.21 19.69,104.2
  L16_SIG6 w0.254: v1(56.14,46.18) 56.9,45.42 57.16,45.42 57.73,45.99 58.08,45.99 60.97,48.87 66.43,48.87 67.99,50.43 68.4,50.43 69.68,51.71 69.68,51.97 71.84,54.13 v1(71.84,55.2)
  BOTTOM w0.152: 53.8,99.38 53.91,99.48 53.91,100.23 53.6,100.54 53.08,100.54 53.08,99.38 53.8,99.38
  BOTTOM w0.178: U6.14 24.7,95.64 24.58,95.52
  BOTTOM w0.203: U87.11 221.28,99.35 v1(221.62,99.01) ; R345.2 92.96,36.99 90.23,36.99 90.09,37.12 v1(90.09,37.54) ; U88.11 212.85,99.35 213.19,99.01 C1021.2
  BOTTOM w0.254: R495.1 33.6,105.74 37.09,105.74 37.85,104.98 37.85,103.58 38.23,103.2 38.23,102.69 ; v3(202.83,39.58) 202.83,34.5 201.99,33.66 197.6,33.66 197.37,33.89 R704.1 ; v1(39.38,107.14) 39.57,107.14 R82.2 ; 194.03,94.63 194.06,94.6 R717.1 ; 12.45,63.32 12.45,61.04 12.83,60.66 14.1,60.66 14.93,59.83 R496.1 ; 12.45,63.32 12.45,64.09 ; 12.45,63.32 12.46,63.33 U58.7 ; 53.03,99.33 53.08,99.38 ; 66.71,67.39 v3(66.74,67.42) 66.74,66.18 66.43,65.86 62.62,65.86 61.43,67.05 61.43,70.78 62.05,71.39 R741.1 ; R503.1 v1(26.17,108.73) ; R399.2 R780.2 ; 38.23,102.69 38.23,101.81 ; 38.23,102.69 38.23,102.69 U57.7 ; C451.2 63.7,78.76 64.14,79.2 64.14,81.55 R340.2 ; R326.1 53.74,11.31 v1(53.6,11.45) ; v1(30.92,14.93) R6892.2 v1(32.95,14.93) ; v1(24.03,94.78) 24.03,94.97 24.58,95.52 ; R433.2 27.44,88.09 27.12,87.77 R81.2 ; 204.35,19.45 R208.2 ; R125.2 52.97,103.46 53.22,103.2 53.22,102.16 52.73,101.67 52.73,100.89 53.08,100.54 ; R87.1 v1(203.21,102.82) ; v3(28.71,98.12) 28.71,102.06 29.6,102.95 R494.1 ; v1(49.91,9.86) R331.1 ; v1(207.14,33.86) R663.1 ; 141.71,21.8 R718.1
  BOTTOM w0.305: R433.2 R432.2 27.88,86.41 27.18,85.7 v1(27.18,85.5) ; v1(37.79,78.69) R80.2 R434.2 ; R399.2 39.19,107.14 v1(39.38,107.14) ; R206.2 204.71,24.15 205.37,23.49 v1(205.37,23.45) 205.37,22.08 204.16,20.87 204.16,19.64 204.35,19.45 ; R641.2 177.3,43
  BOTTOM w0.381: U33.19 162.37,95.84 C460.2 162.38,95.33 162.61,95.1 167.16,95.1 168.28,96.22 172.6,96.22 172.98,96.6 174.63,96.6 174.89,96.85 178.06,96.85 180.96,99.75 183.67,99.75 185.43,98 v1(189.43,98) ; 53.03,99.33 52.97,99.27 R840.2 R839.2 ; v3(66.74,67.42) 65.38,67.42 R609.2 ; U45.8 37.38,83.62 C488.2 ; v1(19.95,106.7) 19.95,104.63 19.69,104.37 19.69,103.2 ; C1021.2 v1(213.94,98.38)
  BOTTOM w0.508: v3(41.66,101.17) 43.31,101.17 43.95,100.54 48.14,100.54 49,101.4 50.2,101.4 50.71,100.89 52.73,100.89
  BOTTOM w0.635: D26.1 v3(224.35,62.18)
  vias: v1(11.82,72.85) v1(12.33,70.15) v1(18.1,108.66) v1(18.18,78.65) v1(18.18,76.65) v1(18.18,74.65) v1(18.93,107.58) v1(20.14,109.55) v1(20.96,107.58) v1(22.18,78.65) v1(22.18,77.65) v1(22.18,76.65) v1(22.68,106.59) v1(22.79,66.95) v1(24.18,84.65) v1(24.18,67.65) v1(26.18,80.65) v1(26.18,71.65) v1(27.18,71.65) v1(28.18,84.61) v1(28.18,71.65) v1(29.18,71.65) v1(30.49,105.68) v1(31.18,77.65) v1(31.18,76.65) v1(32.18,77.65) v1(32.7,24.16) v1(35.05,81.65) v1(35.18,82.65) v1(35.82,73.1) v1(35.92,79.65) v1(35.92,77.65) v1(37.09,83.45) v1(37.79,94.31) v1(47.63,93.41) v1(56.2,49.23) v1(56.52,11.45) v1(196.35,32.02) v1(201.16,80.47) v1(204.35,35.32) v1(206,83.39) v1(206,82.63) v1(213.24,105.55) v1(214.89,101.17) v1(222.87,83.81) v1(222.87,81.78) v1(222.85,61.6) v1(222.85,58.55) v1(222.85,56.52) v1(224.94,60.58) v1(228.11,105.49) v1(231.71,42.45) v1(231.72,40.46) v1(233.05,23.13) v1(233.05,16.02) v2(14.36,101.55) v2(14.36,100.92) v2(15.25,101.55) v2(15.25,100.92) v2(173.88,39.58) v2(173.87,38.31) v2(173.87,37.04) v2(175.14,38.31) v2(175.14,37.04) v2(175.15,39.58) v2(176.41,39.58) v2(176.41,38.31) v2(176.41,37.04) v2(177.68,39.58) v2(177.68,38.31) v2(177.68,37.04) v2(178.95,39.58) v2(178.95,38.31) v2(184.03,39.58) v2(184.03,38.31) v2(184.04,37.16) v2(185.3,39.58) v2(185.3,38.31) v2(185.3,37.04) v2(186.57,39.58) v2(186.57,38.31) v2(186.57,37.04) v2(187.84,39.58) v2(187.84,38.31) v2(187.84,37.04) v3(11.72,66.94) v3(11.72,66.18) v3(12.48,66.94) v3(12.48,66.18) v3(28.71,97.36) v3(33.15,33.73) v3(33.15,32.84) v3(38.11,97.11) v3(39.38,101.17) v3(39.38,99.77) v3(39.38,98.5) v3(39.38,97.11) v3(40.52,101.17) v3(40.52,99.77) v3(40.52,98.5) v3(40.52,97.11) v3(41.66,99.77) v3(41.66,98.5) v3(41.66,97.11) v3(42.17,34.88) v3(62.24,14.81) v3(63,14.81) v3(67.51,67.42) v3(137.68,22.18) v3(138.69,22.18) v3(139.71,22.18) v3(140.98,22.18) v3(148.09,19.51) v3(148.34,18.11) v3(169.68,37.68) v3(169.68,37.05) v3(169.68,36.41) v3(170.07,42.5) v3(170.07,40.97) v3(170.07,39.58) v3(170.31,37.68) v3(170.31,37.05) v3(170.31,36.41) v3(170.95,37.68) v3(170.95,37.05) v3(170.95,36.41) v3(171.33,42.5) v3(171.33,40.97) v3(171.33,39.58) v3(172.22,37.68) v3(172.22,37.05) v3(172.22,36.41) v3(172.6,42.5) v3(172.6,40.97) v3(172.6,39.58) v3(172.85,37.68) v3(172.85,37.05) v3(172.85,36.41) v3(173.88,42.5) v3(173.88,40.97) v3(175.15,42.5) v3(175.15,40.97) v3(176.41,42.5) v3(176.41,40.97) v3(177.68,42.5) v3(177.68,40.97) v3(178.95,42.5) v3(178.95,40.97) v3(180.6,42.5) v3(180.6,40.97) v3(182.51,42.5) v3(182.51,40.97) v3(184.03,42.5) v3(184.03,40.97) v3(185.3,42.5) v3(185.3,40.97) v3(186.57,42.5) v3(186.57,40.97) v3(187.84,42.5) v3(187.84,40.97) v3(189.49,42.5) v3(189.49,40.97) v3(189.49,39.58) v3(190.13,37.81) v3(190.13,37.18) v3(190.13,36.54) v3(190.76,42.5) v3(190.76,40.97) v3(190.76,39.58) v3(190.76,37.81) v3(190.76,37.18) v3(190.76,36.54) v3(192.03,42.5) v3(192.03,40.97) v3(192.03,39.58) v3(192.03,37.81) v3(192.03,37.18) v3(192.03,36.54) v3(192.67,37.81) v3(192.67,37.18) v3(192.67,36.54) v3(193.27,95.39) v3(193.27,94.63) v3(193.3,42.5) v3(193.3,40.97) v3(193.3,39.58) v3(193.3,37.81) v3(193.3,37.18) v3(193.3,36.54) v3(194.03,95.39) v3(194.22,99.57) v3(194.22,98.81) v3(194.98,99.57) v3(194.98,98.81) v3(201.81,40.59) v3(201.81,39.58) v3(202.83,40.59) v3(211.43,109.18) v3(212.7,109.18) v3(213.97,109.18) v3(214.64,46.05) v3(214.64,45.29) v3(214.64,44.53) v3(215.15,109.17) v3(215.4,46.05) v3(215.4,45.29) v3(215.4,44.53) v3(216.16,46.05) v3(216.16,45.29) v3(216.16,44.53) v3(216.92,46.05) v3(216.92,45.29) v3(216.92,44.53) v3(230.98,109.69) v3(230.98,108.42) v3(232.25,109.69) v3(232.25,108.42) v3(233.52,109.69) v3(233.52,108.42) v3(234.79,109.69) v3(234.79,108.42) v3(236.06,109.69) v3(236.06,108.42)
3V3_STBY_PG: length 294
  TOP w0.381: U95.G8 v2(178.95,31.96) ; U95.G9 v2(177.68,31.96)
  L03_SIG1 w0.081: v1(27.06,107.9) 27.46,108.31 27.46,109.02 28.73,110.29 47.45,110.29 49.08,108.66 49.08,104.42 49.54,103.96 58.3,103.96 59.95,105.62 60.71,105.62 62.42,107.32 62.42,107.83 63.25,108.66 73.11,108.66 74.28,109.83 91.42,109.83 91.7,110.11 131.73,110.11 131.84,110.22 144.5,110.22 144.89,109.83 172.7,109.83 174.71,107.83 174.71,107.1 174.38,106.77 174.38,102.39 174.65,102.12 174.65,99.48 174.21,99.03 174.21,95.86 171.52,93.17 163.71,93.17 161.93,91.39 161.93,90.5 v1(161.55,90.12)
  L05_SIG2 w0.081: v1(18.1,109.55) 18.42,109.55 19.44,108.54 23.5,108.54 24.14,107.9 v1(27.06,107.9) ; v2(177.68,31.96) v2(178.95,31.96)
  L16_SIG6 w0.081: v1(161.55,90.12) 161.3,89.87 161.3,85.04 159.77,83.52 159.77,76.89 160.41,76.25 160.41,71.71 159.65,70.94 159.65,62.44 160.41,61.67 160.41,60.02 159.27,58.88 159.27,51.89 158.12,50.75 158.12,45.8 159.01,44.91 159.01,37.06 159.75,36.32 159.75,32.69 159.14,32.08 159.14,23.95 159.77,23.32 164.52,23.32 164.73,23.12 168.59,23.12 169.81,24.34 169.81,28.91 173.36,32.46 176.79,32.46 177.3,31.96 v2(177.68,31.96)
3V3_SYS: length 64.8
  TOP w0.254: U81.7 63.64,59.65 63.78,59.51 64.52,59.51 ; R402.2 v1(52.78,48.21)
  TOP w0.305: R400.2 R401.2
  L05_SIG2 w0.508: 60.74,105.39 v1(62.54,105.39)
  BOTTOM w0.203: 6.97,25.14 U89.11 ; 6.97,31.36 U90.11
  BOTTOM w0.254: R784.2 40.58,38.88 ; R404.2 v1(239.72,104.47) ; R789.2 25.85,60.85 v1(26.17,60.53) ; R378.2 R379.2 64.14,96.85 63.76,97.23 63.76,98.82 64.02,99.08 ; R744.1 61.69,62.84 61.69,59.74 61.81,59.62 v3(66.99,59.62) ; R440.2 R439.2 34.87,31.77 35.52,31.12 35.75,31.12 C304.2 ; C324.2 26.29,42.42 26.14,42.27 26.14,41.9 R220.2 ; R218.2 v1(45.5,21.44) ; R211.2 35.74,29.83 ; R368.2 192.67,62.18 v1(193.17,62.69) 193.68,62.18 R369.2 ; R6894.2 39.5,38.94
  BOTTOM w0.255: R785.2 R784.2 ; R218.2 R217.2
  BOTTOM w0.305: v1(6.1,25.48) 6.62,25.48 6.97,25.14 ; v1(62.54,105.39) 62.54,104.42 64.27,102.69 64.27,102.01 64.02,101.76 64.02,100.79 64.35,100.46 64.35,99.9 64.02,99.57 64.02,99.08 C471.2 64.59,98.5 R380.1 ; v1(6.1,31.7) 6.62,31.7 6.97,31.36
  BOTTOM w0.381: U31.5 51.51,13.29 C449.1 v1(51.63,14.05) ; v1(28.39,25.35) 28.35,25.39 U46.8 ; U28.5 58.49,13.29 C444.1 58.62,15.38 v3(59.06,15.83) ; v1(28.96,64.79) C344.1 29.85,64.79 30.21,65.15 U22.14 ; v3(66.99,59.62) v3(67.62,59.62)
  BOTTOM w0.508: FB26.2 58.3,56.09 57.54,55.32 57.54,54.69
  vias: v1(27.31,35.58) v1(27.95,107.84) v1(44.52,22.43) v1(53.16,45.16) v1(217.24,105.46) v1(231.85,107.27) v1(235.15,107.27) v1(237.69,107.27) v2(26.69,43.58) v2(26.69,42.44) v2(27.71,43.58) v2(27.71,42.44) v2(35.72,109.55) v2(35.72,108.16) v2(35.72,106.89) v2(35.82,30.33) v2(35.82,29.19) v2(36.84,30.33) v2(36.84,29.19) v2(50.81,54.69) v2(56.14,57.86) v2(56.78,57.86) v3(2.22,65.31) v3(2.22,64.04) v3(2.29,59.9) v3(2.93,60.28) v3(23.5,18.87) v3(24.52,18.87) v3(25.53,18.87) v3(26.42,18.87) v3(27.44,37.67) v3(28.33,37.67) v3(29.09,37.67) v3(29.85,37.67) v3(39.38,106) v3(39.38,104.85) v3(39.38,103.58) v3(39.38,102.57) v3(40.52,106) v3(40.52,104.85) v3(40.52,103.58) v3(40.52,102.57) v3(41.54,106) v3(41.54,104.85) v3(41.54,103.58) v3(41.54,102.57) v3(59.82,15.83) v3(67.32,29.8) v3(67.32,29.16) v3(67.95,29.29) v3(135.77,10.11) v3(136.53,10.11) v3(235.72,56.09)
3V3_SYS_PG: length 2.7
  BOTTOM w0.149: R527.1 R525.2 22.34,109.55 U60.1
3V3_USBPHY: length 11.2
  TOP w0.254: v2(12.45,91.29) U49.11 ; U49.43 v2(20.35,97.61) ; v1(14.49,97.74) 14.35,97.61 U49.55 ; U49.27 v2(19.85,88.34) ; U49.32 v2(21.8,91.29) ; v1(12.48,93.55) 12.74,93.29 U49.7 ; U49.3 v1(12.53,95.29) ; U49.17 v2(14.85,88.34)
  BOTTOM w0.254: R452.2 R451.2 12.71,89.23 v1(12.45,88.98) ; v1(8.47,97.28) 8.55,97.36 C490.2
  BOTTOM w0.381: C499.2 12.57,95.33 v1(12.53,95.29) ; v1(12.48,93.55) 12.61,93.42 C498.2 ; v2(21.8,91.29) C503.2
  vias: v1(22.61,95.8) v2(12.33,99.65) v2(12.33,98.76) v2(12.96,99.65) v2(12.96,98.76)
5V0: length 10.5
  TOP w0.381: v3(191.4,46.18) 190.13,46.18 189.87,46.43 C1202.1 R6877.1
  vias: v1(39.38,107.97) v2(160.54,83.14) v2(160.54,68.66) v2(160.54,54.18) v2(160.54,39.7) v2(160.54,25.1) v2(161.3,83.14) v2(161.3,68.66) v2(161.3,54.18) v2(161.3,39.7) v2(161.3,25.1) v3(191.4,49.99) v3(191.4,48.72) v3(191.4,47.45) v3(192.67,49.99) v3(192.67,48.72) v3(192.67,47.45) v3(192.67,46.18) v3(193.05,54.69) v3(193.05,53.42) v3(193.05,52.02) v3(194.32,53.42)
5V0_AGND: length 0.9
  TOP w0.381: U94.B4 v1(198.13,57.23)
  vias: v1(192.67,57.23) v1(193.05,59.45) v1(194.32,59.45) v1(196.86,59.44) v1(198.13,59.44)
5V0_PG: length 42.1
  TOP w0.254: U94.C2 v1(194.32,55.96)
  TOP w0.381: 178.32,32.59 v2(177.68,33.23) ; 183.4,32.59 v2(184.03,33.23)
  L05_SIG2 w0.081: v2(184.03,33.23) 183.32,33.94 183.32,45.09 183.83,45.6 185.73,45.6 187.84,47.7 187.84,52.66 190.45,55.27 193.03,55.27 193.72,55.96 v1(194.32,55.96)
  L16_SIG6 w0.081: v2(177.68,33.23) 178.06,33.23 178.7,32.59 183.4,32.59 v2(184.03,33.23)
  BOTTOM w0.254: R864.1 R863.2 v1(194.32,55.96)
12V_AUX: length 184.3
  TOP w0.381: J11.3 241.44,83.12 ; J11.3 241.93,81.79 ; J11.3 240.11,79.96 ; J11.3 241.44,80.45 ; J11.3 240.11,83.61 ; J11.3 238.77,80.45 ; J11.3 238.77,83.12 ; J11.3 238.28,81.79 ; J11.2 241.44,87.32 ; J11.2 240.11,84.16 ; J11.2 238.28,85.99 ; J11.2 238.77,87.32 ; J11.2 241.93,85.99 ; J11.2 238.77,84.65 ; J11.2 240.11,87.81 ; J11.2 241.44,84.65 ; J11.1 241.93,92.01 ; J11.1 238.28,88.36 ; J11.1 240.11,88.36 ; J11.1 241.93,90.19 ; J11.1 240.11,92.01 ; J11.1 241.93,88.36 ; J11.1 238.28,92.01 ; J11.1 238.28,90.19
  L03_SIG1 w0.508: 238.77,80.45 J11.3 ; J11.3 241.44,80.45 ; J11.3 238.28,81.79 ; J11.3 241.93,81.79 ; J11.3 240.11,79.96 ; J11.3 240.11,83.61 ; J11.3 241.44,83.12 ; J11.3 238.77,83.12 ; 238.28,90.19 J11.1 ; J11.1 241.93,90.19 ; J11.1 238.77,88.85 ; J11.1 238.77,91.52 ; J11.1 241.44,91.52 ; J11.1 240.11,88.36 ; J11.1 240.11,92.01 ; J11.1 241.44,88.85 ; J11.2 240.11,87.81 ; J11.2 241.44,84.65 ; J11.2 238.77,84.65 ; J11.2 238.28,85.99 ; J11.2 241.44,87.32 ; J11.2 238.77,87.32 ; J11.2 241.93,85.99 ; J11.2 240.11,84.16
  L16_SIG6 w0.508: 238.77,87.32 J11.2 ; J11.2 241.44,84.65 ; J11.2 240.11,84.16 ; J11.2 241.93,85.99 ; J11.2 238.77,84.65 ; J11.2 241.44,87.32 ; J11.2 238.28,85.99 ; J11.2 240.11,87.81 ; 238.77,88.85 J11.1 ; J11.1 241.93,90.19 ; J11.1 238.77,91.52 ; J11.1 238.28,90.19 ; J11.1 241.44,91.52 ; J11.1 240.11,88.36 ; J11.1 240.11,92.01 ; J11.1 241.44,88.85 ; 238.77,80.45 J11.3 ; J11.3 241.44,83.12 ; J11.3 238.28,81.79 ; J11.3 240.11,79.96 ; J11.3 241.44,80.45 ; J11.3 241.93,81.79 ; J11.3 238.77,83.12 ; J11.3 240.11,83.61
  BOTTOM w0.254: v1(244.8,93.42) 244,93.42
  BOTTOM w0.381: 240.11,84.16 J11.2 ; J11.2 238.28,85.99 ; J11.2 238.77,84.65 ; J11.2 241.44,87.32 ; J11.2 240.11,87.81 ; J11.2 241.44,84.65 ; J11.2 241.93,85.99 ; J11.2 238.77,87.32 ; 238.28,81.79 J11.3 ; J11.3 238.77,83.12 ; J11.3 241.44,83.12 ; J11.3 241.44,80.45 ; J11.3 238.77,80.45 ; J11.3 241.93,81.79 ; J11.3 240.11,79.96 ; J11.3 240.11,83.61 ; J11.1 241.93,90.19 ; J11.1 241.93,88.36 ; J11.1 238.28,88.36 ; J11.1 241.93,92.01 ; J11.1 240.11,88.36 ; J11.1 240.11,92.01 ; J11.1 238.28,90.19 ; J11.1 238.28,92.01
  vias: v1(228.03,82.52) v1(228.03,82.01) v1(228.03,81.5) v1(228.03,80.99) v1(229.05,82.52) v1(229.05,82.01) v1(229.05,81.5) v1(229.05,80.99) v1(230.06,82.52) v1(230.06,82.01) v1(230.06,81.5) v1(230.06,80.99) v3(227.93,89.26) v3(227.97,92.12) v3(227.97,90.85) v3(227.97,87.67) v3(227.97,86.4) v3(227.97,84.88) v3(227.97,83.61) v3(229.24,96.06) v3(229.24,94.79) v3(229.24,93.52) v3(229.24,92.12) v3(229.24,90.85) v3(229.24,89.32) v3(229.24,87.67) v3(229.24,86.4) v3(229.24,84.88) v3(229.24,83.61) v3(230.51,96.06) v3(230.51,94.79) v3(230.51,93.52) v3(235.59,96.69) v3(235.59,94.79) v3(237.37,96.69) v3(237.37,94.79) v5(230.51,92.15) v5(230.51,90.85) v5(230.51,89.32) v5(230.51,87.67) v5(230.51,86.4) v5(230.51,85.01) v5(230.51,83.74) v5(232.16,96.73) v5(232.16,94.82) v5(232.16,92.79) v5(232.16,90.85) v5(232.16,89.32) v5(232.16,87.67) v5(232.16,86.4) v5(232.16,85.01) v5(232.16,83.74) v5(233.94,96.73) v5(233.94,94.82) v5(233.94,92.79) v5(235.59,92.79) v5(237.37,92.79) v5(239.02,96.73) v5(239.02,94.82) v5(239.02,92.79) v5(240.55,92.79) v5(240.8,96.73) v5(240.8,94.82) v5(242.24,92.72) v5(242.37,90.82) v5(242.37,89.29) v5(242.37,88.02) v5(242.37,86.75) v5(242.37,85.23) v5(242.37,83.96) v5(242.37,82.69) v5(243.64,92.72) v5(243.64,90.82) v5(243.64,89.29) v5(243.64,88.02) v5(243.64,86.75) v5(243.64,85.23) v5(243.64,83.96) v5(243.64,82.69)
12V_AUX_IN: length 30.1
  TOP w0.381: U53.2 219.84,79.48 220.13,79.78 220.69,79.78
  L05_SIG2 w0.508: 237.5,16.8 J2.2 ; J2.2 236.56,17.73 ; J2.2 238.43,17.73
  L09_PWR1 w0.508: J2.2 238.43,17.73 ; J2.2 236.56,17.73 ; J2.2 237.5,16.8
  L10_PWR2 w0.508: 236.56,17.73 J2.2 ; J2.2 237.5,16.8 ; J2.2 238.43,17.73
  BOTTOM w0.305: R6839.2 200.79,53.61 200.79,46.43 200.54,46.18 v3(199.78,46.18) ; 218.7,73.74 218.7,77.68 218.14,78.23 214.4,78.23 R468.1
  vias: v1(180.56,61.62) v1(192.67,55.96) v1(195.59,59.44) v1(220.69,82.44) v1(220.71,81.55) v1(220.71,80.53) v1(228.54,79.98) v1(228.54,79.47) v1(228.54,78.96) v1(228.54,78.45) v1(229.56,79.98) v1(229.56,79.47) v1(229.56,78.96) v1(229.56,78.45) v1(230.57,79.98) v1(230.57,79.47) v1(230.57,78.96) v1(230.57,78.45) v2(157.23,87.58) v2(157.23,86.95) v2(157.23,86.31) v2(157.23,85.68) v2(157.23,84.6) v2(157.23,83.96) v2(157.23,82.88) v2(157.23,82.25) v2(157.23,81.61) v2(157.23,80.98) v2(157.23,73.1) v2(157.23,72.47) v2(157.23,71.83) v2(157.23,71.2) v2(157.23,70.12) v2(157.23,69.48) v2(157.23,68.4) v2(157.23,67.77) v2(157.23,67.13) v2(157.23,66.5) v2(157.23,58.63) v2(157.23,57.99) v2(157.23,57.36) v2(157.23,56.72) v2(157.23,55.64) v2(157.23,55.01) v2(157.23,53.93) v2(157.23,53.29) v2(157.23,52.66) v2(157.23,52.02) v2(157.23,44.15) v2(157.23,43.51) v2(157.23,42.88) v2(157.23,42.24) v2(157.23,41.16) v2(157.23,40.53) v2(157.23,39.45) v2(157.23,38.81) v2(157.23,38.18) v2(157.23,37.54) v2(157.87,87.58) v2(157.87,86.95) v2(157.87,86.31) v2(157.87,85.68) v2(157.87,82.88) v2(157.87,82.25) v2(157.87,81.61) v2(157.87,80.98) v2(157.87,73.1) v2(157.87,72.47) v2(157.87,71.83) v2(157.87,71.2) v2(157.87,68.4) v2(157.87,67.77) v2(157.87,67.13) v2(157.87,66.5) v2(157.87,58.63) v2(157.87,57.99) v2(157.87,57.36) v2(157.87,56.72) v2(157.87,53.93) v2(157.87,53.29) v2(157.87,52.66) v2(157.87,52.02) v2(157.87,44.15) v2(157.87,43.51) v2(157.87,42.88) v2(157.87,42.24) v2(157.87,39.45) v2(157.87,38.81) v2(157.87,38.18) v2(157.87,37.54) v3(157.36,91.65) v3(157.36,90.76) v3(157.36,89.49) v3(157.36,79.07) v3(157.36,77.8) v3(157.36,76.41) v3(157.36,75.01) v3(157.36,64.59) v3(157.36,63.2) v3(157.36,61.93) v3(157.36,60.4) v3(157.36,50.12) v3(157.36,48.85) v3(157.36,47.45) v3(157.36,46.05) v3(157.36,35.66) v3(157.36,34.5) v3(158.88,91.65) v3(158.88,90.76) v3(158.88,89.36) v3(158.88,79.07) v3(158.88,77.8) v3(158.88,76.41) v3(158.88,75.01) v3(158.88,64.59) v3(158.88,63.2) v3(158.88,61.93) v3(158.88,60.4) v3(158.88,50.12) v3(158.88,48.85) v3(158.88,47.45) v3(158.88,35.66) v3(158.88,34.5) v3(160.88,91.01) v3(162.4,81.87) v3(162.4,80.47) v3(162.4,79.07) v3(162.4,77.8) v3(162.4,76.41) v3(162.4,67.39) v3(162.4,66.25) v3(162.4,63.32) v3(162.4,61.93) v3(162.4,52.91) v3(162.4,51.51) v3(162.4,50.12) v3(162.4,48.85) v3(162.4,47.45) v3(162.4,38.43) v3(162.4,37.04) v3(162.4,35.64) v3(163.71,91.26) v3(163.71,90.5) v3(163.8,83.26) v3(163.8,81.87) v3(163.8,80.47) v3(163.8,79.07) v3(163.8,77.8) v3(163.8,76.41) v3(163.8,68.79) v3(163.8,67.39) v3(163.8,66.25) v3(163.8,63.32) v3(163.8,61.93) v3(163.8,54.31) v3(163.8,52.91) v3(163.8,51.51) v3(163.8,50.12) v3(163.8,48.85) v3(163.8,47.45) v3(163.8,39.83) v3(163.8,38.43) v3(163.8,37.04) v3(163.8,35.64) v3(198.64,49.99) v3(198.64,48.72) v3(198.64,47.45) v3(198.64,46.18) v3(199.78,49.99) v3(199.78,48.72) v3(199.78,47.45) v3(208.67,95.33) v3(208.67,93.8) v3(210.19,95.33) v3(210.19,93.8) v3(211.59,95.33) v3(211.59,93.8) v3(219.84,72.72) v3(219.84,71.07) v3(219.84,69.42) v3(221.11,72.72) v3(221.11,71.07) v3(221.11,69.42) v3(222.38,72.72) v3(222.38,71.07) v3(222.38,69.42) v3(223.65,72.72) v3(223.65,71.07) v3(223.65,69.42) v3(237.75,60.91) v3(237.75,59.26) v3(237.75,57.61) v3(239.02,60.91) v3(239.02,59.26) v3(239.02,57.61) v5(225.01,72.63) v5(225.01,70.98) v5(225.01,69.33) v5(226.28,72.63) v5(226.28,70.98) v5(226.28,69.33) v5(227.46,74.37) v5(227.55,72.63) v5(227.55,70.98) v5(227.55,69.33) v5(229.07,76.18) v5(229.07,74.41) v5(229.07,72.63) v5(229.07,70.98) v5(229.07,69.33) v5(230.6,76.18) v5(230.6,74.41) v5(230.6,72.63) v5(230.6,70.98) v5(230.6,69.33) v5(232.12,79.74) v5(232.12,77.96) v5(232.12,76.18) v5(232.12,74.41) v5(232.12,72.63) v5(232.12,70.98) v5(232.12,69.33) v5(233.14,79.74) v5(233.14,77.96) v5(233.39,76.18) v5(233.39,74.41) v5(233.39,72.63) v5(233.39,70.98) v5(233.39,69.33)
12V_PCIE_HSC: length 15.3
  BOTTOM w0.225: 208.67,50.12 U52.2
  BOTTOM w0.254: 208.83,49.95 208.67,50.12 ; U51.3 217.69,51.82 217.47,51.61 217.47,48.38
  BOTTOM w0.381: 217.47,48.38 217.13,48.04 209.54,48.04 208.83,48.75 208.83,49.95
  vias: v1(223.97,45.94) v1(223.97,45.43) v1(223.97,44.92) v1(223.97,44.42) v1(224.98,45.94) v1(224.98,45.43) v1(224.98,44.92) v1(224.98,44.42) v1(226,45.94) v1(226,45.43) v1(226,44.92) v1(226,44.42) v3(222.66,54.05) v3(222.66,52.78) v3(222.66,51.51) v3(222.66,50.24) v3(223.93,54.05) v3(223.93,52.78) v3(223.93,51.51) v3(223.93,50.24) v3(225.33,54.05) v3(225.33,52.78) v3(225.33,51.51) v3(225.33,50.24) v3(226.6,54.05) v3(226.6,52.78) v3(226.6,51.51) v3(226.6,50.24) v5(221.2,55.36) v5(221.24,54.05) v5(221.24,52.78) v5(221.24,51.51) v5(221.24,50.24) v5(221.24,48.85) v5(221.24,47.45) v5(221.24,46.05) v5(221.24,44.66) v5(222.64,55.32) v5(222.64,48.85) v5(222.64,47.45) v5(222.64,46.05) v5(222.64,44.66) v5(223.99,55.36) v5(224.04,48.85) v5(224.04,47.45) v5(225.31,48.85) v5(225.31,47.45) v5(225.52,55.36)
12V_PCIE_IN: length 8
  TOP w0.381: 212.24,78.83 U53.8 ; U93.B9 v1(52.7,90.31) ; U96.B9 v1(198.06,75.4) ; U96.B10 v1(198.86,74.6) ; U93.B10 v1(53.5,91.11)
  BOTTOM w0.225: 209.84,53.57 U52.6 ; 209.84,50.72 U52.1
  BOTTOM w0.381: 178.32,28.65 180.73,28.65 R1005.1
  vias: v1(46.3,85.51) v1(46.3,84.71) v1(46.3,83.91) v1(46.3,83.11) v1(47.1,85.51) v1(47.1,84.71) v1(47.1,83.91) v1(47.1,83.11) v1(48.01,105.74) v1(48.01,105.11) v1(48.04,103.96) v1(48.01,103.2) v1(48.04,96.22) v1(48.39,98.38) v1(48.39,97.74) v1(48.78,96.22) v1(51.1,86.31) v1(51.1,85.51) v1(51.1,84.71) v1(51.1,83.91) v1(51.1,83.11) v1(190.86,81.8) v1(190.86,81) v1(190.86,77) v1(191.66,81.8) v1(191.66,81) v1(191.66,77) v1(192.46,81.8) v1(192.46,81) v1(192.46,77) v1(193.26,81.8) v1(193.26,81) v1(193.26,77) v1(194.06,77) v1(201.81,22.3) v1(202.06,22.68) v1(202.32,22.3) v1(217.43,30.05) v1(218.32,30.05) v1(218.32,29.03) v2(157.23,29.54) v2(157.23,28.91) v2(157.23,28.27) v2(157.23,27.64) v2(157.23,26.56) v2(157.23,25.92) v2(157.23,24.84) v2(157.23,24.21) v2(157.23,23.57) v2(157.23,22.94) v2(157.87,29.54) v2(157.87,28.91) v2(157.87,28.27) v2(157.87,27.64) v2(157.87,24.84) v2(157.87,24.21) v2(157.87,23.57) v2(157.87,22.94) v2(175.39,28.15) v2(175.39,26.88) v2(175.39,25.61) v2(175.39,24.34) v2(176.41,28.15) v2(176.41,26.88) v2(176.41,25.61) v2(176.41,24.34) v2(177.68,28.15) v2(177.68,26.88) v2(177.68,25.61) v2(177.68,24.34) v2(178.95,25.61) v2(178.95,24.34) v2(180.22,25.61) v2(180.22,24.34) v2(181.49,25.61) v2(181.49,24.34) v2(182.76,25.61) v2(182.76,24.34) v2(184.03,25.61) v2(184.03,24.34) v2(185.3,28.15) v2(185.3,26.88) v2(185.3,25.61) v2(185.3,24.34) v2(186.57,28.15) v2(186.57,26.88) v2(186.57,25.61) v2(186.57,24.34) v2(187.59,28.15) v2(187.59,26.88) v2(187.59,25.61) v2(187.59,24.34) v3(41.05,84.53) v3(41.05,83.14) v3(41.82,84.53) v3(41.82,83.14) v3(42.68,84.53) v3(42.68,83.14) v3(43.57,84.53) v3(43.57,83.14) v3(59.06,87.71) v3(59.06,86.95) v3(59.06,86.18) v3(59.82,87.71) v3(59.82,86.95) v3(59.82,86.18) v3(60.59,87.71) v3(60.59,86.95) v3(60.59,86.18) v3(157.36,32.84) v3(157.36,31.45) v3(157.36,20.93) v3(157.36,19.51) v3(157.36,18.11) v3(158.88,32.84) v3(158.88,20.93) v3(158.88,19.51) v3(158.88,18.11) v3(160.88,32.84) v3(162.4,34.37) v3(162.4,32.97) v3(162.4,22.43) v3(162.4,19.76) v3(162.4,18.24) v3(163.8,34.37) v3(163.8,32.97) v3(163.8,21.03) v3(163.8,19.76) v3(163.8,18.24) v3(175.53,22.81) v3(175.53,21.54) v3(175.53,20.14) v3(175.53,19.51) v3(176.17,22.81) v3(176.17,21.54) v3(176.17,20.14) v3(176.17,19.51) v3(177.68,22.81) v3(177.68,21.54) v3(177.68,20.14) v3(178.95,22.81) v3(178.95,21.54) v3(178.95,20.14) v3(180.22,22.81) v3(180.22,21.54) v3(180.22,20.14) v3(181.49,22.81) v3(181.49,21.54) v3(181.49,20.14) v3(182.76,22.81) v3(182.76,21.54) v3(182.76,20.14) v3(184.03,22.81) v3(184.03,21.54) v3(184.03,20.14) v3(185.3,22.81) v3(185.3,21.54) v3(185.3,20.14) v3(186.2,22.81) v3(186.2,21.54) v3(186.2,20.14) v3(186.2,19.51) v3(186.84,22.81) v3(186.84,21.54) v3(186.84,20.14) v3(186.84,19.51) v3(187.47,22.81) v3(187.47,21.54) v3(187.47,20.14) v3(187.47,19.51) v3(190.89,87.33) v3(190.89,86.44) v3(190.89,85.55) v3(190.89,84.53) v3(190.89,83.64) v3(190.89,82.76) v3(192.29,87.33) v3(192.29,86.44) v3(192.29,85.55) v3(192.29,84.53) v3(192.29,83.64) v3(192.29,82.76) v3(193.81,22.05) v3(193.81,20.65) v3(194.7,71.07) v3(194.7,69.29) v3(194.7,68.4) v3(194.7,67.52) v3(194.7,66.63) v3(195.33,22.05) v3(195.33,20.65) v3(195.71,71.07) v3(195.71,69.29) v3(195.71,68.4) v3(195.71,67.52) v3(195.71,66.63) v3(196.73,69.29) v3(196.73,68.4) v3(196.73,67.52) v3(196.73,66.63) v3(211.21,77.29) v3(211.21,75.99) v3(214,77.29) v3(214,75.9) v3(214,74.25) v3(214,72.6) v3(214.13,53.32) v3(214.13,52.05) v3(214.13,50.52) v3(215.27,77.29) v3(215.27,75.9) v3(215.27,74.25) v3(215.27,72.6) v3(215.53,53.32) v3(215.53,52.05) v3(215.53,50.52) v3(216.54,77.29) v3(216.54,75.9) v3(216.54,74.25) v3(216.54,72.6) v3(216.8,53.32) v3(216.8,52.05) v3(216.8,50.52) v3(217.81,77.29) v3(217.81,75.9) v3(217.81,74.25) v3(217.81,72.6) v5(205.24,77.29) v5(205.24,75.9) v5(205.24,74.25) v5(205.24,72.6) v5(206.64,77.29) v5(206.64,75.9) v5(206.64,74.25) v5(206.64,72.6) v5(208.16,77.29) v5(208.16,75.9) v5(208.16,74.25) v5(208.16,72.6) v5(209.68,77.29) v5(209.68,75.9) v5(209.68,74.25) v5(209.68,72.6) v5(211.21,74.25) v5(211.21,72.6) v5(211.3,54.65) v5(211.34,53.42) v5(211.34,52.02) v5(211.34,50.62) v5(211.3,49.06) v5(212.73,77.29) v5(212.73,75.9) v5(212.73,74.25) v5(212.73,72.6) v5(212.7,55.92) v5(212.7,54.65) v5(212.73,53.42) v5(212.73,52.02) v5(212.73,50.62) v5(212.7,49.06) v5(214,71.2) v5(214.1,55.92) v5(214.1,54.65) v5(214.1,49.06) v5(215.27,71.2) v5(215.53,57.23) v5(215.49,55.92) v5(215.49,54.65) v5(215.49,49.06) v5(216.54,71.2) v5(216.71,49.06) v5(216.76,55.92) v5(216.76,54.65) v5(217.81,71.2)
GND: length 377
  TOP w0.229: U62.27 159.38,39.85 159.9,39.32 ; 159.9,53.8 159.38,54.32 U63.27 ; U65.31 159.39,85.28 ; U64.31 159.39,70.8 ; U66.27 159.38,25.24 159.9,24.72 ; 159.9,68.28 159.38,68.8 U64.27 ; U65.27 159.38,83.28 159.9,82.76 ; U62.31 159.39,41.85 ; U63.31 159.39,56.32 ; U66.31 159.39,27.24
  TOP w0.253: v1(14.69,90.63) 14.53,90.79 U49.12 ; U49.41 19.9,95.79 19.64,95.53 v1(19.64,95.33) ; U49.14 v2(12.45,89.79) ; v1(11.77,93.8) 11.77,93.37 11.56,93.17 C493.2 v1(10.29,93.17) v1(9.02,93.17) 8.78,93.41 Y2.4 8.13,94.07 8.01,94.19 v1(8.01,94.57) v1(8.01,96.29) v1(9.93,96.29) Y2.2 10.31,95.9 C494.2 11.63,95.9 11.77,95.76 v1(11.77,95.25) ; U49.53 v1(15.35,97.72) ; U49.28 v2(20.78,89.14) ; U49.56 13.85,97.11 v1(13.22,97.74)
  TOP w0.254: R261.1 v1(56.2,48.21) ; v1(227.48,40.72) v1(227.48,41.18) U50.13 ; v1(19.51,91.01) 19.35,90.85 U49.26 ; U36.1 194.94,64.96 195.59,65.61 v1(195.71,65.61) ; v1(94.5,34.57) 94.24,34.57 94.08,34.74 EU2.8 ; U49.6 14.32,93.79 v1(14.69,93.42) ; U54.13 v1(227.06,83.18) v1(227.06,83.64) ; U77.4 190.39,103.32 ; U49.10 14.33,91.79 v1(14.69,92.15) ; v1(75.17,11) 75.42,11.25 75.42,11.57 R15.2 ; R18.2 127.71,10.56 v1(128.15,11) ; R23.2 123.71,10.56 v1(124.15,11) ; EU1.8 65.3,83.03 v1(65.46,83.19) ; R259.1 R260.1
  TOP w0.255: 190.39,103.32 190.13,103.58 v1(189.87,103.58)
  TOP w0.279: v1(45.62,52.35) v1(45.62,53.95) v1(45.62,54.75) v1(45.62,55.55) ; v1(45.62,45.15) 45.62,50.44
  TOP w0.305: v1(160.54,41.99) 160.39,41.85 159.39,41.85 ; 159.39,56.32 160.39,56.32 v1(160.54,56.47) ; 159.39,85.28 160.39,85.28 v1(160.54,85.42) ; 159.39,70.8 160.39,70.8 v1(160.54,70.94) ; 159.39,27.24 160.39,27.24 v1(160.54,27.38) ; v1(189.87,103.58) v1(189.36,103.58)
  TOP w0.33: v1(10.63,83.63) J9.B4 v1(8.47,83.63) ; v1(5.52,69.23) J9.A28 v1(7.68,69.23) ; v1(7.68,76.43) J9.A16 v1(5.12,76.43) ; v1(8.47,71.03) J9.B25 v1(10.63,71.03) ; v1(7.68,65.63) J9.A34 ; v1(8.47,67.43) J9.B31 v1(10.63,67.43) ; v1(10.63,81.83) J9.B7 v1(8.47,81.83) ; v1(8.47,74.63) J9.B19 v1(10.63,74.63) ; v1(5.72,71.03) J9.A25 v1(7.68,71.03) ; v1(8.47,65.63) J9.B34 v1(10.63,65.63) ; v1(7.68,72.83) J9.A22 ; v1(10.63,80.03) J9.B10 v1(8.47,80.03) ; v1(10.63,85.43) J9.B1 v1(8.47,85.43) ; v1(7.68,85.43) J9.A1 v1(5.12,85.43) ; v1(8.47,78.23) J9.B13 v1(10.63,78.23) ; v1(10.63,72.83) J9.B22 v1(8.47,72.83) ; v1(7.68,63.83) J9.A37 ; v1(5.12,81.83) J9.A7 v1(7.68,81.83) ; v1(7.68,83.63) J9.A4 v1(5.12,83.63) ; v1(8.47,76.43) J9.B16 v1(10.63,76.43) ; v1(8.47,69.23) J9.B28 v1(10.63,69.23) ; v1(5.12,74.63) J9.A19 v1(7.68,74.63) ; v1(7.68,78.23) J9.A13 v1(5.12,78.23) ; v1(8.47,63.83) J9.B37 v1(10.63,63.83) ; v1(5.65,67.43) J9.A31 v1(7.68,67.43) ; v1(7.68,80.03) J9.A10
  TOP w0.381: v1(109.23,35.51) 109.01,35.73 C524.2 ; v1(160.54,27.38) 160.6,27.45 C782.2 ; C1196.2 66.94,40.21 v1(66.94,40.85) ; v1(160.54,56.47) 160.6,56.53 C728.2 ; C746.2 160.6,71.01 v1(160.54,70.94) ; v2(111.39,87.84) 111.39,87.58 C539.2 111.39,87.07 v2(111.39,86.82) ; v2(99.96,87.84) 99.96,87.52 C538.2 99.96,87.14 v2(99.96,86.82) ; v1(160.54,85.42) 160.6,85.49 C764.2 ; v1(160.54,41.99) 160.6,42.05 C710.2 ; S3.1 v1(220.49,98.63) ; v1(218.13,24.72) v1(216.16,24.72) v1(213.24,24.72) v1(209.94,24.72) v1(206.89,24.72) v1(203.97,24.72) v1(202,24.72) ; v1(211.21,98.63) 211.44,98.86 211.44,99.81 S1.1 211.84,100.24 v1(211.84,101.81) ; v2(104.02,87.84) 104.02,87.52 C534.2 104.02,87.14 v2(104.02,86.82) ; C1198.2 v1(62.75,37.04) ; v2(93.48,87.84) 93.48,87.52 C537.2 93.48,87.14 v2(93.48,86.82) ; v1(5.6,94.19) 5.34,94.44 J10.5 v1(3.41,94.44) ; U95.H7 v2(180.22,30.69) ; v1(56.01,40.59) 56.01,40.91 R258.1 ; U96.D10 v1(197.26,73.8) ; R20.2 v1(60.71,10.56) ; U93.D10 v1(54.3,89.51) ; v1(56.2,54.35) R256.1
  TOP w0.483: J1.B7 51.65,6.17 v3(51.65,6.17)
  TOP w0.508: J1.A4 48.65,6.13 v3(48.7,6.17)
  BOTTOM w0.178: v1(25.15,94.82) 25.15,95.13 U6.13 ; U6.6 v1(28.71,96.04)
  BOTTOM w0.203: U88.6 v1(211.84,101.81) ; v1(107.35,55.03) 106.36,55.03 105.93,54.6 105.57,54.6 105.15,55.03 104.77,55.03 104.34,54.6 104,54.6 103.54,54.14 103.24,54.14 102.72,53.62 102.39,53.62 102.14,53.37 102.14,53.01 102.24,52.9 102.24,52.66 102.12,52.37 102.12,52.1 102.24,51.82 102.13,51.54 102.13,51.18 102.24,50.9 102.24,50.24 101.99,49.99 R6860.1 ; U89.6 v1(8.39,22.68) ; U90.6 v1(8.39,28.91) ; U87.6 v1(219.34,101.81)
  BOTTOM w0.229: v1(97.79,53.19) 97.54,52.94 97.54,52.65 97.34,52.45 97.34,52.09 97.47,51.95 97.47,51.66 97.34,51.53 97.34,51.17 97.49,51.02 97.49,50.67 97.34,50.52 97.34,48.92 R6870.1 ; R541.1 129.2,72.11 127.65,72.11 124.04,75.72 123.16,75.72 122.95,75.84 122.82,76.07 122.26,76.63 121.55,76.63 121.37,76.74 121.22,76.99 121,77.12 119.28,77.12 118.83,77.58 118.37,77.58 118.16,77.7 118.04,77.9 117.81,78.03 117.59,78.03 117.49,77.99 117.08,77.58 116.77,77.58 116.58,77.47 116.43,77.21 116.27,77.11 115.99,77.11 115.78,76.99 115.64,76.75 115.44,76.64 115.19,76.64 114.97,76.51 114.76,76.15 114.46,75.98 114.08,75.98 113.16,75.06 113.16,74.11 112.41,73.36 111.82,73.36 110.85,72.39 110.85,71.98 110.91,71.83 111.02,71.73 111.02,71.45 110.9,71.33 110.85,71.21 110.85,71.04 110.9,70.93 111.02,70.81 111.02,70.59 110.86,70.32 110.66,70.2 110.36,70.2 110.21,70.11 110.03,69.8 109.91,69.73 109.55,69.73 109.09,69.27 108.76,69.27 108.31,68.82 107.99,68.82 107.82,68.72 107.68,68.49 107.49,68.38 107.2,68.38 107.01,68.49 106.89,68.69 106.69,68.81 106.37,68.81 105.94,68.39 105.57,68.39 105.17,68.79 105.16,68.79 105.14,68.81 104.77,68.81 104.35,68.39 103.98,68.39 103.52,68.84 103.24,68.84 103.03,68.72 102.87,68.43 102.73,68.35 102.38,68.35 101.92,67.89 101.59,67.89 101.14,67.45 v1(100.18,67.45) ; v1(105.75,51.35) 105.54,51.14 105.54,50.37 105.16,49.99 R6872.1 ; C1224.1 96.93,57.89 96.55,57.5 96.55,57.14 96.63,57.06 96.63,57.06 96.63,57.05 96.63,56.68 96.36,56.41 96.08,56.41 95.85,56.28 95.71,56.04 95.52,55.93 95.21,55.93 94.75,55.47 94.41,55.47 93.99,55.05 93.66,55.05 93.17,54.56 92.83,54.56 92.36,54.09 92.02,54.09 91.59,53.65 91.24,53.65 91,53.42 90.94,53.26 90.94,53.14 91.07,52.83 91.07,52.65 90.94,52.33 90.94,51.31 91.08,50.98 91.08,50.75 90.94,50.42 R6858.1 ; v1(104.16,56.87) 103.19,56.87 102.75,56.43 102.41,56.43 101.93,55.95 101.64,55.95 101.43,55.83 101.29,55.58 101.1,55.47 100.79,55.47 100.53,55.21 100.53,54.84 100.64,54.73 100.64,54.4 100.53,54.29 100.53,53.92 100.64,53.81 100.64,53.57 100.52,53.28 100.52,53.11 100.64,52.82 100.64,52.65 100.52,52.35 100.52,52.18 100.64,51.87 100.64,51.72 100.52,51.43 100.52,51.23 100.64,50.93 100.64,50.68 100.46,50.5 100.46,49.04 R6900.1
  BOTTOM w0.254: 111.89,55.2 111.96,55.2 v1(112.13,55.03) ; U52.4 v1(207.4,53.57) ; v1(73.54,51.64) 73.79,51.39 R6921.1 73.92,51.01 73.79,50.88 73.79,50.62 R6922.1 ; v1(24.39,92.92) 24.39,92.34 R771.1 ; ST10.1 165.36,71.33 ; v1(9.07,44.43) 9.61,43.89 9.79,43.89 10.1,43.58 v1(10.1,43.13) 10,43.03 Y1.2 v1(10.8,41.8) 10.8,39.96 v1(10.68,39.83) v1(8.55,39.83) Y1.4 v1(7.75,40.65) 7.75,42.36 7.44,42.67 v1(7.44,43.13) 7.44,43.98 v1(7.83,44.38) ; R6936.2 73.97,48.34 v1(73.08,48.34) ; v1(73.41,60.91) 73.41,60.95 74.05,61.59 R756.2 R755.2 ; U26.11 19.73,30.33 19.63,30.43 v1(19.31,30.43) ; C451.1 63.25,80.09 v1(63.53,80.37) ; R74.1 31.82,67.01 v1(31.88,66.94) ; U27.12 21.88,49.71 v1(21.72,49.86) ; C303.2 209.94,23.32 v1(209.94,23.57) ; v1(5.6,45.23) 5.89,45.23 U25.8 ; v3(196.73,55.96) 197.19,56.42 ST30.2 ; v1(91.41,72.51) 91.41,72.58 C571.1 ; U26.12 20.23,29.19 v1(20.07,29.03) ; R6933.2 R6932.2 74.21,66.97 v1(73.41,67.77) ; C609.2 219.82,78.21 v1(219.97,78.06) ; v1(72.19,99.47) 71.89,99.17 71.89,98.25 71.62,97.98 U38.1 ; v1(71.05,62.49) 71,62.54 R757.2 ; v1(10.8,45.67) 10.8,45.8 10.39,46.21 U25.32 ; R475.2 225.37,80.79 225.05,81.1 ; 73.79,56.59 74.94,56.59 R6928.2 R6927.2 ; v1(206.89,24.72) 206.57,24.4 R209.2 ; v1(110.53,74.35) 110.45,74.61 R6840.2 R6841.2 ; v1(23.38,50.5) 23.09,50.21 U27.11 ; C1224.1 96.99,57.97 v1(96.99,58.15) ; ST8.1 165.36,42.37 ; v1(73.41,60.15) 74.05,59.51 R6925.2 R6926.2 ; v1(73.92,46.94) 73.92,47.4 R6937.2 ; ST11.1 165.36,85.8 ; v1(91.33,37.56) 91.33,38.04 R6934.2 ; v1(32.01,92.92) 32.01,92.34 R770.1 ; C1203.2 v3(196.73,54.69) ; v1(94.5,34.57) 94.63,34.43 R352.2 ; C623.2 224.72,79.16 ; U39.1 67.97,103.84 v1(66.24,102.11) ; R6931.2 R6930.2 73.92,69.17 v1(73.41,69.67) ; R398.2 v1(17.03,79.07) ; R6935.2 86.49,37.68 v1(86.11,37.3) ; ST14.1 165.36,27.76 ; R614.1 62.68,69.1 v2(62.62,69.17) ; ST9.1 165.36,56.85
  BOTTOM w0.279: 183.27,89.87 ST34.2 182.76,89.36
  BOTTOM w0.305: R137.1 v1(171.64,93.98) ; C77.2 25.68,79.21 25.68,78.15 v1(25.18,77.65) ; C93.2 32.12,79.69 32.58,80.15 34.68,80.15 v1(35.18,79.65) ; C54.2 28.63,76.25 28.88,76.25 29.08,76.05 29.08,75.69 C57.2 ; v2(175.04,96.06) 174.35,96.06 R136.1 ; C81.2 33.13,77.65 33.63,78.15 34.68,78.15 v1(35.18,78.65) ; v1(21.18,81.65) 21.67,81.16 21.67,79.78 21.83,79.63 21.83,79.59 C84.2 ; R153.1 v1(171.64,101.6) ; C96.2 30.48,71.41 30.48,71.05 30.82,70.71 C89.2 ; v1(227.97,39.96) 227.97,41.38 227.72,41.63 227.72,41.89 C601.2 R458.2 ; v1(193.56,72.21) C1216.2
  BOTTOM w0.381: v1(70.02,48.01) 70.56,47.48 C352.1 ; C63.2 C88.2 v1(22.18,69.65) ; C87.2 v1(23.14,95.2) ; C177.2 121.55,105.58 v2(121.49,105.52) ; C400.1 64.4,54.75 v1(64.65,54.75) ; v1(65.48,97.87) 65.29,97.68 C471.1 ; C381.1 C370.1 55.93,54.63 v1(56.2,54.35) ; Q1.2 v1(23.19,88.53) ; C467.1 v1(194.7,62.69) ; v2(121.49,97.9) 121.55,97.96 C151.2 ; v1(56.8,50.88) 56.78,50.88 56.71,50.94 C369.1 ; C490.1 10.47,97.36 v1(10.59,97.49) ; v1(73.98,103.96) 74.18,104.16 C473.1 ; U12.3 54.76,105.76 v1(54.62,105.62) ; v1(27.18,70.65) 27.12,70.71 C65.2 ; v1(29.18,69.65) C78.2 C86.2 ; v2(109.59,96.07) 109.59,96.81 C144.1 ; C382.1 v1(55.89,56.02) ; C460.1 v1(163.27,96.09) ; C191.2 v1(48.39,107.65) ; C395.1 66.68,54.75 v1(66.43,54.75) ; v1(73.89,99.98) 74.05,99.82 R6897.2 ; C157.2 v1(49,99.52) ; v1(10.63,81.83) 11.17,81.83 Q15.2 ; ST31.2 185.17,33.23 185.3,33.35 v2(185.3,34.5) ; C176.2 v1(111.29,108.38) ; Q7.2 235.87,101.17 v5(235.34,101.17) ; v1(86.38,20.16) 86.06,20.16 C1228.2 ; v2(109.59,103.69) 109.59,104.43 C178.1 ; v1(73.41,63.07) 73.41,63.71 C121.1 73.41,64.21 v1(73.41,64.85) ; v1(59.44,44.27) 59.76,44.27 C358.1 ; v1(72.19,99.47) 72.51,99.47 C470.2 ; C435.1 v1(25.6,48.08) ; v1(47.02,13.16) 47.15,13.29 U31.2 ; v1(60.71,10.56) 60.97,10.81 60.97,12.78 60.33,13.41 C444.2 ; v1(29.18,81.65) 30.18,80.65 C95.2 ; v2(180.22,30.69) 180.34,30.69 C1218.2 ; C141.2 v1(109.56,100.84) ; C140.2 v1(111.29,100.84) ; U91.3 54.98,97.76 v1(54.74,98) ; R6896.1 v1(195.71,63.45) ; 135.09,106.77 v1(135.09,107.6) ; C175.2 v1(109.56,108.36) ; C466.2 v1(194.7,63.45)
  BOTTOM w0.483: v3(48.7,6.17) 48.65,6.13 J1.A4
  vias: v1(2.1,51.51) v1(2.1,49.74) v1(2.1,47.07) v1(2.1,43.13) v1(3.18,53.48) v1(3.88,43.13) v1(3.88,42.24) v1(5.09,54.19) v1(5.09,31.7) v1(5.09,29.67) v1(5.09,28.65) v1(5.09,25.48) v1(5.09,23.45) v1(5.09,22.43) v1(5.21,73.29) v1(5.21,64.91) v1(5.55,96.06) v1(5.66,43.13) v1(5.66,42.24) v1(6.36,54.19) v1(6.61,49.23) v1(6.61,47.96) v1(6.61,46.69) v1(7.12,97.11) v1(7.12,94.95) v1(7.25,53.48) v1(7.88,98.12) v1(7.88,49.23) v1(7.88,47.96) v1(7.88,46.69) v1(8.26,55.26) v1(8.47,93.91) v1(8.64,98.12) v1(9.15,49.23) v1(9.15,47.96) v1(9.15,46.69) v1(9.28,55.26) v1(11.23,19.06) v1(11.26,88.6) v1(11.31,53.48) v1(11.44,91.77) v1(11.44,32.72) v1(11.44,31.7) v1(11.44,26.49) v1(11.44,25.48) v1(11.88,38.73) v1(12.71,42.43) v1(13.23,83.72) v1(13.23,81.74) v1(13.23,76.52) v1(13.23,74.54) v1(13.15,53.67) v1(13.15,51.64) v1(13.15,50.75) v1(13.15,49.74) v1(13.15,47.7) v1(13.15,46.69) v1(13.15,45.67) v1(13.82,80.58) v1(13.82,78.42) v1(14.23,64.59) v1(14.23,63.83) v1(14.23,63.07) v1(14.29,47.7) v1(14.29,44.66) v1(14.36,70.69) v1(14.42,28.78) v1(14.42,27.76) v1(14.42,25.86) v1(14.42,24.84) v1(14.69,95.33) v1(14.69,94.31) v1(14.74,64.21) v1(14.74,63.45) v1(15.22,85.52) v1(15.22,83.54) v1(15.22,78.32) v1(15.22,76.34) v1(15.25,64.59) v1(15.25,63.83) v1(15.25,63.07) v1(15.19,33.73) v1(15.5,70.69) v1(15.83,95.33) v1(15.83,94.31) v1(15.83,93.42) v1(15.83,92.15) v1(15.83,91.01) v1(15.83,73.92) v1(15.95,82.8) v1(16.14,53.74) v1(16.2,30.18) v1(16.2,29.29) v1(16.2,27.26) v1(16.2,26.37) v1(16.2,24.34) v1(16.2,23.45) v1(16.9,107.58) v1(17.03,53.74) v1(17.1,95.33) v1(17.1,94.31) v1(17.1,93.42) v1(17.1,92.15) v1(17.1,91.01) v1(17.53,55.51) v1(17.91,49.86) v1(17.91,48.59) v1(17.91,47.32) v1(17.91,46.05) v1(18.18,77.65) v1(18.18,75.65) v1(18.18,73.65) v1(18.37,95.33) v1(18.37,94.31) v1(18.37,93.42) v1(18.37,92.15) v1(18.37,91.01) v1(18.55,55.51) v1(18.8,33.59) v1(19.06,53.74) v1(19.18,83.65) v1(19.18,74.65) v1(19.18,68.65) v1(19.18,49.86) v1(19.18,48.59) v1(19.18,47.32) v1(19.18,46.05) v1(19.51,94.31) v1(19.51,93.42) v1(19.51,92.15) v1(19.95,53.74) v1(19.97,61.17) v1(20.07,27.76) v1(20.07,26.49) v1(20.07,25.22) v1(20.09,19.06) v1(20.18,71.65) v1(20.33,33.59) v1(20.45,55.51) v1(20.45,49.86) v1(20.45,48.59) v1(20.45,47.32) v1(20.45,46.05) v1(20.9,32.91) v1(21.18,77.65) v1(21.34,29.03) v1(21.34,27.76) v1(21.34,26.49) v1(21.34,25.22) v1(21.47,55.51) v1(21.67,97.61) v1(21.72,48.59) v1(21.72,47.32) v1(21.72,46.05) v1(21.91,32.91) v1(22.02,66.95) v1(21.98,53.74) v1(22.18,75.65) v1(22.18,72.65) v1(22.49,33.59) v1(22.61,29.03) v1(22.61,27.76) v1(22.61,26.49) v1(22.61,25.22) v1(22.61,21.22) v1(22.87,53.74) v1(23.1,44.55) v1(23.18,80.65) v1(23.18,67.65) v1(23.53,97.59) v1(23.5,61.74) v1(23.63,109.21) v1(23.76,63.9) v1(23.88,29.03) v1(23.88,27.76) v1(23.88,26.49) v1(23.88,25.22) v1(24.01,33.59) v1(24.18,85.5) v1(24.18,70.65) v1(24.65,34.81) v1(24.65,32.91) v1(24.65,21.22) v1(24.73,54.82) v1(24.73,53.8) v1(25.07,60.72) v1(25.18,83.65) v1(25.18,81.65) v1(25.18,75.65) v1(25.18,68.65) v1(25.53,32.91) v1(25.48,30.3) v1(25.6,45.29) v1(25.6,44.4) v1(25.6,42.37) v1(26.18,74.65) v1(26.3,92.26) v1(26.28,51.13) v1(26.28,49.61) v1(26.28,47.45) v1(26.28,45.93) v1(26.42,35.58) v1(26.62,40.94) v1(26.8,65.8) v1(27.06,108.73) v1(27.18,77.65) v1(27.64,40.94) v1(28.08,17.8) v1(28.18,85.5) v1(28.18,81.65) v1(28.18,76.65) v1(28.18,74.65) v1(28.72,40.91) v1(28.84,63.9) v1(29.22,92.26) v1(29.28,25.35) v1(29.85,63.9) v1(29.87,45.23) v1(29.87,44.09) v1(29.87,42.06) v1(29.87,40.91) v1(30.18,82.65) v1(30.18,78.65) v1(30.18,71.65) v1(30.45,89.36) v1(30.38,43.07) v1(30.61,52.77) v1(30.74,101.42) v1(30.74,100.66) v1(30.74,99.9) v1(30.88,45.23) v1(30.88,44.09) v1(30.88,42.06) v1(30.88,40.91) v1(31.12,60.53) v1(31.06,25.35) v1(31.25,101.04) v1(31.25,100.28) v1(31.18,82.65) v1(31.18,81.65) v1(31.18,78.65) v1(31.38,104.79) v1(31.76,101.42) v1(31.76,100.66) v1(31.76,99.9) v1(32.18,76.65) v1(32.18,73.65) v1(32.16,32.74) v1(32.62,30.38) v1(33.03,66.94) v1(33.18,70.65) v1(33.3,45.36) v1(33.42,41.42) v1(33.92,92.26) v1(33.98,64.47) v1(34.11,20.53) v1(34.18,83.65) v1(34.18,68.65) v1(34.17,27.96) v1(34.17,21.48) v1(34.87,34.11) v1(34.87,30.81) v1(35.06,102.95) v1(35.06,102.19) v1(35.06,101.42) v1(35.57,101.81) v1(35.76,74.12) v1(35.76,71.58) v1(35.75,27.69) v1(35.95,101.42) v1(35.92,80.65) v1(35.92,78.65) v1(36.05,81.65) v1(36.08,102.95) v1(36.08,102.19) v1(36.18,82.65) v1(36.22,25.63) v1(36.84,54.43) v1(36.77,27.69) v1(36.92,92.26) v1(37.07,45.81) v1(37.22,82.57) v1(37.5,61.25) v1(37.6,50.5) v1(37.84,81.6) v1(37.79,77.68) v1(37.79,75.39) v1(37.79,73.23) v1(37.78,67.83) v1(37.85,27.66) v1(38.74,73.48) v1(39,31.98) v1(39,30.84) v1(39,28.81) v1(39,27.66) v1(39.25,51.01) v1(39.25,49.99) v1(39.26,46.56) v1(39.26,44.66) v1(39.5,29.82) v1(40.01,31.98) v1(40.01,30.84) v1(40.01,28.81) v1(40.75,95.99) v1(40.77,51.01) v1(40.77,49.99) v1(40.79,46.56) v1(40.92,44.66) v1(41.31,27.79) v1(41.54,108.85) v1(42.19,44.66) v1(42.17,19.45) v1(42.3,46.56) v1(42.43,51.01) v1(42.43,32.11) v1(42.55,28.17) v1(42.93,49.48) v1(43.48,55.35) v1(43.48,52.95) v1(43.48,50.55) v1(43.48,45.75) v1(43.48,43.35) v1(43.48,40.95) v1(43.57,22.37) v1(44.85,55.35) v1(44.85,52.95) v1(44.85,50.55) v1(44.85,45.75) v1(44.85,43.35) v1(44.85,40.95) v1(45.62,44.35) v1(45.62,42.75) v1(45.62,41.95) v1(46.01,50.95) v1(46.4,55.75) v1(46.4,53.35) v1(46.4,46.15) v1(46.4,43.75) v1(46.4,41.35) v1(46.57,101.12) v1(47,64.47) v1(47.2,11.41) v1(47.4,14.68) v1(47.77,55.75) v1(47.77,53.35) v1(47.77,50.95) v1(47.77,46.15) v1(47.77,43.75) v1(47.77,41.35) v1(48.54,21.56) v1(48.6,102.09) v1(48.7,86.31) v1(48.7,85.51) v1(48.7,84.71) v1(48.7,83.91) v1(48.7,83.11) v1(48.79,19.16) v1(48.98,49.49) v1(48.98,48.6) v1(49.5,86.31) v1(49.5,85.51) v1(49.5,84.71) v1(49.5,83.91) v1(49.5,83.11) v1(49.99,33.56) v1(49.99,31.16) v1(49.99,28.76) v1(49.99,23.96) v1(49.99,21.56) v1(49.99,19.16) v1(50.94,101.6) v1(50.94,93.98) v1(51.6,28.76) v1(51.6,21.56) v1(51.72,31.16) v1(51.72,19.16) v1(52.2,45.29) v1(52.48,13.41) v1(52.64,93.98) v1(52.72,102.31) v1(52.7,85.51) v1(52.7,84.71) v1(52.7,83.91) v1(52.7,83.11) v1(52.92,33.56) v1(52.92,31.16) v1(52.92,28.76) v1(52.92,23.96) v1(52.92,21.56) v1(52.92,19.16) v1(53.09,61.26) v1(53.49,107.6) v1(53.49,99.98) v1(53.5,85.51) v1(53.5,84.71) v1(53.5,83.91) v1(53.5,83.11) v1(53.58,36.78) v1(54.34,101.6) v1(54.34,94.49) v1(54.3,85.51) v1(54.3,84.71) v1(54.3,83.91) v1(54.3,83.11) v1(54.53,33.96) v1(54.65,31.56) v1(54.65,21.96) v1(54.65,19.56) v1(55.19,107.6) v1(55.19,99.47) v1(55.25,55.35) v1(55.38,13.29) v1(55.85,33.96) v1(55.85,31.56) v1(55.85,29.16) v1(55.85,24.36) v1(55.85,21.96) v1(55.85,19.56) v1(55.89,85.93) v1(56.16,53.22) v1(56.24,43.18) v1(56.89,101.6) v1(56.89,94.62) v1(56.9,59.26) v1(56.9,56.02) v1(57.54,39.07) v1(57.59,59.26) v1(57.58,33.96) v1(57.58,31.56) v1(57.58,24.36) v1(57.58,21.96) v1(57.58,19.56) v1(57.74,52.68) v1(58.17,10.56) v1(58.64,101.6) v1(58.59,93.98) v1(58.7,41.66) v1(58.78,33.96) v1(58.78,31.56) v1(58.78,29.16) v1(58.78,24.36) v1(58.78,21.96) v1(58.78,19.56) v1(59.15,5.94) v1(59.15,2.2) v1(59.32,9.1) v1(59.44,107.6) v1(59.44,99.47) v1(59.57,58.5) v1(59.57,40.21) v1(60.21,96.47) v1(60.15,5.94) v1(60.15,2.2) v1(60.33,103.71) v1(60.29,101.6) v1(60.29,93.98) v1(60.65,8.21) v1(60.84,40.85) v1(61.14,107.6) v1(61.14,99.98) v1(61.22,51.77) v1(61.22,50.62) v1(61.22,49.48) v1(61.22,48.34) v1(61.22,47.2) v1(61.15,5.94) v1(61.15,2.2) v1(61.6,58.5) v1(61.73,54.75) v1(61.65,8.21) v1(61.99,101.6) v1(61.99,93.98) v1(62.17,11) v1(62.15,5.94) v1(62.15,2.2) v1(62.36,51.77) v1(62.36,50.62) v1(62.36,49.48) v1(62.36,48.34) v1(62.36,47.2) v1(62.84,107.6) v1(62.84,99.98) v1(62.87,40.85) v1(63,58.63) v1(63.13,74.55) v1(63.15,5.94) v1(63.15,2.2) v1(63.38,70.18) v1(63.38,69.17) v1(63.38,61.42) v1(63.53,81.39) v1(63.51,62.31) v1(63.51,51.77) v1(63.51,50.62) v1(63.51,49.48) v1(63.51,48.34) v1(63.51,47.2) v1(63.69,102.14) v1(63.69,94.49) v1(63.95,84.15) v1(64.14,62.31) v1(64.14,61.42) v1(64.14,20.27) v1(64.14,19) v1(64.14,17.25) v1(64.14,15.95) v1(64.15,11) v1(64.15,5.94) v1(64.15,2.2) v1(64.4,58.63) v1(64.55,99.42) v1(64.65,51.77) v1(64.65,50.62) v1(64.65,49.48) v1(64.65,48.34) v1(64.65,47.2) v1(64.65,18.11) v1(64.65,14.3) v1(64.8,81.39) v1(64.8,80.37) v1(64.76,74.63) v1(64.9,70.18) v1(64.9,69.17) v1(64.9,62.31) v1(64.9,61.42) v1(64.9,40.85) v1(64.9,40.08) v1(65.16,19) v1(65.16,17.25) v1(65.16,15.95) v1(65.15,5.94) v1(65.15,2.2) v1(65.37,103.61) v1(65.54,20.27) v1(65.69,81.39) v1(65.69,80.37) v1(65.65,8.21) v1(65.79,58.5) v1(65.79,51.77) v1(65.79,50.62) v1(65.79,49.48) v1(65.79,48.34) v1(65.79,47.2) v1(65.92,10.56) v1(66.05,40.08) v1(66.18,94.62) v1(66.15,5.94) v1(66.15,2.2) v1(66.43,44.21) v1(66.56,74.63) v1(66.65,8.21) v1(66.81,79.2) v1(66.94,82.25) v1(67.09,107.6) v1(67.09,99.47) v1(67.06,76.79) v1(67.17,11) v1(67.15,5.94) v1(67.15,2.2) v1(67.83,58.5) v1(67.83,40.15) v1(67.94,101.6) v1(67.94,94.62) v1(67.9,79.26) v1(68.15,5.94) v1(68.15,2.2) v1(68.79,107.6) v1(68.79,99.98) v1(68.97,40.21) v1(69.1,44.29) v1(69.1,41.73) v1(69.15,11) v1(69.15,5.94) v1(69.15,2.2) v1(69.64,101.6) v1(69.64,93.98) v1(69.6,81.61) v1(69.6,60.91) v1(69.6,60.15) v1(69.6,58.63) v1(69.65,8.21) v1(69.86,44.29) v1(70.02,54.24) v1(70.15,51.57) v1(70.15,50.68) v1(70.15,5.94) v1(70.15,2.2) v1(70.49,107.6) v1(70.49,99.98) v1(70.56,68.4) v1(70.75,72.24) v1(70.75,71.71) v1(70.75,70.21) v1(70.75,69.67) v1(70.65,8.21) v1(70.82,12.69) v1(71.16,55.15) v1(71.17,11) v1(71.15,5.94) v1(71.15,2.2) v1(71.34,101.6) v1(71.34,93.98) v1(71.38,75.26) v1(71.38,23.38) v1(71.38,20.97) v1(71.46,65.05) v1(71.83,80.09) v1(71.89,76.41) v1(71.89,71.71) v1(72.19,107.6) v1(72.15,5.94) v1(72.15,2.2) v1(72.4,71.96) v1(72.37,23.36) v1(72.37,20.96) v1(72.42,12.69) v1(72.52,70.21) v1(72.52,69.67) v1(72.57,63.3) v1(73.04,102.11) v1(73.04,94.49) v1(73.15,11) v1(73.15,5.94) v1(73.15,2.2) v1(73.41,72.6) v1(73.41,71.96) v1(73.41,70.21) v1(73.41,68.3) v1(73.41,65.38) v1(73.41,58.5) v1(73.41,57.74) v1(73.41,56.09) v1(73.41,55.45) v1(73.41,40.21) v1(73.39,27.36) v1(73.39,26.56) v1(73.39,25.76) v1(73.65,8.21) v1(73.84,44.55) v1(73.89,107.6) v1(74.24,79.33) v1(74.18,53.29) v1(74.18,49.86) v1(74.19,24.96) v1(74.19,24.16) v1(74.19,22.56) v1(74.19,20.16) v1(74.19,17.76) v1(74.15,5.94) v1(74.15,2.2) v1(74.4,45.16) v1(74.64,74.06) v1(74.65,8.21) v1(74.99,27.36) v1(75.22,52.03) v1(75.15,5.94) v1(75.15,2.2) v1(75.32,12.78) v1(75.59,102.11) v1(75.59,94.68) v1(75.83,52.78) v1(76.21,72.95) v1(76.15,5.94) v1(76.15,2.2) v1(76.33,75.21) v1(76.44,107.6) v1(76.44,99.47) v1(76.51,61.14) v1(76.51,59.07) v1(76.51,56.02) v1(76.59,27.96) v1(76.59,24.96) v1(77.08,22.56) v1(77.08,21.76) v1(77.08,20.96) v1(77.08,20.16) v1(77.08,19.36) v1(77.08,18.56) v1(77.08,17.76) v1(77.22,23.4) v1(77.15,11) v1(77.15,5.94) v1(77.15,2.2) v1(77.29,101.6) v1(77.29,93.98) v1(77.48,12.78) v1(77.69,22.56) v1(77.69,21.76) v1(77.69,20.96) v1(77.69,20.16) v1(77.69,19.36) v1(77.69,18.56) v1(78.14,107.6) v1(78.14,99.47) v1(78.19,26.56) v1(78.15,5.94) v1(78.15,2.2) v1(78.62,12.78) v1(78.66,70.67) v1(78.66,69.75) v1(78.66,68.83) v1(78.66,67.91) v1(78.66,66.99) v1(78.66,66.07) v1(78.66,65.15) v1(78.66,64.23) v1(78.66,63.31) v1(78.66,62.39) v1(78.66,61.47) v1(78.66,60.55) v1(78.66,59.63) v1(78.66,58.71) v1(78.66,57.79) v1(78.66,56.87) v1(78.66,55.95) v1(78.66,55.03) v1(78.66,54.11) v1(78.66,53.19) v1(78.66,52.27) v1(78.66,51.35) v1(78.66,50.43) v1(78.66,49.51) v1(78.66,48.59) v1(78.66,47.67) v1(78.75,10.56) v1(78.99,102.11) v1(78.99,94.49) v1(79.15,5.94) v1(79.15,2.2) v1(79.46,81.25) v1(79.46,80.33) v1(79.46,76.65) v1(79.46,74.81) v1(79.46,73.89) v1(79.46,72.97) v1(79.46,72.05) v1(79.46,71.13) v1(79.46,69.29) v1(79.46,67.45) v1(79.46,65.61) v1(79.46,63.77) v1(79.46,61.93) v1(79.46,60.09) v1(79.46,58.25) v1(79.46,56.41) v1(79.46,54.57) v1(79.46,52.73) v1(79.46,50.89) v1(79.46,49.05) v1(79.46,47.21) v1(79.46,44.45) v1(79.46,43.53) v1(79.46,42.61) v1(79.65,8.21) v1(79.84,107.6) v1(79.84,99.98) v1(79.79,27.36) v1(79.79,25.76) v1(79.89,12.78) v1(80.15,5.94) v1(80.15,2.2) v1(80.26,81.71) v1(80.26,80.79) v1(80.26,78.95) v1(80.26,75.27) v1(80.26,74.35) v1(80.26,73.43) v1(80.26,72.51) v1(80.26,71.59) v1(80.26,69.75) v1(80.26,67.91) v1(80.26,66.07) v1(80.26,64.23) v1(80.26,62.39) v1(80.26,60.55) v1(80.26,58.71) v1(80.26,56.87) v1(80.26,55.03) v1(80.26,53.19) v1(80.26,51.35) v1(80.26,49.51) v1(80.26,47.67) v1(80.26,45.83) v1(80.26,44.91) v1(80.26,43.99) v1(80.26,42.15) v1(80.53,10.56) v1(80.59,27.36) v1(80.59,24.96) v1(80.59,24.16) v1(80.59,21.76) v1(80.59,20.16) v1(80.69,101.6) v1(80.69,94.49) v1(80.65,8.21) v1(81.05,82.17) v1(81.05,81.25) v1(81.05,76.65) v1(81.05,73.89) v1(81.05,72.05) v1(81.05,71.13) v1(81.05,70.21) v1(81.05,69.29) v1(81.05,68.37) v1(81.05,67.45) v1(81.05,66.53) v1(81.05,65.61) v1(81.05,64.69) v1(81.05,63.77) v1(81.05,62.85) v1(81.05,61.93) v1(81.05,61.01) v1(81.05,60.09) v1(81.05,59.17) v1(81.05,58.25) v1(81.05,57.33) v1(81.05,56.41) v1(81.05,55.49) v1(81.05,54.57) v1(81.05,53.65) v1(81.05,52.73) v1(81.05,51.81) v1(81.05,50.89) v1(81.05,49.97) v1(81.05,49.05) v1(81.05,48.13) v1(81.05,47.21) v1(81.05,46.29) v1(81.05,45.37) v1(81.05,44.45) v1(81.05,42.61) v1(81.05,41.69) v1(81.16,12.78) v1(81.17,11) v1(81.15,5.94) v1(81.15,2.2) v1(81.39,17.76) v1(81.54,107.6) v1(81.54,99.98) v1(81.49,25.76) v1(81.79,23.56) v1(81.85,81.71) v1(81.85,78.95) v1(81.85,75.27) v1(81.85,72.51) v1(81.85,71.59) v1(81.85,70.67) v1(81.85,68.83) v1(81.85,66.99) v1(81.85,65.15) v1(81.85,63.31) v1(81.85,61.47) v1(81.85,59.63) v1(81.85,57.79) v1(81.85,55.95) v1(81.85,54.11) v1(81.85,52.27) v1(81.85,50.43) v1(81.85,48.59) v1(81.85,46.75) v1(81.85,44.91) v1(81.85,43.99) v1(81.85,42.15) v1(82.15,5.94) v1(82.15,2.2) v1(82.39,101.6) v1(82.39,94.68) v1(82.65,82.17) v1(82.65,80.33) v1(82.65,76.65) v1(82.65,72.97) v1(82.65,72.05) v1(82.65,70.21) v1(82.65,68.37) v1(82.65,66.53) v1(82.65,64.69) v1(82.65,62.85) v1(82.65,61.01) v1(82.65,59.17) v1(82.65,57.33) v1(82.65,55.49) v1(82.65,53.65) v1(82.65,51.81) v1(82.65,49.97) v1(82.65,48.13) v1(82.65,46.29) v1(82.65,44.45) v1(82.65,42.61) v1(82.65,41.69) v1(82.81,24.34) v1(83.24,107.6) v1(83.24,99.98) v1(83.19,38.05) v1(83.15,11) v1(83.15,5.94) v1(83.15,2.2) v1(83.44,80.79) v1(83.44,78.95) v1(83.44,74.35) v1(83.44,69.75) v1(83.44,68.83) v1(83.44,67.91) v1(83.44,66.99) v1(83.44,66.07) v1(83.44,65.15) v1(83.44,64.23) v1(83.44,63.31) v1(83.44,62.39) v1(83.44,61.47) v1(83.44,60.55) v1(83.44,59.63) v1(83.44,58.71) v1(83.44,57.79) v1(83.44,56.87) v1(83.44,55.95) v1(83.44,55.03) v1(83.44,54.11) v1(83.44,53.19) v1(83.44,52.27) v1(83.44,51.35) v1(83.44,50.43) v1(83.44,49.51) v1(83.44,48.59) v1(83.44,47.67) v1(83.44,46.75) v1(83.44,45.83) v1(83.44,44.91) v1(83.65,8.21) v1(84.24,81.25) v1(84.24,76.65) v1(84.24,72.97) v1(84.24,72.05) v1(84.24,69.29) v1(84.24,67.45) v1(84.24,65.61) v1(84.24,63.77) v1(84.24,56.41) v1(84.24,50.89) v1(84.24,49.05) v1(84.24,47.21) v1(84.24,46.29) v1(84.24,45.37) v1(84.24,42.61) v1(84.2,37.17) v1(84.15,5.94) v1(84.15,2.2) v1(84.65,8.21) v1(84.94,101.6) v1(84.94,94.49) v1(85.04,78.95) v1(85.04,74.35) v1(85.04,69.75) v1(85.04,67.91) v1(85.04,66.07) v1(85.04,64.23) v1(85.04,63.31) v1(85.04,61.47) v1(85.04,60.55) v1(85.04,59.63) v1(85.04,57.79) v1(85.04,56.87) v1(85.04,53.19) v1(85.04,51.35) v1(85.04,49.51) v1(85.04,47.67) v1(85.04,44.91) v1(85.18,37.17) v1(85.18,23.56) v1(85.17,11) v1(85.15,5.94) v1(85.15,2.2) v1(85.58,27.36) v1(85.58,26.56) v1(85.58,25.76) v1(85.58,21.76) v1(85.58,20.96) v1(85.58,18.56) v1(85.79,107.6) v1(85.79,99.47) v1(85.83,81.25) v1(85.83,76.65) v1(85.83,72.97) v1(85.83,69.29) v1(85.83,68.37) v1(85.83,67.45) v1(85.83,66.53) v1(85.83,65.61) v1(85.83,64.69) v1(85.83,63.77) v1(85.83,62.85) v1(85.83,61.93) v1(85.83,61.01) v1(85.83,60.09) v1(85.83,59.17) v1(85.83,58.25) v1(85.83,57.33) v1(85.83,56.41) v1(85.83,55.49) v1(85.83,54.57) v1(85.83,53.65) v1(85.83,52.73) v1(85.83,50.89) v1(85.83,49.97) v1(85.83,49.05) v1(85.83,48.13) v1(85.83,47.21) v1(85.83,42.61) v1(86.11,35.4) v1(86.15,5.94) v1(86.15,2.2) v1(86.38,24.96) v1(86.38,24.16) v1(86.38,22.56) v1(86.38,17.76) v1(86.37,15.26) v1(86.64,102.11) v1(86.64,94.68) v1(86.63,78.95) v1(86.63,74.35) v1(86.63,70.67) v1(86.63,67.91) v1(86.63,66.99) v1(86.63,66.07) v1(86.63,55.95) v1(86.63,55.03) v1(86.63,54.11) v1(86.63,53.19) v1(86.63,51.35) v1(86.63,50.43) v1(86.63,48.59) v1(86.63,44.91) v1(87.18,27.36) v1(87.18,16.49) v1(87.15,11) v1(87.15,5.94) v1(87.15,2.2) v1(87.43,81.25) v1(87.43,76.65) v1(87.43,72.97) v1(87.43,68.37) v1(87.43,67.45) v1(87.43,66.53) v1(87.43,64.69) v1(87.43,62.85) v1(87.43,61.01) v1(87.43,59.17) v1(87.43,57.33) v1(87.43,55.49) v1(87.43,52.73) v1(87.43,51.81) v1(87.43,50.89) v1(87.43,49.05) v1(87.43,47.21) v1(87.43,42.61) v1(87.49,107.6) v1(87.49,99.98) v1(87.65,8.21) v1(88.22,78.95) v1(88.22,74.35) v1(88.22,70.67) v1(88.22,67.91) v1(88.22,66.07) v1(88.22,55.95) v1(88.22,55.03) v1(88.22,54.11) v1(88.22,53.19) v1(88.22,52.27) v1(88.22,51.35) v1(88.22,50.43) v1(88.22,49.51) v1(88.22,48.59) v1(88.22,44.91) v1(88.15,5.94) v1(88.15,2.2) v1(88.27,37.42) v1(88.36,102.11) v1(88.36,93.98) v1(88.65,8.21) v1(88.78,29.06) v1(88.78,25.86) v1(89.02,81.25) v1(89.02,76.65) v1(89.02,72.97) v1(89.02,72.05) v1(89.02,67.45) v1(89.02,64.69) v1(89.02,62.85) v1(89.02,61.01) v1(89.02,59.17) v1(89.02,57.33) v1(89.02,55.49) v1(89.02,54.57) v1(89.02,53.65) v1(89.02,50.89) v1(89.02,49.97) v1(89.02,49.05) v1(89.02,47.21) v1(89.02,42.61) v1(89.15,23.56) v1(89.15,22.56) v1(89.15,21.76) v1(89.15,20.96) v1(89.15,20.16) v1(89.15,19.36) v1(89.15,18.56) v1(89.15,17.76) v1(89.19,99.47) v1(89.16,37.42) v1(89.17,11) v1(89.15,5.94) v1(89.15,2.2) v1(89.26,107.6) v1(89.82,78.95) v1(89.82,74.35) v1(89.82,70.67) v1(89.82,68.83) v1(89.82,67.91) v1(89.82,66.07) v1(89.82,65.15) v1(89.82,53.19) v1(89.82,52.27) v1(89.82,49.51) v1(89.82,44.91) v1(90.04,101.6) v1(90.04,93.98) v1(90.01,22.56) v1(90.01,21.76) v1(90.01,20.96) v1(90.01,20.16) v1(90.01,19.36) v1(90.01,18.56) v1(90.15,5.94) v1(90.15,2.2) v1(90.38,27.36) v1(90.38,24.96) v1(90.61,81.25) v1(90.61,76.65) v1(90.61,71.13) v1(90.61,69.29) v1(90.61,67.45) v1(90.61,65.61) v1(90.61,53.65) v1(90.61,52.73) v1(90.61,50.89) v1(90.61,47.21) v1(90.61,42.61) v1(90.66,31.04) v1(90.89,107.6) v1(90.89,99.98) v1(91.15,11) v1(91.15,5.94) v1(91.15,2.2) v1(91.41,78.95) v1(91.41,74.35) v1(91.41,70.67) v1(91.41,66.99) v1(91.41,63.31) v1(91.41,61.47) v1(91.41,59.63) v1(91.41,57.79) v1(91.41,55.95) v1(91.41,53.19) v1(91.41,52.27) v1(91.41,51.35) v1(91.41,49.51) v1(91.41,44.91) v1(91.42,36.5) v1(91.42,35.23) v1(91.42,34.22) v1(91.74,102.24) v1(91.74,94.62) v1(91.65,8.21) v1(91.98,27.36) v1(91.98,25.76) v1(91.98,16.49) v1(92.21,81.25) v1(92.21,76.65) v1(92.21,72.97) v1(92.21,69.29) v1(92.21,66.53) v1(92.21,63.77) v1(92.21,61.01) v1(92.21,58.25) v1(92.21,55.49) v1(92.21,52.73) v1(92.21,51.81) v1(92.21,50.89) v1(92.21,47.21) v1(92.21,42.61) v1(92.15,5.94) v1(92.15,2.2) v1(92.44,36.5) v1(92.44,35.23) v1(92.59,107.6) v1(92.59,99.47) v1(92.73,37.47) v1(92.65,8.21) v1(92.78,27.36) v1(92.78,24.96) v1(92.78,24.16) v1(92.78,21.76) v1(92.78,20.16) v1(93,78.95) v1(93,74.35) v1(93,72.51) v1(93,69.75) v1(93,68.83) v1(93,66.07) v1(93,63.31) v1(93,60.55) v1(93,57.79) v1(93,55.03) v1(93,53.19) v1(93,52.27) v1(93,51.35) v1(93,49.51) v1(93,44.91) v1(93.17,11) v1(93.15,5.94) v1(93.15,2.2) v1(93.45,105.49) v1(93.45,98) v1(93.58,18.56) v1(93.58,17.76) v1(93.68,25.76) v1(93.8,81.25) v1(93.8,76.65) v1(93.8,72.97) v1(93.8,68.37) v1(93.8,65.61) v1(93.8,62.85) v1(93.8,60.09) v1(93.8,57.33) v1(93.8,50.89) v1(93.8,47.21) v1(93.8,42.61) v1(93.98,23.56) v1(94.23,37.54) v1(94.15,5.94) v1(94.15,2.2) v1(94.29,102.11) v1(94.29,94.62) v1(94.6,78.95) v1(94.6,74.35) v1(94.6,72.51) v1(94.6,71.59) v1(94.6,70.67) v1(94.6,67.91) v1(94.6,65.15) v1(94.6,62.39) v1(94.6,59.63) v1(94.6,56.87) v1(94.6,53.19) v1(94.6,52.27) v1(94.6,51.35) v1(94.6,49.51) v1(94.6,44.91) v1(95.14,106.9) v1(95.14,99.98) v1(95.15,11) v1(95.15,5.94) v1(95.15,2.2) v1(95.26,37.54) v1(95.39,81.25) v1(95.39,76.65) v1(95.39,72.97) v1(95.39,72.05) v1(95.39,71.13) v1(95.39,70.21) v1(95.39,67.45) v1(95.39,64.69) v1(95.39,61.93) v1(95.39,59.17) v1(95.39,56.41) v1(95.39,47.21) v1(95.39,42.61) v1(95.99,101.6) v1(95.99,94.49) v1(96.19,78.95) v1(96.19,74.35) v1(96.19,72.51) v1(96.19,71.59) v1(96.19,70.67) v1(96.19,66.99) v1(96.19,55.95) v1(96.19,54.11) v1(96.19,52.27) v1(96.19,51.35) v1(96.19,49.51) v1(96.19,44.91) v1(96.15,5.94) v1(96.15,2.2) v1(96.65,10.56) v1(96.65,8.21) v1(96.99,81.25) v1(96.99,76.65) v1(96.99,55.49) v1(96.99,52.73) v1(96.99,51.81) v1(96.99,50.89) v1(96.99,47.21) v1(96.99,42.61) v1(97.16,35.51) v1(97.15,5.94) v1(97.15,2.2) v1(97.37,23.56) v1(97.69,101.6) v1(97.69,93.98) v1(97.65,8.21) v1(97.79,78.95) v1(97.79,74.35) v1(97.79,72.51) v1(97.79,71.59) v1(97.79,69.75) v1(97.79,68.83) v1(97.75,64.23) v1(97.75,63.31) v1(97.75,62.39) v1(97.75,61.47) v1(97.75,60.55) v1(97.75,59.63) v1(97.75,58.71) v1(97.79,55.03) v1(97.79,52.27) v1(97.79,51.35) v1(97.79,49.51) v1(97.79,44.91) v1(97.77,27.36) v1(97.77,26.56) v1(97.77,25.76) v1(97.77,21.76) v1(97.77,20.96) v1(98.17,11) v1(98.15,5.94) v1(98.15,2.2) v1(98.33,105.62) v1(98.54,93.09) v1(98.58,81.25) v1(98.58,76.65) v1(98.58,68.37) v1(98.58,52.73) v1(98.58,51.81) v1(98.58,47.21) v1(98.58,42.61) v1(98.57,24.96) v1(98.57,24.16) v1(98.57,22.56) v1(98.57,20.16) v1(98.57,17.76) v1(99.1,105.62) v1(99.1,98) v1(99.15,5.94) v1(99.15,2.2) v1(99.39,108.4) v1(99.39,100.79) v1(99.38,78.95) v1(99.38,74.35) v1(99.38,72.51) v1(99.38,71.59) v1(99.38,70.67) v1(99.38,67.91) v1(99.4,65.15) v1(99.4,64.23) v1(99.4,59.88) v1(99.38,56.87) v1(99.38,54.11) v1(99.38,52.27) v1(99.38,51.35) v1(99.38,49.51) v1(99.38,44.91) v1(99.37,27.36) v1(99.37,16.49) v1(100.24,100.71) v1(100.24,93.09) v1(100.18,81.25) v1(100.18,76.65) v1(100.18,56.41) v1(100.18,54.57) v1(100.18,53.65) v1(100.18,52.73) v1(100.18,51.81) v1(100.18,50.89) v1(100.18,47.21) v1(100.18,42.61) v1(100.15,11) v1(100.15,5.94) v1(100.15,2.2) v1(100.65,8.21) v1(100.93,63.97) v1(100.93,62.39) v1(100.93,61.47) v1(100.93,59.88) v1(100.97,78.95) v1(100.97,74.35) v1(100.97,72.51) v1(100.97,71.59) v1(100.97,69.75) v1(100.97,66.99) v1(100.97,55.95) v1(100.97,53.19) v1(100.97,52.27) v1(100.97,51.35) v1(100.97,49.51) v1(100.97,44.91) v1(100.97,35.51) v1(100.97,29.06) v1(100.97,25.86) v1(101.15,5.94) v1(101.15,2.2) v1(101.34,23.56) v1(101.34,22.56) v1(101.34,21.76) v1(101.34,20.96) v1(101.34,20.16) v1(101.34,19.36) v1(101.34,18.56) v1(101.34,17.76) v1(101.65,8.21) v1(101.77,81.25) v1(101.77,76.65) v1(101.77,55.49) v1(101.77,52.73) v1(101.77,51.81) v1(101.77,47.21) v1(101.77,42.61) v1(101.94,93.09) v1(101.99,35.51) v1(102.2,22.56) v1(102.2,21.76) v1(102.2,20.96) v1(102.2,20.16) v1(102.2,19.36) v1(102.2,18.56) v1(102.2,17.76) v1(102.17,11) v1(102.15,5.94) v1(102.15,2.2) v1(102.57,78.95) v1(102.57,74.35) v1(102.57,72.51) v1(102.57,71.59) v1(102.57,70.67) v1(102.57,68.83) v1(102.58,65.15) v1(102.58,64.23) v1(102.58,63.31) v1(102.58,59.88) v1(102.57,55.03) v1(102.57,54.11) v1(102.57,52.27) v1(102.57,51.35) v1(102.57,49.51) v1(102.57,44.91) v1(102.57,27.36) v1(102.57,24.96) v1(102.79,108.39) v1(102.79,100.86) v1(102.79,93.09) v1(102.88,35.51) v1(103.15,5.94) v1(103.15,2.2) v1(103.36,81.25) v1(103.36,76.65) v1(103.36,68.37) v1(103.36,52.73) v1(103.36,51.81) v1(103.36,50.89) v1(103.36,47.21) v1(103.36,42.61) v1(103.64,108.39) v1(103.64,100.87) v1(103.77,35.51) v1(104.16,78.95) v1(104.16,74.35) v1(104.16,72.51) v1(104.16,71.59) v1(104.16,69.75) v1(104.16,67.91) v1(104.23,65.15) v1(104.23,64.23) v1(104.23,63.31) v1(104.23,62.39) v1(104.23,61.47) v1(104.23,60.55) v1(104.23,59.63) v1(104.23,57.79) v1(104.16,53.19) v1(104.16,52.27) v1(104.16,51.35) v1(104.16,49.51) v1(104.16,44.91) v1(104.17,27.36) v1(104.17,25.76) v1(104.17,16.49) v1(104.15,11) v1(104.15,5.94) v1(104.15,2.2) v1(104.49,93.09) v1(104.65,8.21) v1(104.96,81.25) v1(104.96,76.65) v1(104.96,67.45) v1(104.96,56.41) v1(104.96,47.21) v1(104.96,42.61) v1(104.97,27.36) v1(104.97,24.96) v1(104.97,24.16) v1(104.97,21.76) v1(104.97,20.16) v1(105.15,5.94) v1(105.15,2.2) v1(105.34,108.39) v1(105.34,100.84) v1(105.34,93.09) v1(105.65,8.21) v1(105.75,78.95) v1(105.75,74.35) v1(105.75,72.51) v1(105.75,71.59) v1(105.75,70.67) v1(105.75,66.99) v1(105.75,55.95) v1(105.75,54.11) v1(105.75,52.27) v1(105.75,49.51) v1(105.75,44.91) v1(105.77,18.56) v1(105.77,17.76) v1(105.87,25.76) v1(106.19,108.39) v1(106.19,100.84) v1(106.17,23.56) v1(106.17,11) v1(106.15,5.94) v1(106.15,2.2) v1(106.43,35.51) v1(106.55,81.25) v1(106.55,76.65) v1(106.55,66.53) v1(106.55,63.77) v1(106.55,61.01) v1(106.55,58.25) v1(106.55,55.49) v1(106.55,47.21) v1(106.55,42.61) v1(107.04,93.09) v1(107.15,5.94) v1(107.15,2.2) v1(107.35,78.95) v1(107.35,74.35) v1(107.35,72.51) v1(107.35,71.59) v1(107.35,69.75) v1(107.35,68.83) v1(107.35,66.07) v1(107.35,63.31) v1(107.35,60.55) v1(107.35,57.79) v1(107.35,53.19) v1(107.35,52.27) v1(107.35,51.35) v1(107.35,49.51) v1(107.35,44.91) v1(107.89,108.39) v1(107.89,100.84) v1(107.89,93.09) v1(108.14,81.25) v1(108.14,76.65) v1(108.14,68.37) v1(108.14,65.61) v1(108.14,62.85) v1(108.14,60.09) v1(108.14,57.33) v1(108.14,50.89) v1(108.14,47.21) v1(108.14,42.61) v1(108.21,35.51) v1(108.15,11) v1(108.15,5.94) v1(108.15,2.2) v1(108.74,108.39) v1(108.74,100.84) v1(108.65,8.21) v1(108.94,78.95) v1(108.94,74.35) v1(108.94,72.51) v1(108.94,71.59) v1(108.94,70.67) v1(108.94,67.91) v1(108.94,65.15) v1(108.94,62.39) v1(108.94,59.63) v1(108.94,56.87) v1(108.94,54.11) v1(108.94,51.35) v1(108.94,49.51) v1(108.94,44.91) v1(109.15,5.94) v1(109.15,2.2) v1(109.59,93.09) v1(109.56,23.56) v1(109.74,81.25) v1(109.74,76.65) v1(109.74,72.97) v1(109.74,72.05) v1(109.74,71.13) v1(109.74,70.21) v1(109.74,67.45) v1(109.74,64.69) v1(109.74,61.93) v1(109.74,59.17) v1(109.74,56.41) v1(109.74,47.21) v1(109.74,42.61) v1(109.65,8.21) v1(109.96,27.36) v1(109.96,26.56) v1(109.96,25.76) v1(109.96,21.76) v1(109.96,20.96) v1(110.24,35.51) v1(110.17,11) v1(110.15,5.94) v1(110.15,2.2) v1(110.44,108.38) v1(110.44,100.84) v1(110.44,93.09) v1(110.53,78.95) v1(110.53,71.59) v1(110.53,70.67) v1(110.53,69.75) v1(110.53,68.83) v1(110.53,67.91) v1(110.53,66.07) v1(110.53,64.23) v1(110.53,62.39) v1(110.53,60.55) v1(110.53,59.63) v1(110.53,58.71) v1(110.53,55.03) v1(110.53,52.27) v1(110.53,49.51) v1(110.53,44.91) v1(110.76,24.96) v1(110.76,24.16) v1(110.76,22.56) v1(110.76,20.16) v1(110.76,17.76) v1(111.13,35.51) v1(111.15,5.94) v1(111.15,2.2) v1(111.33,81.25) v1(111.33,76.65) v1(111.33,72.05) v1(111.33,71.13) v1(111.33,59.17) v1(111.33,57.33) v1(111.33,52.73) v1(111.33,50.89) v1(111.33,47.21) v1(111.33,42.61) v1(111.56,27.36) v1(111.56,16.49) v1(112.14,108.38) v1(112.14,100.84) v1(112.07,93.09) v1(112.13,78.95) v1(112.13,74.35) v1(112.13,72.51) v1(112.13,70.67) v1(112.13,58.71) v1(112.13,49.51) v1(112.13,44.91) v1(112.15,11) v1(112.15,5.94) v1(112.15,2.2) v1(112.65,8.21) v1(112.92,81.25) v1(112.92,76.65) v1(112.92,72.97) v1(112.92,70.21) v1(112.92,69.29) v1(112.92,68.37) v1(112.92,66.53) v1(112.92,64.69) v1(112.92,62.85) v1(112.92,61.01) v1(112.92,57.33) v1(112.92,52.73) v1(112.92,50.89) v1(112.92,47.21) v1(112.92,42.61) v1(112.99,108.54) v1(112.99,100.84) v1(113.06,93.09) v1(113.16,29.06) v1(113.16,25.86) v1(113.15,5.94) v1(113.15,2.2) v1(113.53,23.56) v1(113.53,22.56) v1(113.53,21.76) v1(113.53,20.96) v1(113.53,20.16) v1(113.53,19.36) v1(113.53,18.56) v1(113.53,17.76) v1(113.72,78.95) v1(113.72,74.35) v1(113.72,72.51) v1(113.72,71.59) v1(113.72,68.83) v1(113.72,58.71) v1(113.72,55.03) v1(113.72,49.51) v1(113.72,44.91) v1(113.67,35.51) v1(113.65,8.21) v1(114.17,11) v1(114.15,5.94) v1(114.15,2.2) v1(114.4,22.56) v1(114.4,21.76) v1(114.4,20.96) v1(114.4,20.16) v1(114.4,19.36) v1(114.4,18.56) v1(114.4,17.76) v1(114.52,81.25) v1(114.52,76.65) v1(114.52,73.89) v1(114.52,72.97) v1(114.52,71.13) v1(114.52,70.21) v1(114.52,68.37) v1(114.52,66.53) v1(114.52,64.69) v1(114.52,62.85) v1(114.52,61.01) v1(114.52,57.33) v1(114.52,52.73) v1(114.52,50.89) v1(114.52,47.21) v1(114.52,42.61) v1(114.69,35.51) v1(114.76,27.36) v1(114.76,24.96) v1(115.15,5.94) v1(115.15,2.2) v1(115.31,78.95) v1(115.31,77.11) v1(115.31,76.19) v1(115.31,75.27) v1(115.31,74.35) v1(115.31,71.59) v1(115.31,70.67) v1(115.31,69.75) v1(115.31,68.83) v1(115.31,58.71) v1(115.31,55.03) v1(115.31,49.51) v1(115.31,44.91) v1(115.69,102.95) v1(115.69,101.68) v1(115.69,99.9) v1(115.69,98.63) v1(115.69,95.33) v1(115.67,94.06) v1(115.96,35.51) v1(116.11,81.25) v1(116.11,77.57) v1(116.11,76.65) v1(116.11,75.73) v1(116.11,74.81) v1(116.11,73.89) v1(116.11,72.05) v1(116.11,71.13) v1(116.11,70.21) v1(116.11,69.29) v1(116.11,68.37) v1(116.11,67.45) v1(116.11,66.53) v1(116.11,65.61) v1(116.11,64.69) v1(116.11,63.77) v1(116.11,62.85) v1(116.11,61.93) v1(116.11,61.01) v1(116.11,60.09) v1(116.11,59.17) v1(116.11,58.25) v1(116.11,57.33) v1(116.11,56.41) v1(116.11,55.49) v1(116.11,52.73) v1(116.11,50.89) v1(116.11,47.21) v1(116.11,42.61) v1(116.15,11) v1(116.15,5.94) v1(116.15,2.2) v1(116.36,27.36) v1(116.36,25.76) v1(116.36,16.49) v1(116.65,8.21) v1(116.91,78.95) v1(116.91,77.11) v1(116.91,75.27) v1(116.91,73.43) v1(116.91,72.51) v1(116.91,71.59) v1(116.91,66.99) v1(116.91,65.15) v1(116.91,64.23) v1(116.91,63.31) v1(116.91,62.39) v1(116.91,61.47) v1(116.91,60.55) v1(116.91,58.71) v1(116.91,56.87) v1(116.91,55.03) v1(116.91,49.51) v1(116.91,44.91) v1(117.1,35.51) v1(117.16,27.36) v1(117.16,24.96) v1(117.16,24.16) v1(117.16,21.76) v1(117.16,20.16) v1(117.15,5.94) v1(117.15,2.2) v1(117.7,81.25) v1(117.7,77.57) v1(117.7,75.73) v1(117.7,73.89) v1(117.7,72.97) v1(117.7,68.37) v1(117.7,65.61) v1(117.7,63.77) v1(117.7,62.85) v1(117.7,61.93) v1(117.7,61.01) v1(117.7,59.17) v1(117.7,57.33) v1(117.7,55.49) v1(117.7,51.81) v1(117.7,47.21) v1(117.7,42.61) v1(117.65,8.21) v1(117.96,18.56) v1(117.96,17.76) v1(118.06,25.76) v1(118.17,11) v1(118.15,5.94) v1(118.15,2.2) v1(118.37,35.51) v1(118.36,23.56) v1(118.5,78.95) v1(118.5,78.03) v1(118.5,77.11) v1(118.5,76.19) v1(118.5,75.27) v1(118.5,74.35) v1(118.5,73.43) v1(118.5,72.51) v1(118.5,71.59) v1(118.5,70.67) v1(118.5,69.75) v1(118.5,68.83) v1(118.5,67.91) v1(118.5,66.99) v1(118.5,66.07) v1(118.5,65.15) v1(118.5,64.23) v1(118.5,63.31) v1(118.5,62.39) v1(118.5,61.47) v1(118.5,60.55) v1(118.5,59.63) v1(118.5,58.71) v1(118.5,57.79) v1(118.5,56.87) v1(118.5,55.95) v1(118.5,55.03) v1(118.5,54.11) v1(118.5,53.19) v1(118.5,49.51) v1(118.5,44.91) v1(119.15,5.94) v1(119.15,2.2) v1(119.3,82.17) v1(119.3,81.25) v1(119.3,78.49) v1(119.3,76.65) v1(119.3,74.81) v1(119.3,72.97) v1(119.3,71.13) v1(119.3,69.29) v1(119.3,67.45) v1(119.3,65.61) v1(119.3,63.77) v1(119.3,61.93) v1(119.3,60.09) v1(119.3,58.25) v1(119.3,56.41) v1(119.3,54.57) v1(119.3,52.73) v1(119.3,51.81) v1(119.3,47.21) v1(119.3,41.69) v1(119.39,35.54) v1(120.09,81.71) v1(120.09,78.95) v1(120.09,78.03) v1(120.09,76.19) v1(120.09,74.35) v1(120.09,72.51) v1(120.09,70.67) v1(120.09,68.83) v1(120.09,66.99) v1(120.09,65.15) v1(120.09,63.31) v1(120.09,61.47) v1(120.09,59.63) v1(120.09,57.79) v1(120.09,55.95) v1(120.09,54.11) v1(120.09,52.27) v1(120.09,49.51) v1(120.09,44.91) v1(120.09,43.07) v1(120.09,42.15) v1(120.15,11) v1(120.15,5.94) v1(120.15,2.2) v1(120.64,108.49) v1(120.64,100.73) v1(120.65,8.21) v1(120.89,82.17) v1(120.89,81.25) v1(120.89,78.49) v1(120.89,77.57) v1(120.89,76.65) v1(120.89,75.73) v1(120.89,74.81) v1(120.89,73.89) v1(120.89,72.97) v1(120.89,72.05) v1(120.89,71.13) v1(120.89,70.21) v1(120.89,69.29) v1(120.89,68.37) v1(120.89,67.45) v1(120.89,66.53) v1(120.89,65.61) v1(120.89,64.69) v1(120.89,63.77) v1(120.89,62.85) v1(120.89,61.93) v1(120.89,61.01) v1(120.89,60.09) v1(120.89,59.17) v1(120.89,58.25) v1(120.89,57.33) v1(120.89,56.41) v1(120.89,55.49) v1(120.89,54.57) v1(120.89,53.65) v1(120.89,52.73) v1(120.89,51.81) v1(120.89,47.21) v1(120.89,43.53) v1(120.89,42.61) v1(120.89,41.69) v1(121.15,5.94) v1(121.15,2.2) v1(121.49,100.86) v1(121.49,93.09) v1(121.69,81.71) v1(121.69,79.87) v1(121.69,78.95) v1(121.69,78.03) v1(121.69,77.11) v1(121.69,75.27) v1(121.69,73.43) v1(121.69,71.59) v1(121.69,69.75) v1(121.69,67.91) v1(121.69,66.07) v1(121.69,64.23) v1(121.69,62.39) v1(121.69,60.55) v1(121.69,58.71) v1(121.69,56.87) v1(121.69,55.03) v1(121.69,53.19) v1(121.69,49.51) v1(121.69,44.91) v1(121.69,43.07) v1(121.69,42.15) v1(121.65,8.21) v1(121.76,23.56) v1(122.16,27.36) v1(122.16,26.56) v1(122.16,25.76) v1(122.16,21.76) v1(122.16,20.96) v1(122.17,11) v1(122.15,5.94) v1(122.15,2.2) v1(122.34,108.49) v1(122.34,100.86) v1(122.48,81.25) v1(122.48,80.33) v1(122.48,79.41) v1(122.48,78.49) v1(122.48,77.57) v1(122.48,75.73) v1(122.48,73.89) v1(122.48,72.05) v1(122.48,70.21) v1(122.48,68.37) v1(122.48,66.53) v1(122.48,64.69) v1(122.48,62.85) v1(122.48,61.01) v1(122.48,59.17) v1(122.48,57.33) v1(122.48,55.49) v1(122.48,53.65) v1(122.48,51.81) v1(122.48,47.21) v1(122.48,43.53) v1(122.48,42.61) v1(122.96,24.96) v1(122.96,24.16) v1(122.96,22.56) v1(122.96,20.16) v1(122.96,17.76) v1(123.19,108.49) v1(123.19,100.85) v1(123.19,93.09) v1(123.15,5.94) v1(123.15,2.2) v1(123.28,78.03) v1(123.28,77.11) v1(123.28,76.19) v1(123.28,75.27) v1(123.28,74.35) v1(123.28,73.43) v1(123.28,72.51) v1(123.28,71.59) v1(123.28,70.67) v1(123.28,69.75) v1(123.28,68.83) v1(123.28,67.91) v1(123.28,66.99) v1(123.28,66.07) v1(123.28,65.15) v1(123.28,64.23) v1(123.28,63.31) v1(123.28,62.39) v1(123.28,61.47) v1(123.28,60.55) v1(123.28,59.63) v1(123.28,58.71) v1(123.28,57.79) v1(123.28,56.87) v1(123.28,55.95) v1(123.28,55.03) v1(123.28,54.11) v1(123.28,53.19) v1(123.76,27.36) v1(124.04,105.58) v1(124.04,100.85) v1(124.04,97.95) v1(124.04,93.09) v1(124.15,5.94) v1(124.15,2.2) v1(124.37,17.25) v1(124.65,8.21) v1(125.15,5.94) v1(125.15,2.2) v1(125.36,28.96) v1(125.36,25.76) v1(125.74,108.49) v1(125.74,100.86) v1(125.74,93.17) v1(125.72,23.56) v1(125.72,22.56) v1(125.72,21.76) v1(125.72,20.96) v1(125.72,20.16) v1(125.72,19.36) v1(125.72,18.56) v1(125.72,17.76) v1(125.65,8.21) v1(126.17,11) v1(126.15,5.94) v1(126.15,2.2) v1(126.59,105.58) v1(126.59,97.95) v1(126.59,22.56) v1(126.59,21.76) v1(126.59,20.96) v1(126.59,20.16) v1(126.59,19.36) v1(126.59,18.56) v1(126.59,17.76) v1(126.96,27.36) v1(126.96,24.96) v1(127.15,5.94) v1(127.15,2.2) v1(127.44,108.49) v1(127.44,100.86) v1(127.44,93.22) v1(127.95,17.12) v1(128.14,5.94) v1(128.14,2.2) v1(128.15,66.25) v1(128.3,105.58) v1(128.3,97.95) v1(128.43,60.1) v1(128.56,27.36) v1(128.56,25.76) v1(128.91,65.74) v1(128.94,59.59) v1(129.14,108.49) v1(129.14,100.86) v1(129.36,27.36) v1(129.36,24.96) v1(129.36,24.16) v1(129.36,21.76) v1(129.36,20.16) v1(129.99,93.22) v1(130.16,18.56) v1(130.16,17.76) v1(130.26,25.76) v1(130.56,23.51) v1(130.94,19.98) v1(131.22,108.49) v1(131.22,100.86) v1(131.69,107.6) v1(131.69,99.98) v1(131.77,93.22) v1(132.09,20.78) v1(133.39,108.49) v1(133.39,100.86) v1(133.39,93.22) v1(134.24,105.64) v1(134.24,101.6) v1(134.24,93.98) v1(135.09,99.98) v1(135.94,101.6) v1(135.94,94.49) v1(136.79,107.6) v1(136.79,99.98) v1(137.64,102.3) v1(137.64,94.67) v1(138.49,107.09) v1(138.49,99.98) v1(140.19,101.6) v1(140.19,93.98) v1(141.04,107.6) v1(141.04,99.98) v1(141.89,101.6) v1(141.89,93.98) v1(142.74,107.6) v1(142.74,99.98) v1(143.52,20.02) v1(143.52,19) v1(143.59,101.6) v1(143.59,93.98) v1(144.28,20.02) v1(144.28,19) v1(144.44,107.6) v1(144.44,99.98) v1(145.04,20.02) v1(145.04,19) v1(145.29,101.6) v1(145.29,93.98) v1(146.14,107.6) v1(146.14,99.47) v1(146.99,102.11) v1(146.99,94.68) v1(147.84,107.6) v1(147.84,99.98) v1(149.54,101.6) v1(149.54,94.49) v1(150.39,107.6) v1(150.39,99.47) v1(151.24,102.11) v1(151.24,93.98) v1(152.09,107.6) v1(152.09,99.98) v1(152.94,101.6) v1(152.94,94.49) v1(154.64,101.6) v1(154.57,95.01) v1(154.64,93.98) v1(156.34,101.6) v1(156.34,93.98) v1(157.19,107.6) v1(157.19,99.47) v1(158.94,102.29) v1(158.89,93.98) v1(159.74,107.6) v1(159.74,99.47) v1(159.9,90.12) v1(159.9,75.64) v1(159.9,61.17) v1(159.9,46.69) v1(159.9,32.08) v1(160.59,101.6) v1(160.59,93.98) v1(162.29,101.6) v1(162.29,93.98) v1(163.33,105.49) v1(163.99,101.6) v1(163.99,93.98) v1(164.84,107.6) v1(164.84,99.98) v1(165.69,102.11) v1(165.69,93.98) v1(166.54,107.6) v1(166.54,99.98) v1(166.63,105.62) v1(167.57,97.77) v1(168.19,101.6) v1(168.24,93.98) v1(169.09,107.6) v1(169.09,99.98) v1(169.94,101.6) v1(169.94,93.98) v1(170.79,107.6) v1(170.79,99.98) v1(172.49,107.6) v1(172.49,99.98) v1(175.8,105.3) v1(175.8,97.68) v1(181.05,60.02) v1(184.79,60.02) v1(188.6,101.68) v1(188.6,100.66) v1(190,101.68) v1(190,100.66) v1(190.51,93.04) v1(190.51,92.28) v1(190.51,91.52) v1(190.89,101.17) v1(190.86,79.4) v1(190.86,78.6) v1(190.86,75.4) v1(190.86,74.6) v1(190.86,73.8) v1(191.02,92.66) v1(191.02,91.9) v1(191.52,93.04) v1(191.52,92.28) v1(191.52,91.52) v1(191.66,79.4) v1(191.66,78.6) v1(191.66,75.4) v1(191.66,74.6) v1(191.66,73.8) v1(191.78,101.68) v1(191.78,100.66) v1(192.46,79.4) v1(192.46,78.6) v1(192.46,75.4) v1(192.46,74.6) v1(192.46,73.8) v1(193.05,101.68) v1(193.05,100.66) v1(193.26,79.4) v1(193.26,78.6) v1(193.26,75.4) v1(193.26,74.6) v1(193.26,73.8) v1(194.06,79.4) v1(194.06,78.6) v1(194.19,101.17) v1(198.13,53.42) v1(199.02,37.29) v1(199.02,36.53) v1(199.02,35.77) v1(199.52,36.91) v1(199.52,36.15) v1(199.65,31.22) v1(200.03,37.29) v1(200.03,36.53) v1(200.03,35.77) v1(200.67,31.32) v1(201.68,31.32) v1(202.7,31.32) v1(203.82,82.27) v1(203.84,80.98) v1(204.17,107.62) v1(204.22,102.25) v1(204.45,25.29) v1(204.86,29.99) v1(207.78,107.11) v1(208.21,52.66) v1(208.21,51.64) v1(208.67,52.15) v1(208.8,99.01) v1(208.8,98) v1(208.8,37.29) v1(208.8,36.53) v1(208.8,35.77) v1(209.1,52.66) v1(209.1,51.64) v1(209.3,36.91) v1(209.3,36.15) v1(209.81,37.29) v1(209.81,36.53) v1(209.81,35.77) v1(210.07,79.9) v1(212.92,104.6) v1(214.89,99.01) v1(216.29,103.08) v1(216.29,102.06) v1(216.29,101.04) v1(216.29,100.03) v1(216.29,99.14) v1(216.29,98) v1(216.48,30.05) v1(216.48,19.38) v1(217.24,104.45) v1(217.39,78.88) v1(219.4,19.38) v1(221.04,56.77) v1(221.56,104.45) v1(222.64,103.08) v1(222.64,102.06) v1(222.64,101.04) v1(222.64,100.03) v1(222.64,99.01) v1(222.83,77.8) v1(222.83,76.79) v1(222.87,80.72) v1(222.87,79.77) v1(222.87,78.77) v1(222.85,60.58) v1(222.85,59.57) v1(222.85,57.53) v1(223.98,104.47) v1(224,60.58) v1(224,59.31) v1(224.8,101.93) v1(224.81,101.12) v1(224.94,74.66) v1(225.56,75.9) v1(226.58,75.9) v1(227.97,48.47) v1(228.73,39.96) v1(228.86,101.93) v1(228.86,101.17) v1(228.99,48.47) v1(230.26,106.44) v1(231.72,47.58) v1(231.72,46.56) v1(231.72,45.54) v1(231.72,44.53) v1(231.72,43.51) v1(232.42,101.93) v1(239.61,47.96) v1(242.64,70.06) v1(245.12,53.67) v1(245.12,52.4) v1(245.12,51.13) v1(245.12,49.86) v1(245.12,46.05) v1(245.12,44.78) v1(245.12,43.51) v1(246.83,93.42) v2(12.33,101.3) v2(12.83,100.79) v2(14.1,65.61) v2(14.23,62.05) v2(15.25,65.61) v2(15.25,62.05) v2(30.49,109.68) v2(30.49,108.28) v2(30.49,106.89) v2(30.74,102.19) v2(30.74,98.88) v2(31.76,102.19) v2(34.42,105.11) v2(35.06,103.84) v2(35.19,100.79) v2(35.44,105.11) v2(35.95,100.79) v2(35.97,99.77) v2(36.08,103.84) v2(44.97,25.31) v2(45.22,26.65) v2(47,28.15) v2(47,26.62) v2(51.79,107.6) v2(51.79,99.98) v2(57.74,107.6) v2(57.74,99.98) v2(62.49,61.42) v2(62.62,70.18) v2(64.54,107.6) v2(65.61,61.57) v2(65.92,70.18) v2(65.92,69.04) v2(65.92,62.31) v2(83.45,87.71) v2(83.45,86.82) v2(87.38,87.71) v2(87.38,86.82) v2(89.54,87.84) v2(89.54,86.82) v2(93.45,103.62) v2(93.45,96) v2(96.65,86.82) v2(96.84,107.6) v2(96.84,99.98) v2(97.16,34.5) v2(98.33,98) v2(98.51,107.6) v2(98.51,99.98) v2(100.24,108.28) v2(100.97,34.5) v2(101.09,103.7) v2(101.09,96.08) v2(101.99,34.5) v2(103.64,103.68) v2(103.64,96.06) v2(103.77,34.5) v2(104.49,105.52) v2(104.49,97.9) v2(105.54,34.5) v2(106.19,103.68) v2(106.19,96.06) v2(106.43,34.5) v2(107.04,105.52) v2(107.04,97.9) v2(107.7,87.84) v2(107.7,86.82) v2(108.21,34.45) v2(108.74,103.68) v2(108.74,96.06) v2(109.23,34.45) v2(109.59,105.52) v2(109.59,97.9) v2(110.24,34.45) v2(111.13,34.45) v2(113.67,34.45) v2(114.69,34.45) v2(115.69,107.52) v2(115.69,106.25) v2(115.96,34.45) v2(116.59,87.84) v2(116.59,86.82) v2(118.12,86.82) v2(122.34,103.68) v2(122.34,96.06) v2(122.69,87.84) v2(122.69,86.82) v2(123.45,34.75) v2(123.96,35.26) v2(124.89,103.68) v2(124.89,96.06) v2(126.59,103.68) v2(126.59,96.06) v2(126.63,87.84) v2(126.63,86.82) v2(129.14,103.68) v2(129.14,96.06) v2(133.61,96.06) v2(134.24,104.68) v2(134.24,102.68) v2(134.24,96.93) v2(134.24,95.06) v2(142.5,20.14) v2(142.5,19) v2(145.93,20.02) v2(145.93,19) v2(153.79,107.6) v2(153.79,99.98) v2(154.95,70.12) v2(154.95,69.48) v2(154.95,55.64) v2(154.95,55.01) v2(154.95,41.16) v2(154.95,40.53) v2(154.95,26.56) v2(154.95,25.92) v2(155.49,107.6) v2(155.49,99.98) v2(155.58,87.58) v2(155.58,86.95) v2(155.58,86.31) v2(155.58,85.68) v2(155.58,84.6) v2(155.58,83.96) v2(155.58,82.88) v2(155.58,82.25) v2(155.58,81.61) v2(155.58,80.98) v2(155.58,73.1) v2(155.58,72.47) v2(155.58,71.83) v2(155.58,71.2) v2(155.58,70.12) v2(155.58,69.48) v2(155.58,68.4) v2(155.58,67.77) v2(155.58,67.13) v2(155.58,66.5) v2(155.58,58.63) v2(155.58,57.99) v2(155.58,57.36) v2(155.58,56.72) v2(155.58,55.64) v2(155.58,55.01) v2(155.58,53.93) v2(155.58,53.29) v2(155.58,52.66) v2(155.58,52.02) v2(155.58,44.15) v2(155.58,43.51) v2(155.58,42.88) v2(155.58,42.24) v2(155.58,41.16) v2(155.58,40.53) v2(155.58,39.45) v2(155.58,38.81) v2(155.58,38.18) v2(155.58,37.54) v2(155.58,29.54) v2(155.58,28.91) v2(155.58,28.27) v2(155.58,27.64) v2(155.58,26.56) v2(155.58,25.92) v2(155.58,24.84) v2(155.58,24.21) v2(155.58,23.57) v2(155.58,22.94) v2(156.22,87.58) v2(156.22,86.95) v2(156.22,86.31) v2(156.22,85.68) v2(156.22,84.6) v2(156.22,83.96) v2(156.22,82.88) v2(156.22,82.25) v2(156.22,81.61) v2(156.22,80.98) v2(156.22,73.1) v2(156.22,72.47) v2(156.22,71.83) v2(156.22,71.2) v2(156.22,70.12) v2(156.22,69.48) v2(156.22,68.4) v2(156.22,67.77) v2(156.22,67.13) v2(156.22,66.5) v2(156.22,58.63) v2(156.22,57.99) v2(156.22,57.36) v2(156.22,56.72) v2(156.22,55.64) v2(156.22,55.01) v2(156.22,53.93) v2(156.22,53.29) v2(156.22,52.66) v2(156.22,52.02) v2(156.22,44.15) v2(156.22,43.51) v2(156.22,42.88) v2(156.22,42.24) v2(156.22,41.16) v2(156.22,40.53) v2(156.22,39.45) v2(156.22,38.81) v2(156.22,38.18) v2(156.22,37.54) v2(156.22,29.54) v2(156.22,28.91) v2(156.22,28.27) v2(156.22,27.64) v2(156.22,26.56) v2(156.22,25.92) v2(156.22,24.84) v2(156.22,24.21) v2(156.22,23.57) v2(156.22,22.94) v2(160.54,81.87) v2(160.54,67.39) v2(160.54,52.91) v2(160.54,38.43) v2(160.54,23.83) v2(161.3,81.87) v2(161.3,67.39) v2(161.3,52.91) v2(161.3,38.43) v2(161.3,23.83) v2(161.44,107.6) v2(161.44,99.98) v2(163.14,107.6) v2(163.14,99.98) v2(170.79,106.25) v2(170.79,105.25) v2(170.79,98.63) v2(170.79,97.63) v2(173.36,56.59) v2(173.36,55.96) v2(173.87,35.51) v2(173.87,34.5) v2(173.87,33.23) v2(173.87,31.96) v2(173.87,30.69) v2(173.87,29.54) v2(173.87,28.15) v2(173.87,26.88) v2(173.87,25.61) v2(173.87,24.34) v2(174,56.59) v2(174,55.96) v2(174.63,56.59) v2(174.63,55.96) v2(175.04,103.68) v2(175.14,35.51) v2(175.14,34.5) v2(175.14,33.23) v2(175.14,31.96) v2(175.14,30.69) v2(175.14,29.67) v2(175.89,103.68) v2(175.89,96.06) v2(176.41,35.51) v2(176.41,34.5) v2(176.41,33.23) v2(176.41,31.96) v2(176.41,30.69) v2(176.41,29.67) v2(177.68,35.51) v2(177.68,34.5) v2(177.68,29.67) v2(180.23,28.02) v2(180.22,27.08) v2(180.6,39.58) v2(180.6,38.31) v2(181.49,39.58) v2(181.49,38.31) v2(181.49,27.97) v2(181.49,27.08) v2(182.51,39.58) v2(182.51,38.31) v2(182.77,29.42) v2(182.77,28.02) v2(182.76,27.08) v2(183.78,29.42) v2(183.78,28.15) v2(183.78,27.08) v2(185.3,35.51) v2(185.3,29.67) v2(185.94,106.25) v2(185.94,101.68) v2(185.94,100.15) v2(186.57,35.51) v2(186.57,34.5) v2(186.57,33.1) v2(186.57,31.96) v2(186.57,30.69) v2(186.57,29.67) v2(187.21,106.25) v2(187.21,101.68) v2(187.21,100.15) v2(187.84,35.51) v2(187.84,34.5) v2(187.84,33.1) v2(187.84,31.96) v2(187.84,29.67) v2(189.24,35.51) v2(189.24,33.1) v2(189.24,31.96) v2(189.24,30.69) v2(189.24,29.42) v2(189.24,28.15) v2(189.24,26.88) v2(189.24,25.61) v2(189.24,24.34) v2(190.51,94.19) v2(190.51,90.63) v2(191.52,90.63) v2(191.65,94.19) v2(199.02,38.31) v2(199.02,34.88) v2(200.03,38.31) v2(200.03,34.88) v2(208.8,38.31) v2(208.92,34.88) v2(209.81,38.31) v2(209.81,34.88) v2(216.42,65.36) v2(216.42,59.47) v3(5.21,60.02) v3(5.21,58.63) v3(6.55,60.02) v3(6.55,58.63) v3(7.06,36.91) v3(7.06,35.77) v3(8.33,36.91) v3(8.33,35.77) v3(14.1,68.09) v3(14.1,66.94) v3(15.25,68.09) v3(15.25,66.94) v3(30.36,97.49) v3(30.36,96.41) v3(31.5,94.82) v3(31.63,97.49) v3(31.63,96.34) v3(36.58,95.96) v3(38.11,95.96) v3(39.96,71.58) v3(39.96,70.31) v3(39.96,68.79) v3(39.96,67.77) v3(40.09,74.25) v3(40.09,73.23) v3(40.39,86.18) v3(41.41,86.18) v3(42.3,86.18) v3(42.3,78.06) v3(43.31,86.18) v3(43.82,78.31) v3(43.82,77.55) v3(49.49,71.07) v3(49.49,70.06) v3(49.49,68.79) v3(49.49,66.63) v3(50.3,77.42) v3(50.38,74.5) v3(50.38,73.61) v3(50.38,71.07) v3(50.38,70.06) v3(50.38,68.79) v3(50.38,66.63) v3(51.77,71.07) v3(51.77,70.06) v3(51.77,68.79) v3(51.77,66.63) v3(52.66,71.07) v3(52.66,70.06) v3(52.66,68.79) v3(52.66,66.63) v3(57.28,83.39) v3(57.28,82.25) v3(58.3,83.39) v3(58.3,82.25) v3(59.82,83.39) v3(59.82,82.25) v3(60.84,83.39) v3(60.84,82.25) v3(60.79,73.1) v3(60.79,71.45) v3(60.79,70.44) v3(60.79,68.79) v3(60.79,67.77) v3(67.19,70.31) v3(67.19,69.04) v3(67.19,62.44) v3(67.7,23.19) v3(68.71,23.19) v3(69.27,16.91) v3(69.27,16.04) v3(69.27,15.26) v3(69.6,23.19) v3(77.99,37.92) v3(77.99,36.91) v3(82.43,32.46) v3(82.43,31.45) v3(83.32,32.46) v3(84.72,32.46) v3(133.61,75.64) v3(133.87,65.74) v3(134.12,73.99) v3(134.37,64.47) v3(134.37,56.09) v3(134.37,54.43) v3(134.37,46.31) v3(134.37,44.66) v3(137.68,20.02) v3(137.68,19) v3(139.2,20.02) v3(139.2,19) v3(140.72,20.14) v3(140.72,19) v3(148.47,61.93) v3(148.6,92.53) v3(148.6,91.01) v3(148.6,89.36) v3(148.6,79.33) v3(148.6,77.8) v3(148.6,76.28) v3(148.6,74.88) v3(148.6,63.2) v3(148.6,60.4) v3(148.6,48.85) v3(148.6,47.45) v3(148.6,45.93) v3(148.6,34.5) v3(148.6,32.84) v3(148.6,31.32) v3(149.49,19.51) v3(149.49,18.11) v3(150.25,92.53) v3(150.25,91.01) v3(150.25,89.36) v3(150.25,79.33) v3(150.25,77.8) v3(150.25,76.28) v3(150.25,74.88) v3(150.25,63.2) v3(150.25,61.93) v3(150.25,60.4) v3(150.25,48.85) v3(150.25,47.45) v3(150.25,45.93) v3(150.25,34.5) v3(150.25,32.84) v3(150.25,31.32) v3(151.01,19.51) v3(151.01,18.11) v3(151.52,61.93) v3(151.52,48.85) v3(151.52,47.45) v3(151.52,45.93) v3(151.77,34.5) v3(151.77,32.84) v3(151.77,31.32) v3(152.41,19.51) v3(152.41,18.11) v3(153.04,92.53) v3(153.04,61.93) v3(153.04,48.85) v3(153.04,47.45) v3(153.04,45.93) v3(153.17,34.5) v3(153.17,32.84) v3(153.17,31.32) v3(153.8,19.51) v3(153.8,18.11) v3(154.57,92.53) v3(154.57,91.01) v3(154.57,89.36) v3(154.57,79.07) v3(154.57,77.8) v3(154.57,76.41) v3(154.57,75.01) v3(154.57,64.59) v3(154.57,63.2) v3(154.57,61.93) v3(154.57,60.4) v3(154.57,48.85) v3(154.57,47.45) v3(154.57,46.05) v3(154.57,34.5) v3(154.57,32.84) v3(154.57,31.45) v3(154.95,19.51) v3(154.95,18.11) v3(156.09,92.53) v3(156.09,90.76) v3(156.09,89.49) v3(156.09,79.07) v3(156.09,77.8) v3(156.09,76.41) v3(156.09,75.01) v3(156.09,64.59) v3(156.09,63.2) v3(156.09,61.93) v3(156.09,60.4) v3(156.09,50.12) v3(156.09,48.85) v3(156.09,47.45) v3(156.09,46.05) v3(156.09,35.64) v3(156.09,34.5) v3(156.09,32.84) v3(156.09,31.45) v3(156.09,20.91) v3(156.09,19.51) v3(156.09,18.11) v3(165.49,91.77) v3(165.49,90.76) v3(165.45,83.26) v3(165.45,81.87) v3(165.45,80.47) v3(165.45,79.07) v3(165.45,77.8) v3(165.45,76.41) v3(165.45,68.79) v3(165.45,67.39) v3(165.45,66.25) v3(165.45,63.32) v3(165.45,61.93) v3(165.45,54.31) v3(165.45,52.91) v3(165.45,51.51) v3(165.45,50.12) v3(165.45,48.85) v3(165.45,47.45) v3(165.45,39.83) v3(165.45,38.43) v3(165.45,37.04) v3(165.45,35.64) v3(165.45,34.37) v3(165.45,32.97) v3(165.45,22.43) v3(165.45,21.03) v3(165.45,19.76) v3(165.45,18.24) v3(169.68,35.33) v3(169.68,34.7) v3(169.68,34.13) v3(170.31,35.33) v3(170.31,34.7) v3(170.31,34.13) v3(170.31,33.2) v3(170.31,30.69) v3(170.31,28.15) v3(170.31,25.61) v3(170.26,22.81) v3(170.26,19.51) v3(170.95,35.33) v3(170.95,34.7) v3(170.95,34.13) v3(171.08,89.28) v3(171.08,88.01) v3(171.08,79) v3(171.08,77.73) v3(171.08,76.33) v3(171.08,75.06) v3(171.08,67.06) v3(172.22,35.33) v3(172.22,34.7) v3(172.22,34.13) v3(172.22,31.96) v3(172.22,29.54) v3(172.22,26.88) v3(172.22,24.34) v3(172.17,21.54) v3(172.17,19.51) v3(172.35,89.28) v3(172.35,88.01) v3(172.35,79) v3(172.35,77.73) v3(172.35,76.33) v3(172.35,75.06) v3(172.35,67.06) v3(172.85,35.33) v3(172.85,34.7) v3(172.85,34.13) v3(173.62,89.28) v3(173.62,88.01) v3(173.62,79) v3(173.62,77.73) v3(173.62,76.33) v3(173.62,75.06) v3(173.62,67.06) v3(173.82,22.81) v3(173.82,21.54) v3(173.82,20.14) v3(173.82,19.51) v3(174.45,22.81) v3(174.45,21.54) v3(174.45,20.14) v3(174.45,19.51) v3(174.89,89.28) v3(174.89,88.01) v3(174.89,79) v3(174.89,77.73) v3(174.89,76.33) v3(174.89,75.06) v3(174.89,67.06) v3(176.16,89.28) v3(176.16,88.01) v3(176.16,67.06) v3(176.28,79) v3(176.28,77.73) v3(176.28,76.33) v3(176.28,75.06) v3(177.55,89.28) v3(177.55,88.01) v3(177.55,77.73) v3(177.55,76.33) v3(177.55,67.06) v3(178.82,77.73) v3(178.82,67.06) v3(180.22,77.73) v3(181.87,77.73) v3(183.4,85.55) v3(183.4,77.73) v3(184.54,85.42) v3(184.92,77.73) v3(185.55,85.42) v3(186.44,77.73) v3(186.57,86.44) v3(186.57,85.42) v3(188.61,22.81) v3(188.61,21.54) v3(188.61,20.14) v3(188.61,19.51) v3(188.7,106.25) v3(189.25,22.81) v3(189.25,21.54) v3(189.25,20.14) v3(189.25,19.51) v3(190.13,35.46) v3(190.13,34.83) v3(190.13,34.25) v3(190.38,106.25) v3(190.51,96.66) v3(190.51,95.39) v3(190.76,35.46) v3(190.76,34.83) v3(190.76,34.25) v3(190.76,31.96) v3(190.76,29.42) v3(190.76,26.88) v3(190.76,24.34) v3(190.77,21.54) v3(190.77,19.51) v3(191.14,71.07) v3(191.14,70.18) v3(191.14,69.29) v3(191.14,68.4) v3(191.14,67.52) v3(191.14,66.63) v3(191.65,96.66) v3(191.65,95.39) v3(192.01,106.25) v3(192.03,35.46) v3(192.03,34.83) v3(192.03,34.25) v3(192.16,71.07) v3(192.16,70.18) v3(192.16,69.29) v3(192.16,68.4) v3(192.16,67.52) v3(192.16,66.63) v3(192.67,35.46) v3(192.67,34.83) v3(192.67,34.25) v3(192.67,33.1) v3(192.67,30.69) v3(192.67,28.15) v3(192.67,25.61) v3(193.3,35.46) v3(193.3,34.83) v3(193.3,34.25) v3(193.68,106.25) v3(193.81,28.4) v3(193.81,27) v3(193.94,87.33) v3(193.94,85.8) v3(193.94,84.79) v3(194.95,49.99) v3(194.95,48.72) v3(194.95,47.45) v3(194.95,46.18) v3(195.33,28.4) v3(195.33,27) v3(195.59,57.23) v3(195.59,55.96) v3(195.59,54.69) v3(195.59,53.42) v3(195.59,51.13) v3(196.22,49.99) v3(196.22,48.72) v3(196.22,47.45) v3(196.22,46.18) v3(196.73,53.42) v3(196.73,51.13) v3(198.76,41.1) v3(198.76,39.58) v3(200.03,41.1) v3(200.03,39.64) v3(201.94,95.33) v3(201.94,93.8) v3(203.46,95.33) v3(203.46,93.8) v3(204.86,95.33) v3(204.86,93.8) v3(206.76,65.48) v3(206.76,61.8) v3(208.54,63.71) v3(208.54,41.1) v3(208.54,39.58) v3(209.81,41.1) v3(209.81,39.64) v3(210.19,65.48) v3(210.19,61.8) v3(214.15,35.38) v3(214.15,33.99) v3(214.15,32.59) v3(215.55,35.38) v3(215.55,33.99) v3(215.55,32.59) v3(216.95,42.37) v3(216.95,40.97) v3(216.95,39.58) v3(216.95,38.18) v3(216.95,36.78) v3(218.35,42.37) v3(218.35,40.97) v3(218.35,39.58) v3(218.35,38.18) v3(218.35,36.78) v3(221.5,96.06) v3(221.5,94.79) v3(221.5,93.52) v3(222.89,96.06) v3(222.89,94.79) v3(222.89,93.52) v3(224.16,96.06) v3(224.16,94.79) v3(224.16,93.52) v3(224.16,92.12) v3(224.16,90.85) v3(224.16,89.32) v3(224.16,87.67) v3(224.16,86.4) v3(224.16,84.88) v3(225.43,96.06) v3(225.43,94.79) v3(225.43,93.52) v3(225.43,92.12) v3(225.43,90.85) v3(225.43,89.32) v3(225.43,87.67) v3(225.43,86.4) v3(225.43,84.88) v3(225.43,83.61) v3(228.38,54.05) v3(228.38,52.78) v3(228.38,51.51) v3(228.38,50.24) v3(228.38,38.18) v3(228.38,36.78) v3(229.65,54.05) v3(229.65,52.78) v3(229.65,51.51) v3(229.65,50.24) v3(229.78,39.58) v3(229.78,38.18) v3(229.78,36.78) v3(231.05,54.05) v3(231.05,52.78) v3(231.05,51.51) v3(231.05,50.24) v3(231.55,35.38) v3(231.55,33.99) v3(231.55,32.59) v3(232.95,35.38) v3(232.95,33.99) v3(232.95,32.59) v3(235.38,99.33) v3(236.35,54.31) v3(236.35,52.66) v3(236.35,51.01) v3(237.75,54.31) v3(237.75,52.66) v3(237.75,51.01) v3(238.43,99.33) v3(239.02,54.31) v3(239.02,52.66) v3(239.02,51.01) v3(240.29,54.31) v3(240.29,52.66) v3(240.29,51.01) v3(240.55,107.39) v3(240.55,106.38) v3(241.56,105.62) v3(241.56,104.6) v4(116.91,67.91) v4(116.91,66.07) v5(151.52,63.2) v5(151.52,60.4) v5(153.04,91.01) v5(153.04,89.36) v5(153.04,77.8) v5(153.04,76.28) v5(153.04,74.88) v5(153.04,63.2) v5(153.04,60.4) v5(221.5,92.15) v5(221.5,90.85) v5(221.5,89.32) v5(221.5,87.67) v5(221.5,86.4) v5(222.89,92.15) v5(222.89,90.85) v5(222.89,89.32) v5(222.89,87.67) v5(222.89,86.4) v5(235.34,102.57) v5(239.4,102.57) v5(239.4,101.17) v6(62.36,44.21) v7(48.67,33.56) v7(48.79,31.16) v7(48.79,28.76) v7(48.79,23.96) v7(51.6,33.56) v7(51.6,23.96) v7(54.65,29.16) v7(54.65,24.36) v7(57.46,29.16) v7(128.4,34.88) v7(128.53,34.11) v7(129.8,34.88) v7(129.8,34.11) v7(131.83,88.6) v7(131.83,87.45) v7(132.47,88.6) v7(132.47,87.45) v8(119.26,34.37) v8(120.91,34.37) v8(128.28,69.42) v8(128.28,68.02) v8(128.58,57) v8(128.66,54.69) v8(128.66,53.55) v8(128.66,52.28) v8(128.66,51.13) v8(128.66,49.86) v8(128.66,48.59) v8(128.66,47.32) v8(129.01,78.08) v8(129.04,77.04) v8(129.04,70.56) v8(129.04,67.26) v8(129.04,63.32) v8(129.04,62.05) v8(129.04,58.37) v8(129.04,55.96) v8(133.61,58.35) v8(133.87,57.1) v8(134.09,48.52) v8(134.09,47.25) v8(134.09,43.69) v8(134.09,42.42) v8(134.22,53.47) v8(134.22,52.2)
