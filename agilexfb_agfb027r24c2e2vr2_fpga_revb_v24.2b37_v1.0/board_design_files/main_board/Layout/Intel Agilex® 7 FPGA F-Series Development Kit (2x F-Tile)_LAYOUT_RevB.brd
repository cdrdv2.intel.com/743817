# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_A8: length 98
  L05_SIG2 w0.081: v1(74.99,18.56) 76.31,18.16 86.41,18.16 86.86,18.34 v1(87.18,18.56) 88.5,18.16 98.6,18.16 99.05,18.34 v1(99.37,18.56) 100.69,18.16 110.8,18.16 111.24,18.34 v1(111.56,18.56)
  L07_SIG3 w0.089: v1(123.76,18.56) 123.36,18.96 122.06,18.96 120.25,20.78 120.25,29.73 120.05,29.92 119.54,29.92 119.36,29.75 119.36,29.16 119.19,28.98 118.8,28.98 118.62,29.16 118.62,30.08 118.45,30.25 114.21,30.25 113.49,30.97 113.49,33.68 112.93,34.24 112.93,37.11 112.55,37.5 112.55,48.37 112.77,48.59 113.13,48.59 113.62,49.08 113.9,49.08 114.37,49.55 114.69,49.55 115.14,49.1 115.61,49.1 116.03,49.52 116.28,49.52 116.75,49.05 v1(117.7,49.05)
  L16_SIG6 w0.081: v1(123.76,18.56) 123.3,18.25 123.07,18.16 112.91,18.16 112.18,18.3 v1(111.56,18.56)
  BOTTOM w0.149: v1(74.99,18.56) 74.99,17.91 74.57,17.49 74.57,17.31 R176.2
DDR4_COMP_A9: length 100.5
  TOP w0.149: U18.M7 v1(90.67,18.56) ; U17.M7 v1(102.86,18.56) ; U15.M7 v1(127.25,18.56) ; U16.M7 v1(115.06,18.56) ; U19.M7 v1(78.35,18.56)
  L05_SIG2 w0.081: v1(127.25,18.56) 127.25,18.58 128.42,19.76 128.73,19.76 128.96,19.98 128.96,20.33 129.18,20.56 129.5,20.56 129.75,20.8 130.18,21.45 131.01,23.46 131.01,31.21 130.2,32.02 130.2,33.13 129.29,34.04 129.29,35.26 129.16,35.38 128.99,35.38 128.87,35.26 128.87,33.53 128.75,33.41 128.58,33.41 128.46,33.53 128.46,37.07 123.13,49.95 122.63,50.45 122.29,50.45 121.83,50.92 121.51,50.92 121.07,50.47 120.79,50.47 120.3,49.99 119.96,49.99 119.47,49.5 119.04,49.5 118.74,49.2 118.32,49.03 117.88,48.59 v1(116.91,48.59)
  L14_SIG5 w0.081: v1(78.35,18.56) 79,18.29 79.66,18.16 90.02,18.16 90.26,18.26 90.59,18.48 v1(90.67,18.56) 91.44,18.24 91.86,18.16 102.21,18.16 102.45,18.26 102.79,18.48 v1(102.86,18.56) 103.63,18.24 104.05,18.16 114.41,18.16 114.64,18.26 114.98,18.48 v1(115.06,18.56) 115.82,18.24 116.24,18.16 126.6,18.16 126.83,18.26 127.17,18.48 v1(127.25,18.56)
  BOTTOM w0.149: v1(78.35,18.56) 77.77,17.97 R177.2
DDR4_COMP_A10: length 98.1
  TOP w0.149: U19.J3 v1(76.42,20.96) ; U17.J3 v1(100.68,20.96) ; U16.J3 v1(112.87,20.96) ; U18.J3 v1(88.49,20.96) ; U15.J3 v1(125.06,20.96)
  L03_SIG1 w0.081: v1(112.87,20.96) 112.95,20.88 113.33,20.63 113.5,20.56 124.1,20.56 v1(125.06,20.96)
  L05_SIG2 w0.081: v1(117.7,49.97) 117.3,49.57 117.3,49.22 117.1,49.02 116.79,49.02 116.51,48.74 116.51,47.94 116.26,47.69 115.96,47.69 115.72,47.45 115.72,40 116.5,39.22 117.66,39.22 121.75,35.13 121.75,33.93 121.92,33.76 124.9,33.76 125.05,33.61 125.05,33.39 124.9,33.24 121.65,33.24 121.52,33.11 121.52,32.85 121.65,32.72 124.87,32.72 125.03,32.57 125.03,32.35 124.87,32.2 123.51,32.2 123.36,32.04 123.36,21.56 123.55,21.37 124.66,21.37 v1(125.06,20.96)
  L07_SIG3 w0.089: v1(76.42,20.96) 76.51,20.88 76.84,20.65 77.07,20.56 87.52,20.56 v1(88.49,20.96) 88.57,20.88 88.91,20.65 89.13,20.56 99.71,20.56 v1(100.68,20.96) 100.76,20.88 101.1,20.65 101.32,20.56 111.91,20.56 v1(112.87,20.96)
DDR4_COMP_A11: length 97.3
  TOP w0.149: U19.N2 v1(74.99,17.25) ; U18.N2 v1(87.18,17.25) ; U17.N2 v1(99.37,17.25) ; U16.N2 v1(111.56,17.25) ; U15.N2 v1(123.76,17.25)
  L05_SIG2 w0.081: v1(116.91,50.43) 115.98,50.43 115.55,50.85 115.14,50.85 114.71,50.43 114.3,50.43 113.86,49.98 113.58,49.98 111.84,48.24 111.84,46.61 111.34,46.1 111.34,43.77 111.87,43.23 111.87,42.24 112.43,41.68 112.43,36.48 113.04,35.87 113.04,35.11 113.21,34.93 113.82,34.93 114.13,34.62 114.13,34.04 114.26,33.91 114.26,33 114.05,32.79 114.05,31.55 114.43,31.17 114.43,28.78 115.12,28.1 117,28.1 118.75,26.34 118.75,21.31 122.82,17.25 v1(123.76,17.25)
  L07_SIG3 w0.089: v1(74.99,17.25) 75.91,16.87 86.26,16.87 v1(87.18,17.25) 88.1,16.87 98.45,16.87 v1(99.37,17.25) 100.29,16.87 110.64,16.87 v1(111.56,17.25)
  L16_SIG6 w0.081: v1(123.76,17.25) 117.39,17.25 116.48,17.63 115.87,17.63 113.97,17.25 v1(111.56,17.25)
  BOTTOM w0.149: v1(74.99,17.25) 74.99,16.83 R179.2
DDR4_COMP_A12: length 99.7
  TOP w0.149: U18.J7 v1(90.67,20.96) ; U17.J7 v1(102.86,20.96) ; U19.J7 v1(78.35,20.96) ; U15.J7 v1(127.25,20.96) ; U16.J7 v1(115.06,20.96)
  L07_SIG3 w0.089: v1(127.25,20.96) 127.73,21.44 127.73,22.81 127.36,23.18 127.36,28.04 127.06,28.35 127.06,40.23 126.47,40.82 124.56,40.82 124.41,40.96 124.41,41.17 124.56,41.31 126.13,41.31 126.27,41.46 126.27,41.66 126.13,41.81 122.08,41.81 121.94,41.66 121.94,41.46 122.08,41.31 123.66,41.31 123.8,41.17 123.8,40.96 123.66,40.82 118.33,40.82 118.09,41.06 118.09,50.02 v1(118.5,50.43)
  L14_SIG5 w0.081: v1(78.35,20.96) 78.83,21.16 79.84,21.36 90.02,21.36 90.26,21.26 90.59,21.04 v1(90.67,20.96) 91.44,21.27 91.86,21.36 102.21,21.36 102.45,21.26 102.79,21.04 v1(102.86,20.96) 103.63,21.27 104.05,21.36 114.41,21.36 114.64,21.26 114.98,21.04 v1(115.06,20.96) 115.82,21.27 116.24,21.36 126.6,21.36 126.83,21.26 127.17,21.04 v1(127.25,20.96)
DDR4_COMP_A13: length 96.5
  TOP w0.149: U17.N8 v1(104.17,17.25) ; U16.N8 v1(116.36,17.25) ; U18.N8 v1(91.98,17.25) ; U15.N8 v1(128.56,17.25) ; U19.N8 v1(79.79,17.25)
  L07_SIG3 w0.089: v1(120.89,49.05) 121.19,48.75 121.19,48.46 121.53,48.12 121.87,48.12 122.31,47.68 122.8,47.68 128.52,41.97 128.52,37.96 128.66,37.81 128.87,37.81 129.01,37.96 129.01,40.7 129.16,40.85 129.36,40.85 129.51,40.7 129.51,29.75 129.75,29.51 129.75,24.76 130.14,24.36 130.14,22.01 129.51,21.38 129.18,21.38 128.95,21.15 128.95,20.82 128.67,20.54 128.24,20.54 128.01,20.31 128.01,17.8 v1(128.56,17.25)
  L12_SIG4 w0.089: v1(128.56,17.25) 128.14,17.53 127.38,17.53 126.58,17.37 125.16,17.37 125.01,17.38 124.91,17.41 124.71,17.48 124.66,17.54 124.5,17.61 124.38,17.63 123.73,17.63 123.54,17.59 123.09,17.41 122.86,17.35 121.86,17.25 v1(116.36,17.25) 114.19,17.25 112.82,17.38 112.71,17.41 112.52,17.48 112.47,17.54 112.31,17.61 112.19,17.63 111.54,17.63 111.35,17.59 110.9,17.41 110.67,17.35 109.67,17.25 v1(104.17,17.25) 100.71,17.25 100.46,17.35 100.27,17.54 100.12,17.61 100,17.63 99.35,17.63 99.16,17.59 98.71,17.41 98.48,17.35 97.48,17.25 v1(91.98,17.25) 88.48,17.25 88.29,17.33 88.08,17.54 87.92,17.61 87.8,17.63 87.16,17.63 86.97,17.59 86.52,17.41 86.29,17.35 85.29,17.25 v1(79.79,17.25)
  BOTTOM w0.149: R181.2 79.79,16.82 v1(79.79,17.25)
DDR4_COMP_A14: length 96
  L05_SIG2 w0.081: v1(111.56,21.76) 111.24,21.97 110.8,22.16 100.69,22.16 v1(99.37,21.76) 99.05,21.97 98.6,22.16 88.5,22.16 v1(87.18,21.76) 86.86,21.97 86.41,22.16 76.31,22.16 v1(74.99,21.76) ; v1(123.76,21.76) 124.16,22.16 124.16,27.79 124.32,27.95 124.79,27.95 124.95,28.11 124.95,28.33 124.79,28.49 124.19,28.49 124.04,28.64 124.04,29.33 124.19,29.49 125.33,29.49 125.48,29.64 125.48,29.86 125.33,30.01 124.06,30.01 123.91,30.16 123.91,30.38 124.06,30.53 125.43,30.53 125.53,30.63 125.53,30.95 125.43,31.05 124.16,31.05 124.01,31.21 124.01,31.42 124.16,31.57 125.33,31.57 125.48,31.73 125.48,33.99 125.25,34.22 122.63,34.22 122.42,34.42 122.42,34.84 122.58,35 122.97,35 123.1,35.13 123.1,35.41 122.97,35.54 122.41,35.54 118.01,39.94 117.19,39.94 116.53,40.6 116.53,46.94 116.82,47.23 117.1,47.23 117.51,47.64 117.83,47.64 118.29,48.1 118.73,48.1 119.08,48.45 119.4,48.59 v1(120.09,48.59)
  L16_SIG6 w0.081: v1(123.76,21.76) 123.3,22.07 123.07,22.16 112.91,22.16 112.18,22.01 v1(111.56,21.76)
  BOTTOM w0.149: R182.2 73.33,22.61 73.79,22.16 74.59,22.16 v1(74.99,21.76)
DDR4_COMP_A15: length 98.4
  TOP w0.149: U19.H7 v1(78.35,21.76) ; U18.H7 v1(90.67,21.76) ; U17.H7 v1(102.86,21.76) ; U15.H7 v1(127.25,21.76) ; U16.H7 v1(115.06,21.76)
  L05_SIG2 w0.081: v1(127.25,21.76) 127.78,22.29 128.17,22.29 128.41,22.53 128.77,22.53 128.97,22.73 128.97,27.58 128.57,27.99 128.57,30.74 128.45,30.86 128.28,30.86 128.16,30.74 128.16,27.99 128.04,27.87 127.87,27.87 127.75,27.99 127.75,30.9 127.63,31.02 127.46,31.02 127.33,30.9 127.33,27.87 127.21,27.75 127.04,27.75 126.92,27.87 126.92,37.11 124.95,41.87 123.09,43.73 123.09,46.37 122.69,46.77 122.35,46.77 121.9,47.22 121.51,47.22 121.07,47.66 120.77,47.66 120.49,47.94 120.49,49.57 v1(120.89,49.97)
  L14_SIG5 w0.081: v1(78.35,21.76) 78.85,21.96 79.82,22.16 90.02,22.16 90.26,22.06 90.59,21.84 v1(90.67,21.76) 91.44,22.07 91.86,22.16 102.21,22.16 102.45,22.06 102.79,21.84 v1(102.86,21.76) 103.63,22.07 104.05,22.16 114.41,22.16 114.64,22.06 114.98,21.84 v1(115.06,21.76) 115.82,22.07 116.24,22.16 126.6,22.16 126.83,22.06 127.17,21.84 v1(127.25,21.76)
DDR4_COMP_A16: length 98.4
  L07_SIG3 w0.089: v1(128.56,21.76) 128.56,22.44 128.96,22.83 128.96,28.07 128.08,28.94 128.08,30.54 128.23,30.68 128.43,30.68 128.58,30.54 128.58,29.59 128.72,29.44 128.93,29.44 129.07,29.59 129.07,32.65 128.93,32.79 128.72,32.79 128.58,32.65 128.58,31.61 128.43,31.47 128.23,31.47 128.08,31.61 128.08,34.49 128.23,34.63 128.43,34.63 128.58,34.49 128.58,33.57 128.72,33.43 128.93,33.43 129.07,33.57 129.07,36.79 128.93,36.93 128.72,36.93 128.58,36.79 128.58,35.77 128.43,35.62 128.23,35.62 128.08,35.77 128.08,41.53 122.94,46.68 122.42,46.68 121.86,47.24 121.46,47.24 121.07,47.63 120.73,47.63 120.48,47.88 120.48,50.04 v1(120.09,50.43)
  L12_SIG4 w0.089: v1(79.79,21.76) 80.17,21.5 80.52,21.36 90.65,21.36 91.35,21.5 v1(91.98,21.76) 92.36,21.5 92.71,21.36 102.84,21.36 103.55,21.5 v1(104.17,21.76) 104.56,21.5 104.9,21.36 115.03,21.36 115.74,21.5 v1(116.36,21.76) 116.75,21.5 117.09,21.36 127.22,21.36 127.93,21.5 v1(128.56,21.76)
  BOTTOM w0.149: v1(79.79,21.76) 80.27,22.24 80.86,22.24 81.32,21.78 R184.2
DDR4_COMP_ACT_N: length 99.2
  TOP w0.149: U19.H3 v1(76.42,21.76) ; U17.H3 v1(100.68,21.76) ; U15.H3 v1(125.06,21.76) ; U16.H3 v1(112.87,21.76) ; U18.H3 v1(88.49,21.76)
  L03_SIG1 w0.081: v1(125.06,21.76) 124.1,21.36 113.5,21.36 113.33,21.43 112.95,21.68 v1(112.87,21.76)
  L07_SIG3 w0.089: v1(112.87,21.76) 111.91,21.36 101.32,21.36 101.1,21.45 100.76,21.68 v1(100.68,21.76) 99.71,21.36 89.13,21.36 88.91,21.45 88.57,21.68 v1(88.49,21.76) 87.52,21.36 77.07,21.36 76.84,21.45 76.51,21.68 v1(76.42,21.76) ; v1(113.72,47.67) 114.14,47.25 114.14,39.39 115.25,38.28 115.25,33.48 115.4,33.33 116.37,33.33 116.54,33.5 116.54,34.25 116.69,34.41 117.05,34.41 117.2,34.25 117.2,33.12 117.38,32.95 117.59,32.95 117.76,32.77 117.76,31.42 117.94,31.24 118.22,31.24 118.4,31.42 118.4,33 118.57,33.18 118.84,33.18 119.01,33 119.01,31.42 119.19,31.24 119.43,31.24 119.61,31.42 119.61,32.77 119.78,32.95 120.03,32.95 120.21,32.77 120.21,31.42 120.38,31.24 120.63,31.24 120.8,31.42 120.8,32.77 120.98,32.95 121.26,32.95 121.42,32.79 121.42,25.5 121.85,25.07 121.85,24.52 121.25,23.93 121.25,23.3 121.5,23.05 123.31,23.05 124.21,22.16 124.66,22.16 v1(125.06,21.76)
DDR4_COMP_ALERT_N: length 94.4
  L07_SIG3 w0.089: v1(129.36,19.36) 129.76,19.76 130.28,19.76 130.54,20.02 130.54,20.17 130.77,20.4 131.02,20.4 131.2,20.58 131.2,21.02 131.47,21.68 131.47,37.6 131.33,37.75 131.12,37.75 130.98,37.6 130.98,36.82 130.83,36.67 130.63,36.67 130.48,36.82 130.48,40.44 130.61,40.57 130.87,40.57 130.98,40.46 130.98,38.67 131.12,38.52 131.33,38.52 131.47,38.67 131.47,40.87 123.29,49.05 v1(122.48,49.05)
  L14_SIG5 w0.081: v1(129.36,19.36) 129.28,19.44 128.94,19.66 128.71,19.76 118.35,19.76 117.93,19.67 v1(117.16,19.36) 117.09,19.44 116.75,19.66 116.51,19.76 106.16,19.76 105.74,19.67 v1(104.97,19.36) 104.89,19.44 104.56,19.66 104.32,19.76 93.96,19.76 93.54,19.67 v1(92.78,19.36) 92.7,19.44 92.37,19.66 92.13,19.76 81.77,19.76 81.35,19.67 v1(80.59,19.36)
  BOTTOM w0.149: R194.2 82.21,18.48 81.54,19.15 80.79,19.15 v1(80.59,19.36)
DDR4_COMP_BA0: length 94.6
  L05_SIG2 w0.081: v1(121.69,48.59) 122.74,48.59 123.53,47.8 127.89,37.26 127.89,33.43 128.7,32.62 128.7,31.75 128.82,31.63 128.99,31.63 129.11,31.75 129.11,32.95 129.21,33.05 129.42,33.05 129.52,32.95 129.52,30.43 129.63,30.33 129.83,30.33 129.94,30.43 129.94,31.17 130.06,31.29 130.23,31.29 130.35,31.17 130.35,26.51 130.65,26.2 130.65,24.27 130.14,23.75 130.14,22.29 129.93,22.08 129.93,21.77 129.52,21.36 128.38,21.36 127.57,20.56 126.38,20.56 126.15,20.33 126.15,19.98 125.93,19.76 124.58,19.76 124.18,20.16 v1(123.76,20.16) ; v1(74.99,20.16) 76.31,20.56 86.41,20.56 86.86,20.37 v1(87.18,20.16) 88.5,20.56 98.6,20.56 99.05,20.37 v1(99.37,20.16) 100.69,20.56 110.8,20.56 111.24,20.37 v1(111.56,20.16)
  L16_SIG6 w0.081: v1(111.56,20.16) 112.18,20.41 112.91,20.56 123.07,20.56 123.3,20.47 v1(123.76,20.16)
  BOTTOM w0.149: v1(74.99,20.16) 74.59,20.56 73.99,20.56 73.72,20.28 73.41,20.28 R188.2
DDR4_COMP_BA1: length 96.4
  L07_SIG3 w0.089: v1(122.48,49.97) 122.06,49.55 122.06,48.85 122.34,48.57 122.76,48.57 130,41.32 130,33.94 130.15,33.79 130.35,33.79 130.5,33.94 130.5,35.8 130.64,35.94 130.85,35.94 130.99,35.8 130.99,31.69 130.85,31.55 130.64,31.55 130.5,31.69 130.5,32.88 130.35,33.02 130.15,33.02 130,32.88 130,30.57 130.96,29.61 130.96,21.77 129.75,20.55 129.2,20.55 128.81,20.16 v1(128.56,20.16)
  L12_SIG4 w0.089: v1(128.56,20.16) 128.16,19.76 117.09,19.76 116.75,19.9 v1(116.36,20.16) 115.96,19.76 104.9,19.76 104.56,19.9 v1(104.17,20.16) 103.55,19.9 102.84,19.76 92.71,19.76 92.36,19.9 v1(91.98,20.16) 91.35,19.9 90.65,19.76 80.52,19.76 80.17,19.9 v1(79.79,20.16)
  BOTTOM w0.149: R189.2 81.81,20.13 81.38,20.56 80.19,20.56 v1(79.79,20.16)
DDR4_COMP_BG0: length 96.2
  L05_SIG2 w0.081: v1(74.99,20.96) 76.31,21.36 86.41,21.36 86.86,21.17 v1(87.18,20.96) 88.5,21.36 98.6,21.36 99.05,21.17 v1(99.37,20.96) 100.69,21.36 110.8,21.36 111.24,21.17 v1(111.56,20.96) ; v1(121.69,50.43) 121.28,50.02 121.28,48.28 121.43,48.13 121.88,48.13 122.34,47.67 122.7,47.67 123.22,47.15 127.43,36.98 127.43,31.56 127.55,31.44 127.72,31.44 127.84,31.56 127.84,32.44 127.94,32.54 128.15,32.54 128.25,32.44 128.25,31.68 128.99,30.94 128.99,28.2 129.11,28.08 129.28,28.08 129.4,28.2 129.4,29.63 129.52,29.75 129.69,29.75 129.81,29.63 129.81,24.08 129.36,23.64 129.36,23.18 129.73,22.81 129.73,22.4 129.51,22.18 128.45,22.18 127.62,21.35 126.36,21.35 126.14,21.13 126.14,20.8 125.9,20.56 124.81,20.56 124.41,20.96 v1(123.76,20.96)
  L16_SIG6 w0.081: v1(111.56,20.96) 112.18,21.21 112.91,21.36 123.07,21.36 123.3,21.27 v1(123.76,20.96)
  BOTTOM w0.149: v1(74.99,20.96) 74.6,21.34 73.93,21.34 73.48,21.78 R186.2
DDR4_COMP_BG1: length 99
  L05_SIG2 w0.081: v1(128.56,20.96) 128.02,20.42 128.02,20.2 127.58,19.76 126.34,19.76 126.15,19.58 126.15,19.17 125.94,18.96 124.86,18.96 124.04,19.78 123.54,19.78 123.37,19.95 123.37,20.3 123.12,20.55 122.77,20.55 122.58,20.75 122.58,21.1 122.32,21.36 121.98,21.36 121.14,22.2 121.14,27.92 120.98,28.08 120.31,28.08 120.15,28.24 120.15,28.46 120.31,28.62 120.98,28.62 121.14,28.78 121.14,29 120.98,29.16 119.95,29.16 119.79,29.31 119.79,29.54 119.95,29.69 120.98,29.69 121.14,29.85 121.14,30.08 120.98,30.23 119.95,30.23 119.79,30.39 119.79,30.61 119.95,30.77 120.98,30.77 121.14,30.93 121.14,31.15 120.98,31.31 119.75,31.31 119.59,31.47 119.59,31.69 119.75,31.85 120.28,31.85 120.48,32.05 120.48,34.42 120.05,34.85 119.39,34.85 118.98,35.26 118.98,36.25 117.36,37.87 116.08,37.87 114.12,39.84 114.12,45.89 v1(114.52,46.29)
  L12_SIG4 w0.089: v1(79.79,20.96) 80.17,20.7 80.52,20.56 90.65,20.56 91.35,20.7 v1(91.98,20.96) 92.36,20.7 92.71,20.56 102.84,20.56 103.55,20.7 v1(104.17,20.96) 104.56,20.7 104.9,20.56 115.03,20.56 115.74,20.7 v1(116.36,20.96) 116.75,20.7 117.09,20.56 127.22,20.56 127.93,20.7 v1(128.56,20.96)
  BOTTOM w0.149: R187.2 81.74,20.96 81.34,21.36 80.19,21.36 v1(79.79,20.96)
DDR4_COMP_CK_N: length 100.2
  L05_SIG2 w0.076: 117.15,41.32 117.15,41.34 117.15,41.35 117.15,41.83 117.31,42.1 arc(117.33,42.2) 117.3,42.3 117.22,42.4 arc(117.15,42.61) 117.22,42.83 arc(117.29,43.01) 117.25,43.2 117.17,43.37 arc(117.13,43.57) 117.2,43.76 117.26,43.86 arc(117.3,43.99) 117.26,44.12 117.21,44.2 arc(117.13,44.46) 117.19,44.73 117.22,44.77 arc(117.26,44.93) 117.21,45.09 117.18,45.15 arc(117.12,45.35) 117.17,45.55 117.25,45.68 arc(117.28,45.81) 117.26,45.94 117.2,46.09 arc(117.17,46.18) 117.16,46.27 117.16,46.5 v1(116.91,46.75)
  L05_SIG2 w0.081: 117.15,41.32 117.15,40.96 117.43,40.68 122.61,40.68 122.92,40.99 122.92,41.83 123.13,42.03 123.7,42.03 123.9,41.83 123.9,40.99 124.21,40.68 124.5,40.68 124.7,40.48 124.7,39.96 124.5,39.76 120.63,39.76 120.28,39.41 120.28,38.83 120.63,38.48 124.93,38.48 125.17,38.24 125.17,37.61 124.97,37.41 123.86,37.41 123.65,37.2 123.65,36.02 123.86,35.81 125.95,35.81 126.16,35.61 126.16,23.53 126.68,23.01 127.32,23.01 127.62,22.71 128.12,22.71 128.36,22.94 128.36,23.16 v1(128.56,23.36)
  L12_SIG4 w0.089: v1(79.79,23.36) 79.97,23.54 80.07,23.54 80.17,23.5 80.27,23.43 80.5,23.2 80.71,23.06 80.93,22.97 91.23,22.97 91.67,23.15 v1(91.98,23.36) 92.16,23.54 92.26,23.54 92.36,23.5 92.46,23.43 92.7,23.2 92.9,23.06 93.13,22.97 103.42,22.97 103.86,23.15 v1(104.17,23.36) 104.36,23.54 104.45,23.54 104.55,23.5 104.66,23.43 104.89,23.2 105.1,23.06 105.32,22.97 115.61,22.97 116.06,23.15 v1(116.36,23.36) 116.55,23.54 116.64,23.54 116.74,23.5 116.85,23.43 117.08,23.2 117.29,23.06 117.51,22.97 127.8,22.97 128.25,23.15 v1(128.56,23.36)
  BOTTOM w0.149: R202.2 78.62,23.75 79.39,23.75 v1(79.79,23.36)
DDR4_COMP_CK_P: length 100.3
  L05_SIG2 w0.076: v1(117.7,46.29) 117.53,46.46 117.41,46.46 117.34,46.38 117.34,46.27 arc(117.34,46.21) 117.36,46.16 117.42,46.01 arc(117.46,45.8) 117.4,45.59 117.33,45.46 arc(117.3,45.35) 117.33,45.24 117.37,45.18 arc(117.43,44.94) 117.37,44.69 117.35,44.65 arc(117.31,44.47) 117.36,44.3 117.41,44.22 arc(117.48,43.99) 117.41,43.76 117.35,43.66 arc(117.31,43.56) 117.33,43.45 117.41,43.28 arc(117.46,43) 117.36,42.72 arc(117.33,42.61) 117.36,42.5 117.44,42.4 arc(117.51,42.21) 117.46,42.01 117.33,41.78 117.33,41.35 117.33,41.34 117.33,41.32
  L05_SIG2 w0.081: 117.33,41.32 117.33,41.04 117.51,40.86 122.54,40.86 122.74,41.07 122.74,41.91 123.05,42.22 123.77,42.22 124.08,41.91 124.08,41.07 124.29,40.86 124.58,40.86 124.88,40.56 124.88,39.88 124.58,39.58 120.71,39.58 120.46,39.33 120.46,38.9 120.71,38.66 125.01,38.66 125.36,38.31 125.36,37.54 125.05,37.23 123.93,37.23 123.83,37.13 123.83,36.1 123.93,35.99 126.03,35.99 126.34,35.68 126.34,23.61 126.75,23.19 127.4,23.19 127.7,22.89 128.05,22.89 128.18,23.02 128.18,23.42 128.05,23.54 127.94,23.54 v1(127.76,23.36)
  L12_SIG4 w0.089: v1(78.99,23.36) 79.27,23.55 79.72,23.73 80.1,23.73 80.26,23.67 80.39,23.58 80.63,23.35 80.8,23.23 80.97,23.16 90.98,23.16 v1(91.18,23.36) 91.46,23.55 91.91,23.73 92.3,23.73 92.45,23.67 92.59,23.58 92.82,23.35 93,23.23 93.16,23.16 103.17,23.16 v1(103.37,23.36) 103.65,23.55 104.1,23.73 104.49,23.73 104.64,23.67 104.78,23.58 105.01,23.35 105.19,23.23 105.36,23.16 115.36,23.16 v1(115.56,23.36) 115.85,23.55 116.3,23.73 116.68,23.73 116.83,23.67 116.97,23.58 117.2,23.35 117.38,23.23 117.55,23.16 127.56,23.16 v1(127.76,23.36)
  BOTTOM w0.149: v1(78.99,23.36) 78.12,23.36 R200.2
DDR4_COMP_CKE: length 99.2
  TOP w0.149: U19.G3 v1(76.42,22.56) ; U15.G3 v1(125.06,22.56) ; U18.G3 v1(88.49,22.56) ; U17.G3 v1(100.68,22.56) ; U16.G3 v1(112.87,22.56)
  L03_SIG1 w0.081: v1(125.06,22.56) 124.1,22.16 113.5,22.16 113.33,22.23 112.95,22.48 v1(112.87,22.56)
  L07_SIG3 w0.089: v1(76.42,22.56) 76.51,22.48 76.84,22.25 77.07,22.16 87.52,22.16 v1(88.49,22.56) 88.57,22.48 88.91,22.25 89.13,22.16 99.71,22.16 v1(100.68,22.56) 100.76,22.48 101.1,22.25 101.32,22.16 111.91,22.16 v1(112.87,22.56) ; v1(125.06,22.56) 124.66,22.56 123.36,23.86 123.36,27.59 122.44,28.51 122.44,36.02 122.28,36.17 121.8,36.17 121.62,36 121.62,33.71 121.45,33.53 121.11,33.53 120.94,33.71 120.94,36.15 120.76,36.33 120.32,36.33 120.15,36.15 120.15,33.71 119.97,33.53 119.36,33.53 119.18,33.71 119.18,34.19 119.01,34.36 118.22,34.36 118.04,34.54 118.04,34.79 118.22,34.96 118.78,34.96 118.96,35.14 118.96,35.9 118.78,36.07 116.82,36.07 116.59,36.29 116.59,38.23 114.91,39.91 114.91,46.99 115.15,47.23 115.55,47.23 116.11,47.78 v1(116.11,48.13)
  BOTTOM w0.149: R198.2 76.83,23.75 76.83,22.97 R201.1
DDR4_COMP_CS_N: length 98.8
  TOP w0.149: U17.G7 v1(102.86,22.56) ; U16.G7 v1(115.06,22.56) ; U18.G7 v1(90.67,22.56) ; U19.G7 v1(78.35,22.56) ; U15.G7 v1(127.25,22.56)
  L07_SIG3 w0.089: v1(114.52,48.13) 115.56,48.13 116.01,48.58 116.27,48.58 116.68,48.17 117.04,48.17 117.31,47.9 117.31,40.96 118.29,39.97 125.52,39.97 125.99,39.5 125.99,39.12 125.84,38.97 124.77,38.97 124.62,38.83 124.62,38.62 124.77,38.48 126.3,38.48 126.45,38.33 126.45,38.13 126.3,37.98 124.77,37.98 124.62,37.84 124.62,37.63 124.77,37.49 126.41,37.49 126.56,37.34 126.56,37.14 126.41,36.99 124.77,36.99 124.62,36.85 124.62,36.64 124.77,36.5 126.41,36.5 126.56,36.35 126.56,23.25 v1(127.25,22.56)
  L14_SIG5 w0.081: v1(127.25,22.56) 127.17,22.64 126.83,22.86 126.6,22.96 116.24,22.96 115.82,22.87 v1(115.06,22.56) 114.98,22.64 114.64,22.86 114.41,22.96 104.05,22.96 103.63,22.87 v1(102.86,22.56) 102.79,22.64 102.45,22.86 102.21,22.96 91.86,22.96 91.44,22.87 v1(90.67,22.56) 90.59,22.64 90.26,22.86 90.02,22.96 79.84,22.96 78.84,22.76 v1(78.35,22.56)
DDR4_COMP_DBI_N0: length 76
  L12_SIG4 w0.089: v1(78.99,27.36) 79.47,27.84 81.31,27.84 83.65,30.18 83.65,31.02 84.61,31.98 85.12,31.98 85.33,32.18 85.33,32.46 85.16,32.63 85.16,32.78 85.37,32.99 85.51,32.99 86.08,32.42 86.22,32.42 86.44,32.63 86.44,32.78 85.99,33.22 85.99,33.36 86.18,33.55 86.32,33.55 86.64,33.23 88.83,33.23 88.96,33.35 88.96,33.63 88.86,33.73 87.84,33.73 87.74,33.83 87.74,34.11 87.84,34.22 90.71,34.22 90.81,34.11 90.81,33.83 90.71,33.73 89.64,33.73 89.54,33.63 89.54,33.33 89.64,33.23 90.79,33.23 91.35,33.78 91.57,33.78 91.85,34.06 92,34.06 92.79,34.85 93.05,34.85 93.15,34.95 93.15,35.44 93.25,35.54 93.48,35.54 93.58,35.44 93.58,34.95 93.68,34.85 94.19,34.85 94.75,35.41 94.75,35.61 95.73,36.59 95.73,36.82 96.42,37.52 96.57,37.52 96.67,37.42 96.67,37.19 96.77,37.09 96.91,37.09 97.01,37.19 97.01,37.6 97.11,37.7 97.25,37.7 97.35,37.6 97.35,37.19 97.45,37.09 97.59,37.09 97.69,37.19 97.69,37.6 97.79,37.7 97.94,37.7 98.04,37.6 98.04,37.19 98.14,37.09 98.28,37.09 98.38,37.19 98.38,37.6 98.48,37.7 98.69,37.7 98.79,37.6 98.79,37.19 98.89,37.09 99.14,37.09 99.24,37.19 99.24,37.6 99.35,37.7 99.6,37.7 99.7,37.6 99.7,37.19 99.8,37.09 100.03,37.09 100.13,37.19 100.13,37.6 100.23,37.7 100.49,37.7 100.59,37.6 100.59,37.19 100.69,37.09 100.97,37.09 101.1,37.21 101.1,38.08 101.38,38.36 102.47,38.36 102.65,38.18 102.65,37.87 102.78,37.75 102.96,37.75 103.06,37.85 103.06,38.28 103.16,38.38 103.44,38.38 103.54,38.28 103.54,37.7 103.74,37.49 103.74,37.26 103.84,37.16 104.07,37.16 104.17,37.26 104.17,37.54 104.3,37.67 106.46,37.67 106.74,37.95 106.85,37.95 106.95,38.05 106.95,38.26 107.05,38.36 107.19,38.36 107.29,38.26 107.29,38.05 107.39,37.95 107.54,37.95 107.64,38.05 107.64,38.26 107.74,38.36 107.88,38.36 107.98,38.26 107.98,38.05 108.08,37.95 108.22,37.95 108.32,38.05 108.32,38.26 108.42,38.36 108.56,38.36 108.67,38.26 108.67,38.05 108.77,37.95 108.91,37.95 109.01,38.05 109.01,38.26 109.11,38.36 109.25,38.36 109.35,38.26 109.35,38.05 109.45,37.95 109.59,37.95 109.69,38.05 109.69,38.26 109.79,38.36 109.94,38.36 110.04,38.26 110.04,38.05 110.14,37.95 110.28,37.95 110.38,38.05 110.38,38.26 110.48,38.36 110.62,38.36 110.72,38.26 110.72,38.05 110.82,37.95 111.13,37.95 111.26,38.08 111.26,38.37 111.81,38.92 113.32,38.92 113.42,38.82 113.42,38.58 113.32,38.48 111.89,38.48 111.79,38.38 111.79,38.15 111.89,38.05 113.42,38.05 114.11,38.74 114.11,39 114.31,39.19 114.56,39.19 114.85,39.48 114.85,39.74 115.07,39.96 115.32,39.96 115.46,40.1 115.46,40.43 115.68,40.64 116.01,40.64 116.31,40.95 116.31,41.18 116.16,41.33 115.93,41.33 115.7,41.56 115.7,42.82 115.92,43.04 116.18,43.04 116.34,43.2 116.52,43.51 116.52,44.96 v1(116.11,45.37)
DDR4_COMP_DBI_N1: length 35.3
  L14_SIG5 w0.081: v1(115.56,27.36) 115.95,26.97 117.57,26.97 118.32,27.72 118.48,27.72 118.59,27.61 118.59,27.45 118.07,26.93 118.07,26.77 118.18,26.66 118.34,26.66 118.52,26.83 118.7,26.83 118.86,26.67 119.04,26.67 119.19,26.82 119.19,27 119.03,27.16 119.03,27.34 119.17,27.49 119.35,27.49 119.51,27.33 119.69,27.33 119.84,27.48 119.84,27.65 119.68,27.81 119.68,27.99 120.01,28.32 120.01,28.48 119.9,28.59 119.74,28.59 119.03,27.89 118.87,27.89 118.76,28 118.76,28.16 119.37,28.77 119.37,31.47 122.63,34.73 122.63,35.33 124.92,37.62 124.92,44.79 122.95,46.76 122.25,46.76 121.81,47.21 121.5,47.21 120.89,47.82 v1(120.89,48.13)
DDR4_COMP_DBI_N2: length 48
  L14_SIG5 w0.081: v1(103.37,27.36) 102.93,27.8 102.52,27.8 102.33,27.99 102.33,29.24 102.11,29.46 99.54,29.46 99.42,29.58 99.42,29.87 99.54,30 102.52,30 102.68,30.15 102.68,30.39 102.52,30.54 99.62,30.54 99.47,30.69 99.47,30.93 99.62,31.08 103.07,31.08 103.22,31.23 103.22,31.47 103.07,31.62 101.8,31.62 101.64,31.77 101.64,32 101.8,32.16 103.41,32.16 104.14,32.89 104.36,32.89 104.53,32.73 104.53,32.51 103.9,31.88 103.9,31.67 104.06,31.5 104.28,31.5 105.29,32.51 105.29,32.73 104.74,33.27 104.74,33.49 105.07,33.82 105.07,36.22 105.27,36.42 105.27,37.41 105.48,37.62 113.24,37.62 113.67,38.04 115.15,38.04 118.1,40.98 118.1,42.83 117.7,43.23 v1(117.7,43.53)
DDR4_COMP_DBI_N3: length 60.5
  L12_SIG4 w0.089: v1(120.89,45.37) 121.86,45.37 122.35,44.88 123.96,44.88 124.29,44.55 124.29,41.35 124.42,41.23 124.63,41.23 124.76,41.35 124.76,44.15 124.89,44.27 125.1,44.27 125.23,44.15 125.23,41.73 126.25,40.72 126.25,32.46 123.32,29.54 114.05,29.54 113.67,29.92 97.93,29.92 95.75,27.74 91.56,27.74 v1(91.18,27.36)
DDR4_COMP_DBI_N4: length 41.1
  L14_SIG5 w0.081: v1(127.76,27.36) 127.32,27.8 127.32,28.02 128.16,28.87 128.16,29.38 128.28,29.49 128.91,29.49 129.02,29.6 129.02,29.77 128.9,29.88 128.17,29.88 128.05,30 128.05,30.16 128.17,30.27 129.07,30.27 129.18,30.38 129.18,30.54 129.07,30.66 128.08,30.66 127.97,30.77 127.97,30.93 128.08,31.04 129.08,31.04 129.19,31.16 129.19,31.32 129.08,31.43 128.06,31.43 127.95,31.54 127.95,31.7 128.06,31.82 128.86,31.82 128.98,31.93 128.98,46.69 123.94,51.73 123.08,51.73 122.59,52.22 122.23,52.22 121.85,51.84 121.46,51.84 121.07,52.24 120.62,52.24 120.26,51.88 119.9,51.88 119.6,51.58 119.6,51.24 119.9,50.94 120.24,50.94 120.6,51.3 120.81,51.3 120.89,51.23 v1(120.89,50.89)
DDR4_COMP_DQ0: length 75.9
  L12_SIG4 w0.089: v1(74.99,25.76) 74.59,26.16 74.59,27.61 75.8,28.83 75.8,31.57 76.31,32.07 76.31,32.25 76.21,32.36 75.9,32.36 75.8,32.46 75.8,32.64 75.9,32.74 76.21,32.74 76.31,32.84 76.31,33.02 76.21,33.12 75.9,33.12 75.8,33.22 75.8,33.52 75.9,33.63 76.21,33.63 76.31,33.73 76.31,34.03 76.21,34.13 75.9,34.13 75.8,34.23 75.8,34.54 75.9,34.64 76.21,34.64 76.31,34.74 76.31,35.05 76.21,35.15 75.9,35.15 75.8,35.25 75.8,35.56 75.9,35.66 76.21,35.66 76.31,35.76 76.31,36.06 76.21,36.17 75.9,36.17 75.8,36.27 75.8,36.57 75.9,36.67 76.21,36.67 76.31,36.77 76.31,37.26 77.73,38.69 79.92,38.69 80.02,38.59 80.02,38.28 79.92,38.18 78.72,38.18 78.62,38.08 78.62,37.77 78.72,37.67 79.26,37.67 79.45,37.48 79.45,36.76 79.55,36.65 79.81,36.65 79.92,36.76 79.92,37.57 80.02,37.67 80.32,37.67 80.42,37.57 80.42,36.83 80.52,36.73 80.86,36.73 80.96,36.83 80.96,37.63 81.05,37.72 81.33,37.72 81.41,37.63 81.41,36.95 81.5,36.86 81.78,36.86 81.87,36.95 81.87,37.49 82.05,37.67 82.66,37.67 82.76,37.77 82.76,38.08 82.66,38.18 80.63,38.18 80.53,38.28 80.53,38.59 80.63,38.69 85.61,38.69 85.94,39.02 86.65,39.02 86.75,38.92 86.75,38.03 86.85,37.92 87.41,37.92 87.51,38.03 87.51,38.92 87.69,39.09 90.91,39.09 91.62,38.38 93.43,38.38 93.56,38.51 93.56,38.99 94.34,39.78 94.85,39.78 94.95,39.88 94.95,40.26 95.05,40.36 95.36,40.36 95.46,40.26 95.46,39.85 95.61,39.7 95.87,39.7 96.02,39.86 96.02,40.19 96.27,40.44 100.54,40.44 100.91,40.06 110.36,40.06 111.07,40.77 112.81,40.77 113.32,41.28 113.32,43.58 v1(113.72,43.99)
DDR4_COMP_DQ1: length 72.7
  L12_SIG4 w0.089: v1(78.99,26.56) 79.38,26.95 79.94,26.95 80.12,27.13 80.27,27.13 80.45,26.95 80.76,26.95 80.98,26.72 81.16,26.72 81.26,26.82 81.26,27.39 81.36,27.49 81.62,27.49 81.72,27.39 81.72,26.62 81.82,26.52 82.05,26.52 82.15,26.62 82.15,26.8 82.25,26.9 82.51,26.9 82.61,26.8 82.61,26.47 82.73,26.34 82.96,26.34 83.07,26.44 83.07,28.96 83.24,29.14 83.52,29.14 83.7,29.31 83.7,29.59 83.88,29.77 84.16,29.77 84.28,29.9 84.28,30.14 84.01,30.42 84.01,30.56 84.21,30.77 84.36,30.77 84.59,30.53 84.74,30.53 84.92,30.72 84.92,30.86 84.55,31.24 84.55,31.38 84.77,31.61 84.91,31.61 85.29,31.23 85.43,31.23 85.58,31.37 85.58,31.91 85.73,32.06 86.44,32.06 87.26,32.87 90.96,32.87 91.29,33.2 91.7,33.2 92.03,32.87 93.2,32.87 93.3,32.97 93.3,33.25 93.2,33.35 92.31,33.35 92.21,33.45 92.21,33.76 92.95,34.5 93.1,34.5 93.21,34.38 93.21,34.2 93.04,34.03 93.04,33.85 93.13,33.76 93.3,33.76 93.93,34.38 94.1,34.38 94.25,34.23 94.25,34.05 93.81,33.61 93.81,33.43 93.96,33.28 94.14,33.28 94.93,34.06 94.93,34.67 95.1,34.85 95.41,34.85 95.64,35.08 95.64,35.61 96.25,36.23 96.25,36.37 96.09,36.53 96.09,36.68 96.28,36.87 96.43,36.87 96.59,36.71 101.15,36.71 101.45,37.01 101.45,37.54 101.68,37.77 102.24,37.77 102.47,37.54 102.47,36.93 102.67,36.73 104.48,36.73 104.6,36.86 104.6,37.21 104.71,37.32 104.85,37.32 104.95,37.21 104.95,36.78 105.05,36.68 105.19,36.68 105.29,36.78 105.29,37.21 105.39,37.32 105.53,37.32 105.63,37.21 105.63,36.78 105.73,36.68 105.88,36.68 105.98,36.78 105.98,37.21 106.08,37.32 106.22,37.32 106.32,37.21 106.32,36.78 106.42,36.68 106.56,36.68 106.66,36.78 106.66,37.21 106.76,37.32 106.96,37.32 107.06,37.21 107.06,36.43 107.16,36.32 107.3,36.32 107.4,36.43 107.4,37.49 107.5,37.59 107.65,37.59 107.75,37.49 107.75,36.73 107.85,36.63 107.99,36.63 108.09,36.73 108.09,37.49 108.19,37.59 108.33,37.59 108.43,37.49 108.43,37.19 108.53,37.09 108.67,37.09 108.77,37.19 108.77,37.49 108.88,37.59 110.45,37.59 110.64,37.4 110.76,37.4 110.95,37.59 111.46,37.59 111.56,37.49 111.56,37.11 111.66,37.01 111.84,37.01 111.94,37.11 111.94,37.49 112.04,37.59 112.22,37.59 112.32,37.49 112.32,37.11 112.42,37.01 112.57,37.01 112.67,37.11 112.67,37.49 112.77,37.59 112.91,37.59 113.09,37.42 113.21,37.42 113.39,37.59 113.53,37.59 116.95,41.01 116.95,41.56 116.5,42 116.5,43.1 116.77,43.56 116.91,43.89 v1(116.91,43.99)
DDR4_COMP_DQ2: length 76
  L12_SIG4 w0.089: v1(114.52,44.45) 114.52,44.24 114.11,43.84 114.11,41.16 113.29,40.34 111.28,40.34 110.63,39.69 100.65,39.69 100.41,39.45 96.66,39.45 96.39,39.18 96.11,39.18 95.92,38.99 95.29,38.99 95.21,39.07 95.21,39.29 95.08,39.42 94.5,39.42 93.94,38.86 93.94,38.1 93.83,38 93.83,36.99 93.73,36.88 93.59,36.88 93.49,36.98 93.49,37.9 93.39,38 93.24,38 93.14,37.9 93.14,36.98 93.04,36.88 92.69,36.88 92.3,37.27 91.99,37.27 91.88,37.16 91.88,36.3 91.68,36.1 89.51,36.1 89.32,36.29 89.13,36.29 88.94,36.1 88.76,36.1 88.66,36.2 88.66,36.91 88.55,37.01 88.39,37.01 88.26,36.88 88.26,36.2 88.16,36.1 87.89,36.1 87.79,36.2 87.79,37.42 87.69,37.52 87.43,37.52 87.33,37.42 87.33,36.5 87.23,36.4 86.67,36.4 86.44,36.63 86.29,36.63 86.19,36.53 86.19,35.92 86.09,35.82 85.91,35.82 85.81,35.92 85.81,36.76 85.71,36.86 85.53,36.86 85.43,36.76 85.43,35.46 85.33,35.36 85.15,35.36 85.05,35.46 85.05,36.53 84.95,36.63 84.39,36.63 84.13,36.38 83.78,36.38 83.52,36.63 83.14,36.63 82.94,36.43 82.68,36.43 82.48,36.63 82.08,36.63 81.28,35.83 80.88,35.83 80.78,35.93 80.78,36.25 80.68,36.35 80.37,36.35 80.27,36.25 80.27,35.93 80.17,35.83 79.98,35.83 79.88,35.93 79.88,36.2 79.78,36.3 79.6,36.3 79.5,36.2 79.5,35.93 79.4,35.83 79.22,35.83 79.05,35.99 79.05,36.3 78.44,36.91 78.44,37.21 78.24,37.42 77.76,37.42 77.53,37.19 77.53,36.93 77.43,36.83 77.24,36.83 77.14,36.93 77.14,37.16 77.01,37.29 76.83,37.29 76.72,37.17 76.72,29.16 76.16,28.6 76.16,28.04 76,27.89 75.52,27.89 75.42,27.79 75.42,27.51 75.52,27.41 77.07,27.41 77.17,27.31 77.17,27.16 77.07,27.05 75.72,27.05 75.39,26.72 75.39,25.36 v1(75.79,24.96)
DDR4_COMP_DQ3: length 74.6
  L12_SIG4 w0.089: v1(78.99,24.96) 78.49,24.46 77.63,24.46 77.44,24.27 77.44,23.95 77.57,23.83 78.31,23.83 78.4,23.74 78.4,23.12 78.3,23.02 76.99,23.02 76.81,23.2 76.81,23.63 76.61,23.83 76.46,23.83 76.33,23.95 76.33,24.34 76.46,24.46 76.72,24.46 77.22,24.97 78.49,24.97 78.65,25.12 78.65,25.32 78.52,25.45 77.12,25.45 76.99,25.58 76.99,25.76 77.1,25.86 78.47,25.86 78.77,26.16 80.77,26.16 80.93,26.32 81.52,26.32 81.85,25.99 83,25.99 83.13,25.86 83.13,25.71 83.03,25.61 82.02,25.61 81.92,25.51 81.92,25.33 82.02,25.22 83.55,25.22 83.65,25.33 83.65,27.62 86.08,30.05 86.08,30.21 85.96,30.33 85.8,30.33 84.82,29.35 84.66,29.35 84.54,29.46 84.54,29.62 87.43,32.51 93.91,32.51 95.99,34.6 95.99,35.46 96.86,36.32 106.16,36.32 106.54,35.95 106.97,35.95 107.07,35.85 107.07,35.49 107.17,35.38 107.6,35.38 107.7,35.49 107.7,35.85 108.51,36.65 113.88,36.65 114.21,36.98 114.21,37.72 117.3,40.82 117.3,42.52 117.13,42.82 117.13,43.65 117.3,43.95 117.3,45.43 v1(116.91,45.83)
DDR4_COMP_DQ4: length 72.4
  L12_SIG4 w0.089: v1(114.52,45.37) 114.23,45.08 114.23,44.81 113.86,44.44 112.94,44.44 111.92,43.41 111.92,42.62 112.66,41.89 112.66,41.51 112.33,41.18 110.93,41.18 110.16,40.4 101.27,40.4 100.81,40.87 94.7,40.87 94.29,40.46 94.29,40.29 93.43,39.42 91.99,39.42 91.9,39.51 91.9,39.77 91.99,39.86 93.29,39.86 93.38,39.94 93.38,40.15 93.29,40.24 88.87,40.24 88.78,40.15 88.78,39.94 88.87,39.86 91.4,39.86 91.49,39.77 91.49,39.54 91.4,39.45 85.58,39.45 85.27,39.14 76,39.14 74.42,37.56 74.42,37.42 74.68,37.17 74.82,37.17 75.58,37.93 75.72,37.93 75.97,37.68 75.97,37.54 75.44,37 75.44,29.19 73.79,27.55 73.79,25.56 73.99,25.36 74.59,25.36 v1(74.99,24.96)
DDR4_COMP_DQ5: length 73.1
  L12_SIG4 w0.089: v1(117.7,44.45) 117.7,44.07 117.45,43.82 117.34,43.62 117.34,43.44 117.47,43.2 117.62,43.06 117.8,43.06 117.96,42.89 118.12,42.62 118.12,41.99 118.5,41.61 118.5,41 118.35,40.85 117.99,40.85 116.94,39.8 116.94,39.66 117.09,39.51 117.24,39.51 118.13,40.41 118.28,40.41 118.4,40.28 118.4,39.88 116.52,38 116.34,38 116.16,38.18 116.16,38.33 116.78,38.95 116.78,39.09 116.58,39.29 116.43,39.29 115.12,37.98 115.12,36.99 114.43,36.3 109.07,36.3 108.82,36.05 108.82,34.96 108.69,34.83 108.51,34.83 108.31,35.03 107.83,35.03 107.73,34.93 107.73,34.39 107.63,34.29 107,34.29 106.9,34.39 106.9,34.93 106.8,35.03 104.5,35.03 104.38,35.16 104.38,35.38 104.5,35.5 105.87,35.5 106,35.63 106,35.85 105.87,35.97 102.75,35.97 102.52,35.74 102.34,35.74 102.11,35.97 101.86,35.97 101.58,35.69 101.38,35.69 101.09,35.97 100.85,35.97 100.59,35.72 100.36,35.72 100.1,35.97 99.62,35.97 99.52,35.87 99.52,35.43 99.42,35.33 98.71,35.33 98.61,35.43 98.61,35.87 98.51,35.97 98.03,35.97 97.79,35.74 97.52,35.74 97.28,35.97 97.04,35.97 96.35,35.29 96.35,34.32 93.96,31.93 87.51,31.93 86.41,30.83 86.41,30.67 86.53,30.55 86.69,30.55 87.62,31.48 87.78,31.48 87.9,31.36 87.9,31.2 84.03,27.33 84.03,25.18 83.62,24.77 83.62,24.21 83.52,24.11 83.32,24.11 83.22,24.21 83.22,24.77 83.12,24.87 82.43,24.87 82.33,24.77 82.33,24.46 82.23,24.36 81.79,24.36 81.69,24.46 81.69,24.95 81.28,25.36 80.19,25.36 v1(79.79,24.96)
DDR4_COMP_DQ6: length 72.4
  L12_SIG4 w0.089: v1(75.79,24.16) 75.39,24.56 73.99,24.56 72.91,25.64 72.91,27.32 72.82,27.41 72.49,27.41 72.4,27.32 72.4,26.23 72.31,26.14 71.85,26.14 71.76,26.23 71.76,27.51 72.7,28.45 74.18,28.45 75.09,29.37 75.09,35.69 73.87,36.91 73.87,37.72 73.59,38 72.66,38 72.57,38.09 72.57,38.55 72.66,38.64 74.34,38.64 74.45,38.75 74.45,39.06 74.34,39.17 73.06,39.17 72.96,39.27 72.96,39.53 73.06,39.63 85.15,39.63 85.45,39.93 88.04,39.93 88.73,40.62 93.68,40.62 94.35,41.29 95.88,41.29 96.07,41.48 102.9,41.48 103.59,40.8 109.79,40.8 110.19,41.2 110.19,42.3 v1(113.72,45.83)
DDR4_COMP_DQ7: length 74.3
  L12_SIG4 w0.089: v1(78.99,24.16) 78.99,24.42 79.33,24.77 79.45,24.77 79.66,24.56 79.95,24.56 80.09,24.41 80.3,24.41 80.45,24.56 80.77,24.56 80.96,24.74 80.96,24.87 81.03,24.95 81.19,24.95 81.31,24.82 81.31,24.54 81.01,24.24 81.01,24.08 81.14,23.95 82,23.95 82.23,23.73 83.78,23.73 84.39,24.34 84.39,27.1 88.83,31.55 94.37,31.55 96.73,33.91 96.73,34.7 97.02,34.99 102.16,34.99 102.42,34.72 102.56,34.72 102.63,34.8 102.63,34.95 102.74,35.05 102.88,35.05 102.98,34.95 102.98,34.67 103.08,34.57 103.23,34.57 103.33,34.67 103.33,34.89 103.43,34.99 103.96,34.99 105.04,33.91 105.59,33.91 105.87,34.19 106.13,34.19 106.41,33.91 110.4,33.91 110.7,34.22 110.7,34.75 110.47,34.98 109.91,34.98 109.74,35.16 109.74,35.77 109.89,35.92 110.42,35.92 110.6,35.74 110.78,35.74 110.95,35.92 111.46,35.92 111.59,35.79 111.59,34.85 111.69,34.75 112.03,34.75 112.15,34.87 112.15,35.71 112.23,35.79 112.54,35.79 112.66,35.68 112.66,34.87 112.77,34.75 113.09,34.75 113.24,34.9 113.24,35.79 113.37,35.92 114.08,35.92 114.26,35.74 114.26,35.21 114.51,34.95 115.32,34.95 115.45,35.08 115.45,35.88 115.06,36.26 115.06,36.4 115.19,36.52 115.33,36.52 115.79,36.06 115.97,36.06 116.12,36.21 116.12,36.39 115.52,36.99 115.52,37.87 115.65,38 115.83,38 115.98,37.85 115.98,37.7 116.11,37.57 116.24,37.57 116.44,37.37 116.69,37.37 116.93,37.6 117.28,37.6 117.36,37.68 117.36,37.82 117.18,38.01 117.18,38.15 117.28,38.25 117.42,38.25 117.61,38.06 117.75,38.06 117.85,38.17 117.85,38.31 117.66,38.5 117.66,38.64 117.76,38.74 117.9,38.74 118.09,38.55 118.23,38.55 118.33,38.65 118.33,38.79 118.15,38.98 118.15,39.12 118.25,39.22 118.39,39.22 118.5,39.11 118.64,39.11 118.75,39.22 118.75,40.13 118.88,40.26 118.88,40.62 118.98,40.72 119.36,40.72 119.46,40.82 119.46,41.1 119.36,41.2 118.98,41.2 118.88,41.3 118.88,42.42 118.65,42.65 118.36,42.65 118.27,42.74 118.12,43.01 118.12,44.95 v1(117.7,45.37)
DDR4_COMP_DQ8: length 36
  L14_SIG5 w0.081: v1(111.56,25.76) 111.16,26.16 109.44,26.16 109.27,26.32 109.27,27.47 109.92,28.11 110.1,28.11 110.43,27.78 110.61,27.78 110.76,27.92 110.76,28.1 110.42,28.44 110.42,28.62 112.25,30.45 113.31,30.45 116.87,34 117.51,34 118.98,35.48 118.98,35.85 120.35,37.22 120.35,37.4 120.2,37.55 120.02,37.55 119.08,36.61 118.9,36.61 118.75,36.75 118.75,36.93 121.65,39.83 121.65,41.57 122.07,41.99 122.07,43.27 121.81,43.53 121.47,43.53 120.99,44 120.73,44 120.29,44.44 119.86,44.44 119.38,44.92 119.14,44.92 118.92,45.14 118.92,46.32 v1(118.5,46.75)
DDR4_COMP_DQ9: length 33.8
  L14_SIG5 w0.081: v1(121.69,47.67) 122.67,47.67 125.39,44.95 125.39,37.55 125.07,37.22 125.07,37.04 125.35,36.76 125.35,36.62 125.16,36.44 125.02,36.44 124.74,36.72 124.56,36.72 124.41,36.57 124.41,36.39 124.79,36.02 124.79,35.84 124.64,35.69 124.46,35.69 124.09,36.06 123.91,36.06 123.02,35.18 123.02,34.49 119.92,31.39 119.92,29.64 120.46,29.11 120.46,26.69 120.12,26.36 119.61,26.36 119.48,26.23 119.48,25.92 119.36,25.79 118.89,25.79 118.76,25.92 118.76,26.18 118.66,26.28 117.7,26.28 117.56,26.15 115.97,26.15 v1(115.56,26.56)
DDR4_COMP_DQ10: length 35.9
  L14_SIG5 w0.081: v1(112.36,24.96) 111.96,25.36 111.96,26.92 112.25,27.21 112.25,27.46 111.14,28.57 111.14,28.75 111.29,28.9 111.47,28.9 112.24,28.13 112.42,28.13 112.56,28.28 112.56,28.46 111.75,29.27 111.75,29.45 111.9,29.59 112.08,29.59 112.51,29.17 112.68,29.17 112.83,29.32 112.83,29.5 112.6,29.73 112.6,29.91 112.75,30.06 112.92,30.06 113.46,29.52 113.72,29.52 114.12,29.92 114.12,30.1 113.91,30.31 113.91,30.49 114.06,30.64 114.24,30.64 114.45,30.43 114.63,30.43 114.78,30.57 114.78,30.75 114.56,30.97 114.56,31.15 116.69,33.28 117.7,33.28 120.08,35.65 120.08,36 120.82,36.75 120.82,38.24 122.11,39.53 122.11,41.38 122.95,42.21 122.95,43.72 122.66,44.01 122.3,44.01 121.92,44.39 121.55,44.39 121.04,44.89 120.68,44.89 120.2,45.37 119.92,45.37 119.59,45.7 119.59,46 v1(119.3,46.29)
DDR4_COMP_DQ11: length 33.7
  L14_SIG5 w0.081: v1(122.48,48.13) 122.83,48.13 125.81,45.15 125.81,36.37 120.81,31.37 120.81,25.07 120.66,24.92 120.19,24.92 120.09,25.02 120.09,25.17 119.96,25.3 119.67,25.3 119.54,25.17 119.54,24.88 119.41,24.75 119.13,24.75 119.01,24.88 119.01,25.23 118.88,25.35 118.67,25.35 118.54,25.23 118.54,25.04 118.42,24.91 118.03,24.91 117.6,25.34 115.95,25.34 v1(115.56,24.96)
DDR4_COMP_DQ12: length 37.1
  L14_SIG5 w0.081: v1(111.56,24.96) 111.16,25.36 110.45,25.36 110.28,25.19 110.28,24.4 110.16,24.27 109.97,24.27 109.84,24.4 109.84,25.25 109.71,25.38 109.5,25.38 109.38,25.25 109.38,24.4 109.25,24.27 109.01,24.27 108.87,24.41 108.87,27.67 112.1,30.9 113.29,30.9 117.65,35.26 117.65,35.69 118.24,36.28 118.24,37.19 121.03,39.97 121.03,41.19 121.31,41.47 121.31,42.74 120.94,43.1 120.67,43.1 120.25,43.52 119.94,43.52 119.48,43.98 119.18,43.98 118.73,44.43 118.37,44.43 118.1,44.7 118.1,47.27 v1(118.5,47.67)
DDR4_COMP_DQ13: length 37.1
  L14_SIG5 w0.081: v1(116.36,24.96) 116.77,24.55 117.48,24.55 117.97,24.06 121.06,24.06 121.17,24.16 121.17,31.23 126.15,36.22 126.15,45.3 122.9,48.55 122.3,48.55 121.92,48.18 121.45,48.18 121.08,48.55 120.67,48.55 120.25,48.13 v1(119.3,48.13)
DDR4_COMP_DQ14: length 33.6
  L14_SIG5 w0.081: v1(121.69,46.75) 121.69,46.47 122.4,45.76 122.73,45.76 124.19,44.31 124.19,39.51 122.26,37.59 122.26,36.19 121.74,35.67 121.74,35.26 118.47,31.99 118.47,30.22 116.86,28.62 114.94,28.62 114.36,28.04 114.36,24.26 114.27,24.17 114.02,24.17 113.93,24.26 113.93,25.68 113.84,25.77 113.62,25.77 113.53,25.68 113.53,24.77 113.44,24.68 112.88,24.68 v1(112.36,24.16)
DDR4_COMP_DQ15: length 33.6
  L14_SIG5 w0.081: v1(115.56,24.16) 115.16,24.56 115.16,27.99 115.3,28.12 116.75,28.12 116.93,27.93 117.89,27.93 119.01,29.05 119.01,29.21 118.89,29.32 118.73,29.32 117.76,28.35 117.6,28.35 117.49,28.47 117.49,28.63 118.91,30.05 118.91,31.84 122.18,35.11 122.18,35.45 124.53,37.8 124.53,38.09 124.41,38.21 123.84,38.21 123.73,38.32 123.73,38.55 123.84,38.66 124.41,38.66 124.53,38.78 124.53,44.45 122.69,46.29 v1(122.48,46.29)
DDR4_COMP_DQ16: length 44.6
  L14_SIG5 w0.081: v1(116.11,41.69) 116.11,41.41 114.56,39.86 103.76,39.86 103.38,39.48 101.47,39.48 101.17,39.18 101.17,37.08 101.6,36.65 102.25,36.65 102.45,36.46 102.45,35.11 102.32,34.98 101.58,34.98 101.46,35.11 101.46,36.03 101.26,36.23 100.67,36.23 100.49,36.05 100.49,35.14 100.36,35.02 99.44,35.02 99.29,35.17 99.29,35.84 99.13,35.99 98.9,35.99 98.75,35.84 98.75,35.17 98.59,35.02 96.92,35.02 95.28,33.38 95.28,26.83 95.74,26.37 96.67,26.37 97.26,26.96 98.74,26.96 98.97,26.73 98.97,26.36 99.37,25.96 v1(99.37,25.76)
DDR4_COMP_DQ17: length 45.5
  L14_SIG5 w0.081: v1(118.5,42.15) 118.5,40.86 115.23,37.59 114.42,37.59 114.14,37.31 114.14,36.93 113.9,36.69 106.13,36.69 106,36.56 106,36.12 106.13,36 108.63,36 108.76,35.86 108.76,34.15 108.94,33.97 108.94,33.8 108.66,33.52 108.45,33.52 107.91,34.07 107.69,34.07 106.36,32.73 106.36,32.52 106.52,32.35 106.74,32.35 107.7,33.32 107.92,33.32 108.08,33.15 108.08,32.94 105.29,30.14 105.07,30.14 104.91,30.31 104.91,30.52 106.2,31.82 106.2,32.03 106.03,32.2 105.82,32.2 102.72,29.1 102.72,28.96 102.96,28.72 103.11,28.72 104.35,29.97 104.57,29.97 104.73,29.8 104.73,29.59 103.77,28.63 103.77,26.96 v1(103.37,26.56)
DDR4_COMP_DQ18: length 46.7
  L14_SIG5 w0.081: v1(116.11,43.53) 116.49,43.15 116.49,41.25 114.66,39.42 103.96,39.42 103.59,39.05 101.82,39.05 101.69,38.92 101.69,38.66 101.82,38.53 103.02,38.53 103.14,38.4 103.14,38.2 103.02,38.07 101.83,38.07 101.71,37.94 101.71,37.72 101.83,37.59 103.2,37.59 103.45,37.35 103.45,36.91 103.3,36.77 103.3,34.14 103.12,33.96 96.86,33.96 95.72,32.82 95.72,28.71 96.63,27.79 99.54,27.79 99.78,27.56 99.78,25.55 100.17,25.16 v1(100.17,24.96)
DDR4_COMP_DQ19: length 47
  L14_SIG5 w0.081: v1(103.37,24.96) 103.77,25.36 103.77,25.96 103.97,26.16 104.37,26.16 104.57,26.36 104.57,26.77 104.76,26.96 105.23,26.96 105.62,27.36 105.62,28.18 105.3,28.51 105.1,28.51 104.56,27.96 104.41,27.96 104.23,28.14 104.23,28.28 106.34,30.4 106.53,30.4 106.67,30.26 106.67,30.07 105.68,29.08 105.68,28.89 105.81,28.75 106.01,28.75 108.01,30.76 108.01,30.95 107.88,31.09 107.68,31.09 107.21,30.61 107.02,30.61 106.88,30.75 106.88,30.94 108.93,32.98 109.12,32.98 109.25,32.85 109.25,32.66 108.19,31.59 108.19,31.4 108.33,31.26 108.52,31.26 109.68,32.42 109.68,33.18 109.81,33.31 110,33.31 110.14,33.18 110.14,32.21 109.6,31.66 109.6,31.49 109.7,31.39 109.88,31.39 110.6,32.11 110.6,33.64 110.47,33.78 109.81,33.78 109.68,33.91 109.68,35.69 110.07,36.08 114.71,36.08 115.31,36.68 115.31,37.12 118.92,40.73 118.92,42.65 v1(118.5,43.07)
DDR4_COMP_DQ20: length 47
  L14_SIG5 w0.081: v1(99.37,24.96) 99.17,24.96 98.77,25.36 98.15,25.36 97.31,24.51 94.75,24.51 94.25,25.02 94.25,33.22 94.04,33.43 94.04,34.75 94.29,35 94.58,35 94.71,35.13 94.71,35.4 95.98,36.66 95.98,38.26 96.11,38.4 96.52,38.4 96.62,38.3 96.62,37.21 96.74,37.09 97.04,37.09 97.16,37.21 97.16,38.28 97.28,38.39 97.66,38.39 97.78,38.28 97.78,37.42 97.89,37.31 98.26,37.31 98.39,37.44 98.39,40.18 98.63,40.41 103.03,40.41 103.28,40.67 112.77,40.67 114.26,42.16 114.61,42.16 114.92,42.47 114.92,42.67 v1(115.31,43.07)
DDR4_COMP_DQ21: length 45.7
  L14_SIG5 w0.081: v1(104.17,24.96) 104.57,25.36 105.31,25.36 105.41,25.46 105.41,26.2 105.58,26.37 105.89,26.37 106.03,26.5 106.03,28.08 106.69,28.74 106.88,28.74 107.02,28.6 107.02,28.41 106.56,27.95 106.56,25.22 106.68,25.1 106.91,25.1 107.03,25.22 107.03,26.81 107.16,26.94 107.58,26.94 107.7,27.07 107.7,27.27 107.58,27.4 107.16,27.4 107.03,27.53 107.03,27.77 109.01,29.75 109.01,29.94 108.88,30.08 108.68,30.08 107.55,28.95 107.36,28.95 107.22,29.08 107.22,29.27 109.1,31.15 109.29,31.15 109.43,31.02 109.43,30.82 109.19,30.59 109.19,30.4 109.33,30.26 109.52,30.26 111.18,31.92 111.18,33.79 111.05,33.92 110.81,33.92 110.67,34.05 110.67,34.99 110.77,35.1 111.42,35.1 111.54,35.21 111.54,35.54 111.65,35.65 111.98,35.65 112.09,35.54 112.09,34.68 112.21,34.57 112.44,34.57 112.55,34.68 112.55,35.54 112.66,35.65 112.92,35.65 113.04,35.54 113.04,35.21 113.15,35.1 114.87,35.1 115.42,35.65 115.42,35.88 116.59,37.04 116.59,37.53 119.68,40.62 119.68,42.23 v1(119.3,42.61)
DDR4_COMP_DQ22: length 45.2
  L14_SIG5 w0.081: v1(115.31,42.15) 114.97,41.8 114.97,41.51 113.75,40.29 103.57,40.29 103.18,39.9 100.77,39.9 100.52,39.64 100.52,36.76 100.37,36.6 99.88,36.6 99.73,36.76 99.73,38.36 99.58,38.51 99.19,38.51 99.04,38.36 99.04,36.83 98.67,36.47 96.67,36.47 95.96,35.75 95.96,35.07 94.75,33.86 94.75,25.78 95.36,25.17 96.55,25.17 97.54,26.16 98.77,26.16 98.97,25.96 98.97,25.56 99.17,25.36 99.52,25.36 99.77,25.11 99.77,24.56 v1(100.17,24.16)
DDR4_COMP_DQ23: length 47.2
  L14_SIG5 w0.081: v1(103.37,24.16) 103.77,24.56 105.31,24.56 105.41,24.46 105.41,24.11 105.52,24.01 105.7,24.01 105.83,24.14 105.83,24.87 105.97,25 106.16,25 106.3,24.87 106.3,24.14 106.43,24.01 106.88,24.01 107.01,24.13 107.01,24.59 107.14,24.72 107.34,24.72 107.47,24.59 107.47,24.13 107.6,24.01 108.08,24.01 108.19,24.12 108.19,24.98 108.07,25.11 107.58,25.11 107.45,25.24 107.45,25.45 107.58,25.57 108.07,25.57 108.19,25.7 108.19,25.91 108.07,26.04 107.58,26.04 107.45,26.16 107.45,26.37 107.58,26.5 108.07,26.5 108.19,26.63 108.19,27.82 112.25,31.88 112.25,32.05 112.12,32.17 111.71,32.17 111.55,32.34 111.55,33.97 111.66,34.08 112.09,34.08 112.2,33.97 112.2,33.03 112.32,32.92 112.61,32.92 112.72,33.03 112.72,34.03 112.83,34.14 113.14,34.14 113.26,34.03 113.26,33.66 113.37,33.55 113.66,33.55 114.22,34.1 114.41,34.1 114.55,33.97 114.55,33.77 113,32.23 113,32.03 113.13,31.9 113.33,31.9 115.28,33.85 115.28,34.54 115.75,35.01 116.34,35.01 116.66,35.33 116.66,35.76 117.67,36.77 117.67,37.52 120.14,40 120.14,41.57 120.49,41.92 120.49,42.34 120.19,42.64 119.87,42.64 119.3,43.21 v1(119.3,43.53)
DDR4_COMP_DQ24: length 59.9
  L12_SIG4 w0.089: v1(87.18,25.76) 86.78,26.16 86.78,27.59 87.94,28.76 87.94,29.44 88.89,30.39 94,30.39 97.6,33.99 101.48,33.99 102.12,33.35 102.5,33.35 102.62,33.47 102.62,33.89 102.75,34.01 102.97,34.01 103.09,33.89 103.09,33.47 103.22,33.35 103.44,33.35 103.56,33.47 103.56,33.89 103.69,34.01 103.91,34.01 104.03,33.89 104.03,33.47 104.16,33.35 112.97,33.35 113.09,33.46 113.09,33.63 112.97,33.74 111.48,33.74 111.36,33.86 111.36,34.02 111.48,34.14 113.3,34.14 113.52,33.92 113.52,33.53 113.7,33.35 113.97,33.35 114.09,33.46 114.09,34 114.2,34.11 114.37,34.11 114.48,34 114.48,33.46 114.6,33.35 114.76,33.35 114.87,33.46 114.87,34 114.99,34.11 115.15,34.11 115.27,34 115.27,33.46 115.38,33.35 115.55,33.35 115.66,33.46 115.66,33.85 115.78,33.96 115.94,33.96 116.06,33.85 116.06,33.46 116.17,33.35 116.46,33.35 116.69,33.58 116.69,36.62 116.83,36.76 116.99,36.76 117.13,36.62 117.13,36.19 117.27,36.05 117.51,36.05 118.04,36.58 118.04,37.52 118.65,38.13 119.08,38.13 119.31,38.36 119.31,39.88 120.02,40.59 120.02,41.61 119.68,41.95 119.68,42.81 119.42,43.07 119.2,43.07 118.79,43.48 118.79,43.7 v1(118.5,43.99)
DDR4_COMP_DQ25: length 57.2
  L12_SIG4 w0.089: v1(91.18,26.56) 91.58,26.96 93.05,26.96 93.29,27.2 95.79,27.2 97.91,29.31 100.41,29.31 100.64,29.54 101.86,29.54 102.24,29.16 111.64,29.16 112.02,29.54 113.42,29.54 113.93,29.03 123.55,29.03 126.75,32.24 126.75,42.88 126.63,43 126.41,43 126.28,42.88 126.28,42.12 126.16,41.99 125.94,41.99 125.81,42.12 125.81,44.33 124.77,45.37 v1(122.48,45.37)
DDR4_COMP_DQ26: length 57.4
  L12_SIG4 w0.089: v1(121.69,43.99) 122.09,43.59 122.09,42.29 122.32,42.06 122.32,39.82 124.59,37.54 124.59,37.29 124.34,37.04 123.67,37.04 123.5,36.87 123.5,36.57 123.67,36.4 124.38,36.4 124.57,36.21 124.57,35.96 124.38,35.77 123.21,35.77 122.87,35.42 122.87,34.58 123.21,34.24 124.16,34.24 124.59,33.81 124.59,33.07 122.67,31.15 97.32,31.15 94.94,28.77 90.77,28.77 89.44,27.44 89.44,25.79 88.82,25.17 88.19,25.17 v1(87.98,24.96)
DDR4_COMP_DQ27: length 57.5
  L12_SIG4 w0.089: v1(121.69,45.83) 125.07,45.83 127.26,43.64 127.26,32.01 123.9,28.65 97.79,28.65 95.46,26.32 93.35,26.32 93.19,26.16 91.78,26.16 91.58,25.96 91.58,25.36 v1(91.18,24.96)
DDR4_COMP_DQ28: length 62.1
  L12_SIG4 w0.089: v1(118.5,45.83) 118.91,45.42 118.91,44.16 119.09,43.97 119.49,43.97 119.91,43.55 120.21,43.55 120.49,43.27 120.49,35.77 120.36,35.64 120.23,35.64 120.1,35.77 120.1,39.7 119.97,39.83 119.82,39.83 119.69,39.7 119.69,36.4 119.56,36.27 119.21,36.27 119.08,36.4 119.08,37.54 118.95,37.67 118.74,37.67 118.61,37.54 118.61,36.49 117.81,35.69 117.81,35.33 117.18,34.7 117.18,33.33 116.72,32.87 97.13,32.87 94.31,30.05 89.08,30.05 88.37,29.34 88.37,28.68 87.58,27.89 87.58,25.36 v1(87.18,24.96)
DDR4_COMP_DQ29: length 62
  L12_SIG4 w0.089: v1(119.3,45.37) 120.26,45.37 120.75,45.85 121.03,45.85 121.44,46.26 121.81,46.26 122.31,46.76 125.54,46.76 127.77,44.53 127.77,30.79 125.28,28.3 98.08,28.3 94.98,25.2 93.25,25.2 93.09,25.36 92.38,25.36 v1(91.98,24.96)
DDR4_COMP_DQ30: length 60.3
  L12_SIG4 w0.089: v1(87.98,24.16) 88.4,24.58 89.1,24.58 89.88,25.36 89.88,27.39 90.91,28.43 95.21,28.43 97.54,30.76 114.66,30.76 114.87,30.56 122.64,30.56 125.18,33.1 125.18,37.64 122.87,39.96 122.87,40.14 123.02,40.29 123.2,40.29 123.72,39.77 123.9,39.77 124.05,39.92 124.05,40.1 123.05,41.1 123.05,43.56 122.61,43.99 122.32,43.99 121.89,44.43 121.51,44.43 121,44.94 120.7,44.94 120.38,44.62 119.97,44.45 v1(119.3,44.45)
