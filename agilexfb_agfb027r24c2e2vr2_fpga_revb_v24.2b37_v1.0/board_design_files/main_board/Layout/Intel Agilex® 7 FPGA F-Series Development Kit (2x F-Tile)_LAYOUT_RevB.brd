# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_EP_TX_P10: length 90.5
  TOP w0.116: v4(104.65,7.21) 104.9,7.21 arc(105,7.17) 105.03,7.08 105.03,6.55 arc(105.02,6.47) 104.97,6.39
  TOP w0.17: 104.97,6.39 104.78,6.2 arc(104.69,6.07) 104.65,5.9 J1.B58
  L03_SIG1 w0.085: v4(122.48,71.13) 122.27,71 arc(122.19,70.99) 122.12,71.05 122.1,71.08 arc(122.09,71.12) 122.09,71.17 122.16,71.33 arc(122.27,71.46) 122.43,71.51 122.64,71.51 arc(122.83,71.57) 122.96,71.72 122.99,71.8 arc(123.09,71.91) 123.22,71.95 123.4,71.95 123.65,71.84 123.83,71.66 123.83,71.5 124.01,71.32 124.18,71.32 124.36,71.13 124.36,70.97 124.54,70.79 124.71,70.79 124.89,70.6 124.89,70.44 125.07,70.26 125.24,70.26 125.42,70.07 125.42,69.91 125.6,69.73 125.77,69.73 125.95,69.55 125.95,69.38 126.13,69.2 126.3,69.2 126.48,69.02 126.48,68.85 126.66,68.67 126.83,68.67 127.01,68.49 127.01,68.34 127.19,68.16 127.33,68.16 127.51,67.98 127.51,67.84 127.69,67.65 127.84,67.65 129.07,66.43 129.63,65.43 132.06,55.73 132.06,43.56 131.42,40.33 130.03,36.98 128.37,34.49 124.58,30.7 120.21,28.89 117.73,28.4 110.87,28.4 109.76,27.94 109.43,27.62 108.91,26.35 108.91,20.09 108.32,17.1 107.92,16.15 106.84,14.53 105.44,11.16 105.05,9.19 105.05,7.33 104.93,7.21 v4(104.65,7.21)
PCIE_EP_TX_P11: length 92.2
  TOP w0.116: v4(108.65,7.21) 108.9,7.21 arc(109,7.17) 109.03,7.08 109.03,6.55 arc(109.02,6.47) 108.97,6.39
  TOP w0.17: 108.97,6.39 108.78,6.2 arc(108.69,6.07) 108.65,5.9 J1.B62
  L03_SIG1 w0.085: v4(122.48,72.97) 122.27,72.84 arc(122.19,72.83) 122.12,72.89 122.1,72.92 arc(122.09,72.96) 122.09,73.01 122.16,73.17 arc(122.27,73.3) 122.43,73.35 122.64,73.35 arc(122.83,73.41) 122.96,73.56 122.99,73.64 arc(123.09,73.75) 123.22,73.79 123.34,73.79 123.5,73.72 123.72,73.57 123.9,73.39 123.9,73.23 124.08,73.05 124.25,73.05 124.43,72.86 124.43,72.7 124.61,72.52 124.78,72.52 124.96,72.33 124.96,72.17 125.14,71.99 125.31,71.99 125.49,71.8 125.49,71.64 125.67,71.46 125.84,71.46 126.02,71.28 126.02,71.11 126.2,70.93 126.37,70.93 126.55,70.75 126.55,70.58 126.73,70.4 126.9,70.4 127.11,70.19 127.27,69.99 127.26,69.85 127.42,69.65 127.56,69.63 127.72,69.43 127.71,69.29 127.87,69.09 128.02,69.08 129.26,67.56 130.4,65.86 130.99,64.48 132.87,56.09 132.87,43.13 132.28,40.14 130.84,36.67 130.84,28.15 131.3,25.85 131.3,19.2 130.59,17.48 129.58,16.47 128.61,16.07 114.74,13.31 112.04,11.87 109.46,9.28 109.05,8.31 109.05,7.3 108.96,7.21 v4(108.65,7.21)
PCIE_EP_TX_P12: length 91.3
  TOP w0.116: v4(112.65,7.21) 112.9,7.21 arc(113,7.17) 113.03,7.08 113.03,6.55 arc(113.02,6.47) 112.97,6.39
  TOP w0.17: 112.97,6.39 112.78,6.2 arc(112.69,6.07) 112.65,5.9 J1.B66
  L03_SIG1 w0.085: v4(122.48,74.81) 122.28,74.69 arc(122.22,74.61) 122.24,74.51 122.27,74.46 arc(122.3,74.43) 122.34,74.43 122.62,74.43 arc(122.7,74.45) 122.76,74.5 122.86,74.69 arc(123.01,74.83) 123.21,74.89 123.42,74.89 123.84,74.71 124.4,74.34 127.92,70.82 130.23,68 131.12,66.68 131.93,64.72 133.61,57.99 133.89,55.17 133.89,42.76 133.31,39.85 131.86,36.34 131.86,28.64 132.75,24.17 132.75,19.94 131.46,16.82 130.25,15.62 128.74,14.99 120.4,13.33 118.3,12.21 115.68,9.58 114.54,6.85 114.04,6.34 113.39,6.34 113.05,6.68 113.05,7.12 112.96,7.21 v4(112.65,7.21)
PCIE_EP_TX_P13: length 92
  TOP w0.116: v4(116.65,7.21) 116.9,7.21 arc(117,7.17) 117.03,7.08 117.03,6.55 arc(117.02,6.47) 116.97,6.39
  TOP w0.17: J1.B70 116.65,5.9 arc(116.69,6.07) 116.78,6.2 116.97,6.39
  L03_SIG1 w0.085: v4(116.65,7.21) 116.96,7.21 117.05,7.3 117.05,8.33 117.42,9.22 120.19,11.99 123.25,13.26 128.88,14.38 130.49,15.05 132.13,16.69 133.36,19.64 133.36,24.76 132.47,29.23 132.47,35.94 134.02,39.68 134.78,43.52 134.78,59.22 134.64,59.94 131.8,66.78 130.41,68.86 127.72,72.14 127.24,72.62 127.1,72.62 126.92,72.8 126.92,72.95 126.73,73.13 126.59,73.13 126.41,73.31 126.41,73.45 126.23,73.63 126.08,73.63 125.9,73.82 125.9,73.96 125.72,74.14 125.55,74.14 125.37,74.32 125.37,74.49 125.19,74.67 124.99,74.8 124.83,74.76 124.62,74.9 124.58,75.06 124.37,75.2 124.21,75.17 124,75.31 123.96,75.46 123.85,75.53 arc(123.73,75.59) 123.59,75.61 123.28,75.61 arc(123.15,75.59) 123.05,75.51 122.85,75.31 arc(122.72,75.23) 122.56,75.2 122.4,75.2 arc(122.26,75.23) 122.13,75.31 121.89,75.55 arc(121.84,75.58) 121.78,75.6 121.6,75.6 arc(121.54,75.58) 121.49,75.55 121.28,75.34 arc(121.11,75.23) 120.92,75.19 120.81,75.19 arc(120.62,75.24) 120.48,75.38 120.4,75.51 arc(120.3,75.61) 120.16,75.65 119.96,75.65 arc(119.92,75.64) 119.88,75.61 119.84,75.53 arc(119.83,75.45) 119.88,75.39 v4(120.09,75.27)
PCIE_EP_TX_P14: length 89
  TOP w0.116: v4(120.65,7.21) 120.9,7.21 arc(121,7.17) 121.03,7.08 121.03,6.55 arc(121.02,6.47) 120.97,6.39
  TOP w0.17: 120.97,6.39 120.78,6.2 arc(120.69,6.07) 120.65,5.9 J1.B74
  L03_SIG1 w0.085: v4(120.65,7.21) 120.96,7.21 121.05,7.3 121.05,8.41 121.57,9.66 123.3,11.39 124.94,12.27 126.49,12.58 128.14,13.08 130.75,14.16 132.95,16.36 134.2,19.36 134.2,24.93 133.28,29.52 133.28,35.58 134.82,39.3 135.59,43.16 135.59,59.46 132.41,67.15 130.24,70.76 128.56,72.61 128.11,73.07 127.96,73.07 127.78,73.25 127.78,73.4 127.6,73.58 127.46,73.58 127.28,73.76 127.28,73.9 127.09,74.08 126.93,74.08 126.75,74.27 126.75,74.43 126.56,74.61 126.4,74.61 126.22,74.79 126.22,74.96 126.03,75.14 125.87,75.14 125.69,75.32 125.69,75.49 125.51,75.67 125.34,75.67 125.16,75.85 125.16,76.02 124.98,76.2 124.81,76.2 124.63,76.38 124.63,76.55 124.45,76.73 124.28,76.73 124.1,76.91 124.1,77.08 123.89,77.29 123.46,77.47 123.22,77.47 arc(123.09,77.43) 122.99,77.32 122.96,77.24 arc(122.83,77.09) 122.64,77.03 122.43,77.03 arc(122.27,76.98) 122.16,76.85 122.09,76.69 arc(122.09,76.64) 122.1,76.6 122.12,76.57 arc(122.19,76.51) 122.27,76.52 v4(122.48,76.65)
PCIE_EP_TX_P15: length 90
  TOP w0.116: v4(124.65,7.21) 124.9,7.21 arc(125,7.17) 125.03,7.08 125.03,6.55 arc(125.02,6.47) 124.97,6.39
  TOP w0.17: 124.97,6.39 124.78,6.2 arc(124.69,6.07) 124.65,5.9 J1.B78
  L03_SIG1 w0.085: v4(120.09,77.11) 119.89,77.22 arc(119.83,77.3) 119.85,77.4 119.88,77.45 arc(119.91,77.48) 119.94,77.49 120.1,77.49 arc(120.31,77.53) 120.49,77.65 120.7,77.86 arc(120.77,77.91) 120.86,77.93 120.94,77.93 arc(121.09,77.96) 121.22,78.04 121.49,78.32 arc(121.57,78.37) 121.65,78.39 arc(121.89,78.44) 122.09,78.58 122.22,78.71 arc(122.37,78.81) 122.55,78.85 122.76,78.85 123,78.75 123.05,78.62 123.29,78.52 123.42,78.57 123.66,78.47 123.71,78.34 123.95,78.24 124.08,78.3 124.26,78.22 124.5,77.98 124.5,77.82 124.68,77.64 124.85,77.64 125.03,77.45 125.03,77.29 125.21,77.11 125.38,77.11 125.56,76.93 125.56,76.78 125.74,76.6 125.89,76.6 126.07,76.42 126.07,76.27 126.25,76.09 126.39,76.09 129.29,73.19 131.79,70.16 133.74,67.23 136.17,61.37 136.41,60.18 136.41,42.8 135.62,38.84 134.09,35.16 134.09,30.01 135.14,24.78 135.14,19.31 133.8,16.1 131.2,13.49 128.54,12.39 125.5,9.35 125.05,8.27 125.05,7.3 124.96,7.21 v4(124.65,7.21)
PCIE_HSC_ALERT_N: length 294
  TOP w0.149: v1(230.83,40.46) 230,40.46 229.62,40.85
  TOP w0.152: 229.62,40.85 229.12,41.35 228.86,41.35 228.48,41.73 U50.15
  L03_SIG1 w0.081: v1(224.92,20.53) 229.09,24.7 229.09,34.68 230.83,36.41 v1(230.83,40.46)
  L12_SIG4 w0.089: v1(34.18,72.65) 33.56,73.27 33.56,74.63 32.72,75.47 32.72,75.82 32.39,76.15 26.85,76.15 26.6,75.9 26.6,75.42 26.42,75.24 25.92,75.24 25.79,75.11 25.79,73.61 25.36,73.18 24.95,73.18 24.65,72.87 24.65,71.1 25.56,70.18 25.56,67.69 27.64,65.61 27.64,63.66 28.91,62.39 28.91,60.68 30.61,58.98 30.61,56.8 31.22,56.19 31.22,53.65 33.2,51.67 33.2,50.88 38.87,45.21 39.38,45.21 39.81,44.78 39.81,44.27 42.68,41.4 45.02,41.4 46.46,39.96 55.25,39.96 56.57,38.64 58.07,38.64 58.66,39.22 59.19,39.22 60.4,38.01 60.4,37.68 64.37,33.7 64.37,29.21 66.02,27.56 66.02,26.95 66.4,26.57 66.86,26.57 70.24,23.19 70.24,19.61 74.21,15.64 77.21,15.64 77.6,15.24 84.16,15.24 84.92,14.48 88.04,14.48 88.55,14.99 117.57,14.99 118.36,15.78 130,15.78 131.59,17.37 131.59,18.58 132.79,19.78 132.79,23.86 134.44,25.51 142.76,25.51 144.74,23.52 145.68,23.52 147.02,22.18 149.94,22.18 151.96,20.16 152.45,20.16 152.99,19.61 152.99,17.25 155.21,15.03 210.7,15.03 212.13,16.46 215.78,16.46 218.27,18.95 219.69,18.95 220.87,20.13 224.53,20.13 v1(224.92,20.53)
PCIE_HSC_BST: length 1.6
  TOP w0.149: C602.2 226.98,47.41 U50.4
PCIE_HSC_EN: length 76.3
  TOP w0.152: U50.14 227.98,41.35 228.23,41.1 v1(228.51,41.1)
  L16_SIG6 w0.081: v1(228.51,41.1) 228,41.61 227.26,41.61 226.78,41.13 222.18,41.13 217.99,45.32 217.99,56.82 215.42,59.39 207.91,59.39 203.92,63.38 203.92,77.5 207.4,80.98 213.24,80.98 214.19,81.93 v1(217.18,81.93)
  BOTTOM w0.149: v1(228.51,41.1) C601.1 R458.1 R456.2 ; R469.2 v1(217.18,81.93)
PCIE_HSC_FAULTB: length 1.8
  TOP w0.149: U50.16 229.92,42.39 R457.2
PCIE_HSC_ILOAD: length 2.1
  TOP w0.149: 227.98,46.35 227.98,46.51 v1(228.99,47.51)
  TOP w0.152: 227.98,46.35 U50.2
PCIE_HSC_PG: length 288.7
  TOP w0.152: v1(230.83,42.5) 230.43,42.89 U50.17
  L03_SIG1 w0.081: v1(224.16,20.53) 228.22,24.58 228.22,34.36 230.37,36.51 230.37,42.03 v1(230.83,42.5)
  L12_SIG4 w0.089: v1(33.18,73.65) 33.18,74.34 32.35,75.16 26.85,75.16 26.58,74.88 26.58,74.21 26.3,73.94 26.3,73.45 25.68,72.82 25.68,71.26 26.68,70.26 26.68,67.24 28.15,65.76 28.15,63.88 30.54,61.5 30.54,59.87 31.05,59.36 31.05,57.18 31.76,56.47 31.76,54.06 33.9,51.91 33.9,50.76 39.07,45.6 39.58,45.6 40.32,44.86 40.32,44.53 43.01,41.84 45.17,41.84 46.54,40.46 55.51,40.46 55.96,40.01 57,40.01 57.49,40.49 58.45,40.49 59.19,39.75 59.54,39.75 61.12,38.18 61.12,37.66 64.95,33.82 64.95,29.21 70.53,23.64 70.53,19.86 74.38,16 77.45,16 77.81,15.65 84.31,15.65 85.17,14.79 87.36,14.79 87.97,15.4 117.51,15.4 118.14,16.03 129.91,16.03 131.35,17.47 131.35,18.75 132.49,19.89 132.49,24.05 134.3,25.85 143.01,25.85 144.97,23.89 145.76,23.89 147.2,22.46 150.04,22.46 151.91,20.59 152.7,20.59 153.32,19.97 153.32,17.68 155.48,15.52 169.98,15.52 170.14,15.37 209.65,15.37 211.22,16.94 215.67,16.94 217.89,19.16 217.89,19.48 218.27,19.87 220.02,19.87 220.68,20.53 v1(224.16,20.53)
PCIE_HSC_ROCP: length 1.5
  TOP w0.149: R462.2 230.71,43.39 U50.18
PCIE_HSC_SMB_ID_R: length 1.5
  TOP w0.152: U50.20 230.69,44.39 R461.2
PCIE_HSC_SS: length 3.3
  TOP w0.149: C605.1 227.81,47.68 227.69,47.68 227.44,47.93 227.44,48.05 C606.1
  TOP w0.152: C605.1 227.48,47.03 U50.3
PCIE_PERSTN: length 247.1
  L05_SIG2 w0.081: v1(220.54,106.42) 219.31,107.65 207.02,107.65 206.58,107.22 195.57,107.22 194.15,105.79 186.01,105.79 185.02,104.8 185.02,103.76 183.75,102.49 179.79,102.49 179.08,103.2 167.98,103.2 165.31,100.54 165.31,99.8 163.56,98.05 163.56,97.69 161.27,95.41 157.82,95.41 156.78,94.36 153.55,94.36 153.27,94.08 152.66,94.08 152.31,94.44 150.3,94.44 149.92,94.06 149.31,94.06 148.93,94.44 147.73,94.44 147.23,93.93 146.74,93.93 146.34,93.53 141.46,93.53 140.27,92.33 138.64,92.33 134.73,88.42 134.73,84.25 135.72,83.26 135.72,77.45 135.24,76.96 134.22,76.96 132.3,75.05 130.66,75.05 v1(130.12,74.5)
  L07_SIG3 w0.089: v1(112.92,72.05) 113.92,72.05 114.41,72.54 114.74,72.54 115.21,73.01 115.51,73.01 115.96,73.46 116.3,73.46 116.73,73.89 117.13,73.89 117.5,74.26 117.8,74.26 118.36,74.82 118.66,74.82 119.38,75.53 120.01,75.53 120.59,76.12 121.29,76.12 121.78,76.6 122.21,76.6 123.25,77.64 123.89,77.64 124.72,78.47 124.72,88.22 119.9,93.04 119.9,94.55 120.66,95.32 120.66,99.13 118.75,101.04 118.75,102.12 116.99,103.88 116.99,105.94 116.1,106.84 115.59,106.84 115.22,107.2 115.22,107.9 115.05,108.08 112.73,108.08 112.55,108.26 112.55,108.54 112.28,108.82 102.67,108.82 102.39,108.54 100.59,108.54 100.31,108.82 89.11,108.82 88.88,108.59 80.53,108.59 80.3,108.82 74.71,108.82 74.33,108.44 74.33,107.34 73.62,106.63 64.65,106.63 61.6,103.58 61.6,101.2 61.53,101.12 61.53,99.57 60.51,98.55 60.51,98.05 v1(60.21,97.74)
  L12_SIG4 w0.089: v1(112.92,72.05) 113.8,72.05 114.22,72.47 114.61,72.47 115.1,72.96 115.53,72.96 115.97,73.4 116.38,73.4 116.84,72.94 117.13,72.94 117.56,73.37 118.01,73.37 118.44,72.94 118.75,72.94 119.14,72.56 119.56,72.56 119.95,72.94 120.35,72.94 120.76,72.52 121.2,72.52 121.61,72.94 126.08,72.94 127.64,74.5 v1(130.12,74.5)
PCIE_RSV2: length 6.7
  BOTTOM w0.17: J1.A19 65.65,7.23 65.03,7.85 C17.1
PCIE_RSV4: length 6.9
  BOTTOM w0.17: J1.A32 78.65,9.69 77.79,10.56 C21.1
PCIE_RSV5: length 6.9
  BOTTOM w0.17: J1.A33 79.65,7.34 80.14,7.83 80.14,10.05 C22.1
PCIE_RSV6: length 7.8
  TOP w0.17: C23.1 128.38,7.66 128.38,6.43 128.65,6.15 J1.B82
PCIE_RSV7: length 6.8
  BOTTOM w0.17: C25.1 97.16,10.18 97.16,7.72 96.65,7.22 J1.A50
PCIE_VDD_1V85: length 9.8
  L16_SIG6 w0.381: v1(231.77,41.48) 232.42,41.48 232.8,41.86 232.8,47.7 232.16,48.34 231.34,48.34 v1(230.58,47.58)
PG_0V6_DDR4_VREF_COMP: length 1.7
  TOP w0.254: U78.9 v1(62.36,17.61)
  BOTTOM w0.149: R729.1 61.55,17.61 v1(62.36,17.61)
PG_0V6_DDR4_VREF_DIMM: length 1.7
  TOP w0.254: U77.9 191.39,98.05 R728.1
PG_2V5_DDR4_COMP: length 1.3
  TOP w0.254: v1(144.78,17.35) U76.4
  BOTTOM w0.254: R727.1 v1(144.78,17.35)
PG_2V5_DDR4_DIMM: length 1.3
  TOP w0.254: v1(188.86,91.78) U75.4
  BOTTOM w0.254: R726.1 v1(188.86,91.78)
PG_DDR4_LDO: length 249.6
  L05_SIG2 w0.081: v1(199.4,32.02) 198.72,31.35 195.69,31.35 193,28.65 192.41,28.65 191.9,28.15 191.9,18.75 190.89,17.73 173.21,17.73 172.47,17 146.73,17 v1(146.37,17.35)
  L14_SIG5 w0.081: v1(62.11,12.4) 63.41,12.4 63.56,12.24 84.05,12.24 85.1,13.29 130.18,13.29 132.82,15.93 144.13,15.93 145.55,17.35 v1(146.37,17.35) ; v1(190.38,98) 191.14,97.23 191.14,94.06 190.63,93.55 190.25,93.55 189.62,92.92 189.62,91.84 v1(187.97,90.19) 187.14,89.36 179.1,89.36 178.34,88.6 177.17,88.6 176.79,88.22 176.79,77.8 179.33,75.26 179.33,70.56 181.74,68.15 188.35,68.15 190.76,65.74 190.76,46.05 191.17,45.65 193.15,45.65 195.5,43.29 195.5,39.3 195.91,38.9 195.91,35.51 v1(199.4,32.02)
  BOTTOM w0.149: R729.2 60.71,15.89 60.71,14.56 62.11,13.16 v1(62.11,12.4)
  BOTTOM w0.254: R726.2 v1(187.97,90.19)
PG_MAX_1V2: length 3.9
  TOP w0.149: v1(15.63,61.29) 15.93,61.6 15.93,61.98 16.26,62.3 v1(16.26,63.33)
  BOTTOM w0.149: v1(15.63,61.29) R496.2 R506.1
PG_MAX_1V8: length 3.8
  L05_SIG2 w0.081: v1(33.41,102.69) 33.54,102.81 v1(33.54,104.79)
  BOTTOM w0.254: R505.1 v1(33.54,104.79) ; v1(33.41,102.69) U57.4
PG_MAX_2V5: length 3.7
  TOP w0.254: v1(32.9,101.16) U56.4
  L05_SIG2 w0.081: v1(32.9,101.16) 32.9,102.06 32.01,102.95 v1(31.44,102.95)
  BOTTOM w0.254: R504.1 v1(31.44,102.95)
PG_ZL70733_1V8: length 0.6
  TOP w0.254: v1(63.64,63.96) U81.4
POWER_ON: length 40.5
  TOP w0.254: U54.14 226.56,81.69 v1(226.32,81.45)
  L14_SIG5 w0.254: v1(247.72,93.42) 246.96,94.19 243.59,94.19 243.21,93.8 233.69,93.8 233.05,93.17 233.05,88.98 232.57,88.5 227.62,88.5 226.32,87.2 v1(226.32,81.45)
  BOTTOM w0.254: R472.2 226.32,82.18 v1(226.32,81.45) 226.32,80.24 R475.1 C623.1 ; v1(247.72,93.42) 247.72,96.68 SW5.5
PPS_FPGA_CLKOUT: length 8.3
  TOP w0.149: U23.8 68.46,49.23 68.97,48.72 68.97,48.08 69.6,47.45 72.4,47.45 v1(73.41,46.43)
  BOTTOM w0.149: R845.2 v1(73.41,46.43)
PTP_CLK_RST_N: length 76
  TOP w0.149: v1(47,63.71) 47.63,63.07 58.81,63.07 62.19,66.45 68.66,66.45 70.21,64.9 70.21,62.56 70.92,61.85 71.71,61.85 72.02,61.55 72.02,57.1 71.64,56.72 70.62,56.72 70.37,56.47 70.37,56.15 R739.2 R265.1 69.88,55.2 68.84,54.16 68.84,53.8 68.27,53.23 U23.16
  L05_SIG2 w0.081: v1(26.18,82.65) 26.69,82.14 27.45,82.14 27.68,81.92 27.68,72.56 28.09,72.15 32.96,72.15 34.22,70.9 34.22,70.43 34.85,69.8 35.57,69.8 36.33,69.04 38.81,69.04 39.57,68.28 41.2,68.28 43.91,65.57 46.02,65.57 46.59,65 46.59,64.11 v1(47,63.71)
PTP_SAMPLE_CLK_250M_N: length 33.6
  L14_SIG5 w0.079: 86.02,44.77 86,44.78 85.98,44.79 85.85,44.95 85.1,45.71 84.15,45.71 83.99,45.61 83.86,45.39 83.59,45.24 82.93,45.24 82.46,45.71 82.15,45.71 82.05,45.61 82.05,45.54 81.97,45.47 81.74,45.47 81.66,45.54 81.66,45.61 81.56,45.71 80.97,45.71 80.8,45.61 80.69,45.42 80.42,45.27 79.09,45.27 76.5,47.86 75.98,47.86 v1(75.7,47.58) 75.42,47.86 74.23,47.86 74.11,47.74 72.19,47.74 70.79,49.14 70.28,49.14 67.38,52.04 67.38,54.31 64.65,57.04 64.65,57.85 64.57,57.93 v1(64.27,57.93)
  L14_SIG5 w0.081: v1(86.63,43.07) 86.87,43.2 86.9,43.33 86.83,43.53 87,43.94 87,44.05 86.96,44.14 86.91,44.23 86.78,44.37 86.53,44.37 86.34,44.44 86.02,44.77
  BOTTOM w0.102: v1(75.7,47.58) 74.99,47.58 74.94,47.53
PTP_SAMPLE_CLK_250M_P: length 33.6
  L14_SIG5 w0.079: 86.17,44.89 86.16,44.91 86.16,44.93 86.03,45.1 85.19,45.94 84.09,45.94 83.82,45.78 83.69,45.56 83.53,45.47 83.02,45.47 82.55,45.94 80.91,45.94 80.63,45.78 80.52,45.59 80.36,45.49 79.19,45.49 76.6,48.08 75.98,48.08 v1(75.7,48.36) 75.42,48.08 74.13,48.08 74.01,47.97 72.28,47.97 70.88,49.37 70.37,49.37 67.61,52.13 67.61,54.41 65.59,56.43 65.59,56.53 65.68,56.62 65.68,56.73 65.52,56.9 65.41,56.9 65.34,56.82 65.19,56.82 64.88,57.14 64.88,57.83 64.98,57.93 v1(65.29,57.93)
  L14_SIG5 w0.081: v1(87.43,43.53) 87.19,43.39 87.08,43.42 87.04,43.53 87.19,43.9 87.19,44.09 87.13,44.23 87.07,44.35 86.86,44.56 86.57,44.56 86.45,44.61 86.17,44.89
  BOTTOM w0.102: 74.94,48.42 74.99,48.36 v1(75.7,48.36)
PWM0: length 21.2
  TOP w0.203: U61.5 178.11,49.71 176.99,48.59 v1(176.79,48.59)
  L14_SIG5 w0.203: v1(176.79,48.59) 176.54,48.85 170.06,48.85 166.58,45.37 164.29,45.37 163.46,44.53 161.65,44.53 160.87,45.32 v1(160.87,45.61)
PWM1: length 39.7
  TOP w0.203: v1(175.78,56.47) 175.93,56.31 176.67,56.31 176.91,56.07 U61.42
  L05_SIG2 w0.203: v1(160.87,31) 165.17,31 166.76,32.59 166.76,46.31 168.79,48.34 168.79,55.07 170.57,56.85 172.6,56.85 172.85,57.1 175.14,57.1 v1(175.78,56.47)
PWM2: length 23
  TOP w0.203: v1(173.74,50.62) 174.38,49.99 176.66,49.99 176.91,50.24 U61.2
  L14_SIG5 w0.203: v1(160.87,60.09) 161.89,59.06 165.56,59.06 167.27,57.36 167.27,53.5 170.01,50.75 173.62,50.75 v1(173.74,50.62)
PWM3: length 35.7
  TOP w0.203: U61.1 176.51,50.57 176.31,50.37 175.14,50.37 v1(174.89,50.62)
  L14_SIG5 w0.203: v1(174.89,50.62) 173.18,52.33 170.64,52.33 168.92,54.05 168.92,70.94 166.12,73.74 164.22,73.74 163.39,74.56 v1(160.87,74.56)
PWM4: length 47.5
  TOP w0.203: 174.9,52.36 175.1,52.36 175.1,52.36 U61.50
  TOP w0.254: v1(173.62,52.78) 174.04,52.36 174.9,52.36
  L14_SIG5 w0.203: v1(173.62,52.78) 170.57,55.83 170.57,72.78 169.04,74.31 169.04,87.2 168.03,88.22 164.22,88.22 163.39,89.04 v1(160.87,89.04)
PWRGD_G0: length 56.3
  L07_SIG3 w0.089: v1(27.18,72.65) 26.78,72.65 26.38,72.25 21.93,72.25 21.68,72.5 21.68,72.85 21.38,73.15 20.98,73.15 20.68,73.45 20.68,73.85 20.38,74.15 19.88,74.15 19.68,74.35 19.68,74.75 19.28,75.15 17.88,75.15 15.63,77.4 15.63,78.56 14.99,79.2 14.99,81.99 14.48,82.51 14.48,84.29 10.8,87.96 10.8,92.66 11.34,93.2 11.34,101.51 15.78,105.95 18.89,105.95 19.35,106.42 19.35,107.15 19.49,107.29 19.49,109.05 v1(18.99,109.55)
  BOTTOM w0.149: v1(18.99,109.55) R523.2 R527.2
PWRGD_G1: length 332
  TOP w0.149: v1(27.18,67.65) 27.68,68.15 27.68,70.15 U5.G14
  L03_SIG1 w0.081: v1(36.9,94.31) 36.9,94.63 37.35,95.07 39.3,95.07 40.27,94.11 50.25,94.11 50.81,93.55 54.93,93.55 v1(55.82,92.66)
  L07_SIG3 w0.089: v1(61.86,72.98) 61.48,72.6 61.48,66.75 59.29,64.57 55.48,64.57 51.8,60.89 51.8,45.06 52.08,44.78 52.33,44.78 52.59,44.53 52.59,43.77 v1(52.2,43.39) ; v1(36.9,94.31) 35.91,93.32 35.91,90.14 32.58,86.81 32.58,77.48 32.25,77.15 31.98,77.15 31.68,76.85 31.68,76.45 31.38,76.15 30.98,76.15 30.48,75.65 30.18,75.65 29.68,75.15 29.68,74.45 29.38,74.15 28.98,74.15 28.68,73.85 28.68,71.55 27.8,70.67 27.8,68.27 v1(27.18,67.65)
  L16_SIG6 w0.081: v1(175.9,46.94) 175.9,44.78 177.05,43.64 177.05,32.84 177.43,32.46 177.93,32.46 178.32,32.08 178.32,31.57 177.93,31.19 172.85,31.19 171.2,29.54 171.2,24.72 166.89,20.4 166.89,18.32 164.78,16.21 138.01,16.21 133.31,11.51 129.37,11.51 127.26,9.4 63.18,9.4 61.59,10.98 60.22,10.98 58.81,12.4 58.81,14.68 52.48,21.01 52.48,22.02 50.12,24.39 49.49,24.39 48.04,25.83 48.04,39.22 v1(52.2,43.39)
  BOTTOM w0.149: R644.2 v1(61.86,72.98) 61.86,73.36 61.63,73.59 61.63,89.84 58.43,93.04 56.2,93.04 v1(55.82,92.66)
  BOTTOM w0.254: v1(175.9,46.94) 175.97,46.88 R641.1 179.97,46.88 R642.2 180.03,47.74 180.75,48.47 182.76,48.47 184.03,49.74 184.03,55.83 182,57.86 176.28,57.86 174.7,59.45 R643.2
PWRGD_G2: length 328.1
  L05_SIG2 w0.081: v1(28.18,68.65) 28.74,69.22 28.74,69.79 27.45,71.09 26.92,71.09 26.56,71.45 26.56,74.87 26.3,75.13 25.97,75.13 25.74,75.35 25.74,75.76 25.34,76.15 16.31,76.15 14.43,74.27 14.43,72.67 13.14,71.38 11.87,71.38 10.17,69.67 10.17,65.48 12.2,63.45 12.2,58.82 12.67,58.35 12.67,50.48 12.88,50.27 13.33,50.27 13.64,49.96 13.64,40.39 12.88,39.62 12.88,38.36 14.1,37.14 14.1,34.2 13.65,33.74 13.65,30.11 14.25,29.5 15.28,29.5 16.9,27.88 17.15,27.88 19.27,25.76 24.15,25.76 25.06,26.67 29.65,26.67 30.47,25.85 31.12,25.85 32.03,24.94 32.9,24.94 33.54,24.31 33.54,24.02 34.07,23.48 42.24,23.48 42.59,23.83 45.53,23.83 46.63,22.73 46.63,19.2 48.34,17.5 54.35,17.5 54.95,16.89 56.37,16.89 59.5,13.77 62.95,13.77 65.3,11.41 80.52,11.41 80.75,11.64 82.09,11.64 82.32,11.41 94.12,11.41 94.36,11.66 96.17,11.66 96.41,11.41 120.65,11.41 120.92,11.68 126.17,11.68 127.49,12.99 132.73,12.99 135.82,16.08 137.21,16.08 137.82,16.69 173.06,16.69 173.72,17.35 191.02,17.35 192.41,18.75 192.41,23.19 197.87,28.65 197.87,30.2 198.49,30.81 199.84,30.81 200.16,31.13 200.16,31.45 200.6,31.89 201.81,31.89 v1(204.35,34.43)
  L14_SIG5 w0.081: v1(200.41,72.28) 200.41,66.37 203.59,63.2 203.59,42.6 204.3,41.89 204.3,37.01 203.59,36.3 203.59,34.9 204.06,34.43 v1(204.35,34.43)
  BOTTOM w0.149: v1(204.35,34.43) R667.2
PWRGD_G3: length 278.8
  L05_SIG2 w0.081: v1(195.71,34.43) 195.71,32.46 193.3,30.05 192.41,30.05 191.27,28.91 191.27,19 190.38,18.11 172.09,18.11 171.24,17.26 147.37,17.26 146.79,17.83 137.39,17.83 137.12,17.56 137.12,16.88 136.71,16.47 135.66,16.47 132.52,13.32 127.39,13.32 126.13,12.06 120.76,12.06 120.56,11.86 96.51,11.86 96.32,12.05 94.12,12.05 93.96,11.89 80.36,11.89 80.13,11.66 65.53,11.66 63.18,14.01 59.7,14.01 56.31,17.4 55.1,17.4 54.72,17.78 48.52,17.78 46.87,19.42 46.87,22.95 45.67,24.16 42.25,24.16 41.87,23.78 36.07,23.78 35.25,24.6 34.22,24.6 33,25.81 32.68,25.81 32.38,25.51 31.91,25.51 31.18,26.24 30.67,26.24 29.92,27 25.01,27 24.08,26.07 19.49,26.07 16.66,28.9 16.66,29.42 16.38,29.7 15.8,29.7 14.59,30.91 14.59,37.12 13.34,38.36 13.34,39.32 14.1,40.08 14.1,43.62 14.8,44.33 14.8,50.05 13.73,51.13 13.73,57.71 12.71,58.73 12.71,60.89 13.29,61.47 13.29,70.74 17.7,75.15 25.32,75.15 25.79,74.69 25.79,70.83 26.47,70.15 27.68,70.15 v1(28.18,69.65)
  BOTTOM w0.254: R714.2 R712.2 R713.2 R709.1 R711.2 v1(195.71,34.43)
PWRGD_OUT: length 29.3
  L14_SIG5 w0.081: v1(29.18,68.65) 28.76,68.24 18.82,68.24 16.83,70.22 16.83,75.43 16.36,75.9 16.36,79.56 17.85,81.04 v1(17.85,82.8)
  BOTTOM w0.149: R398.1 17.85,81.36 v1(17.85,82.8)
QSFP_1V2_LED1: length 98.1
  L14_SIG5 w0.081: v1(10.42,29.67) 10.83,29.26 10.83,28.07 9.91,27.16 9.91,22.38 10.64,21.65 11.47,21.65 13.75,23.93 13.75,25.84 14.52,26.6 15.64,26.6 15.9,26.86 16.57,26.86 16.68,26.75 17.86,26.75 18.08,26.96 24.81,26.96 26.72,28.88 33.84,28.88 34.53,28.2 41.13,28.2 41.87,28.93 43.44,28.93 46.74,32.24 46.74,32.72 55.66,41.63 56.8,41.63 58.99,43.82 71.89,43.82 73.22,42.48 79.04,42.48 80.22,41.3 84.68,41.3 85.04,41.66 v1(85.04,42.15)
  BOTTOM w0.149: U90.3 9.9,30.56 10.42,30.03 v1(10.42,29.67)
QSFP_1V2_LED2: length 97.8
  L14_SIG5 w0.081: v1(10.42,28.65) 9.56,27.79 9.56,22.28 10.42,21.41 12.02,21.41 13.49,22.88 14.14,22.88 17.11,25.86 24.47,25.86 27.21,28.6 32.04,28.6 33.38,27.26 39.94,27.26 40.24,26.95 41.99,26.95 47.38,32.34 47.38,32.77 55.91,41.3 56.98,41.3 59.16,43.49 71.46,43.49 72.78,42.17 78.98,42.17 80.12,41.02 85.16,41.02 v1(85.83,41.69)
  BOTTOM w0.149: U90.4 9.68,30.16 9.91,29.92 9.91,29.16 v1(10.42,28.65)
QSFP_3V3_INT_L: length 79.1
  TOP w0.149: v1(62.49,26.37) 59.7,26.37 59.29,25.96 J7.28
  L14_SIG5 w0.081: v1(62.49,26.37) 60.46,26.37 59.57,25.48 53.78,25.48 51.24,22.94 47.77,22.94 v1(47.26,22.43) ; v1(41.47,40.21) 44.31,43.05 44.31,44.43 45.47,45.6 45.47,45.9 46.13,46.56 46.54,46.56 47.38,47.4 v1(47.38,47.75)
  L16_SIG6 w0.081: v1(30.03,17.04) 31.44,17.04 33.38,18.98 33.38,26.34 33.79,26.75 34.68,26.75 35.25,26.18 42.74,26.18 43.95,24.97 44.72,24.97 v1(47.26,22.43) 47.26,23.03 45.98,24.31 45.98,28.53 42.93,31.57 42.93,36.78 41.47,38.24 v1(41.47,40.21)
QSFP_3V3_LPMODE: length 59.4
  TOP w0.149: J8.31 48.68,50.15 48.96,50.43 v1(48.96,51.34)
  L14_SIG5 w0.081: v1(40.39,34.6) 39.63,35.36 39.63,36.65 40.55,37.57 44.86,37.57 49.91,42.61 49.91,43.6 52.03,45.72 52.56,45.72 52.8,45.96 52.8,47.03 53.47,47.7 53.47,50.12 52.84,50.75 49.55,50.75 v1(48.96,51.34)
  L16_SIG6 w0.081: v1(29.38,17.8) 30.74,19.15 30.74,24.46 31.63,25.35 31.63,26.88 32.27,27.51 35.06,27.51 35.44,27.13 39.76,27.13 40.52,27.89 40.52,29.03 41.03,29.54 41.03,33.96 v1(40.39,34.6)
QSFP_3V3_MODPRS_L: length 103
  L07_SIG3 w0.089: v1(41.47,41.23) 39.76,39.51 39.76,32.72 39.5,32.46 39.5,30.43 39,29.92 39,29.67 39.51,29.16 39.51,27.12 35.07,22.68 30.23,22.68 28.63,24.29 v1(28.09,24.29)
  L12_SIG4 w0.089: v1(46.25,46.95) 45.89,46.59 44.7,46.59 41.54,49.75 41.54,53.04 38.69,55.88 38.69,57.79 35.92,60.56 v1(35.92,64.47)
  L14_SIG5 w0.081: v1(46.25,46.95) 45.45,46.95 42.45,43.94 42.45,42.2 v1(41.47,41.23) ; v1(21.18,82.65) 20.7,82.17 18.88,82.17 18.7,82.35 18.7,82.88 18.3,83.29 17.71,83.29 17.03,82.6 17.03,81.26 16.01,80.24 16.01,75.19 16.26,74.93 16.26,71.43 16.01,71.17 16.01,68.22 16.61,67.62 17.05,67.62 17.38,67.29 17.38,66.85 17.96,66.27 26.8,66.27 27.08,66.55 31.15,66.55 32.57,65.13 35.26,65.13 v1(35.92,64.47)
QSFP_3V3_RESET_L: length 56
  TOP w0.149: v4(48.22,27.16) 48.22,27.16 J7.9
  L03_SIG1 w0.081: v1(45.6,25.73) 45.6,26.11 46.64,27.16 v4(48.22,27.16)
  L07_SIG3 w0.089: v1(45.6,25.73) 45.98,26.11 45.98,28.27 48.27,30.56 48.27,41.84 46.82,43.28 46.82,43.92 45.99,44.75 45.28,44.75 43.87,46.15 43.59,46.15 43.29,46.46 43.29,48.31 43.93,48.95 v1(44.88,48.95)
  L16_SIG6 w0.081: v1(30.69,17.78) 31.38,18.47 31.38,23.7 31.83,24.15 31.83,24.4 32.39,24.97 32.39,25.61 32.65,25.86 32.65,26.24 33.54,27.13 34.88,27.13 35.26,26.75 44.08,26.75 45.09,25.73 v1(45.6,25.73)
QSFP_3V3_SELN: length 35.2
  L07_SIG3 w0.089: v1(30.04,23.53) 30.5,23.07 34.68,23.07 38.49,26.88 38.49,32.21 39.38,33.1 39.38,41.1 v1(39.5,41.23)
  L14_SIG5 w0.081: v1(39.5,41.23) 40.06,41.79 40.06,45.06 43.64,48.64 v1(43.64,49.74)
QSFP_FAULT_N: length 46.7
  L03_SIG1 w0.081: v1(24.65,41.35) 25.79,40.21 31.12,40.21 31.92,41.01 v1(31.92,42.03)
  L07_SIG3 w0.089: v1(32.18,70.65) 31.55,71.28 29.8,71.28 29.37,70.84 29.37,70.18 29.57,69.98 29.57,68.45 27.69,66.57 27.69,65.36 27.48,65.14 27.48,44.87 28.46,43.89 28.46,42.12 27.69,41.35 v1(24.65,41.35)
  BOTTOM w0.152: U21.8 v1(31.92,42.03)
QSFP_LED1: length 14.7
  L16_SIG6 w0.081: v1(13.78,38.73) 12.98,37.92 12.02,37.92 9.13,35.03 9.13,32.69 v1(6.1,29.67)
  BOTTOM w0.149: U90.9 6.99,30.56 v1(6.1,29.67)
QSFP_LED2: length 15.6
  L16_SIG6 w0.081: v1(17.09,33.73) 16.61,33.25 14.08,33.25 11.68,30.85 8.3,30.85 v1(6.1,28.65)
  BOTTOM w0.149: v1(6.1,28.65) 6.87,29.42 6.87,29.92 7.1,30.16 U90.8
QSFP_PWR_EN: length 27.5
  L07_SIG3 w0.089: v1(28.33,45.74) 28.33,46.94 28.2,47.07 28.2,64.98 28.58,65.36 28.58,66.66 30.08,68.15 30.42,68.15 30.68,68.41 30.68,69.15 v1(31.18,69.65)
  BOTTOM w0.152: U21.4 28.68,44.05 28.33,44.4 v1(28.33,45.74)
QSFP_REFCLK_N: length 21.3
  L07_SIG3 w0.081: v1(85.04,58.71) 84.8,58.84 84.66,58.81 84.63,58.75 84.49,58.61 83.95,58.61 83.79,58.77 83.67,58.97 83.52,59.05 83.38,59.05 83.17,59.13 82.81,59.49 82.49,59.49 82.11,59.11 81.61,59.11 81.19,59.52 80.97,59.52 80.95,59.5 80.93,59.5
  L07_SIG3 w0.085: v1(66.3,57.93) 66.59,57.93 66.68,57.84 66.68,57.46 66.93,57.21 69.65,57.21 71.39,58.96 75.65,58.96 v1(75.93,58.68) 76.61,58.68 76.89,58.96 78.28,58.96 78.37,59.05 80.28,59.05 80.73,59.5 80.93,59.5
QSFP_REFCLK_P: length 21.6
  L07_SIG3 w0.081: v1(84.24,59.17) 84.48,59.03 84.51,58.93 84.47,58.87 84.41,58.81 84.03,58.81 83.94,58.89 83.81,59.11 83.57,59.24 83.42,59.24 83.28,59.3 82.89,59.69 82.41,59.69 82.03,59.3 81.69,59.3 81.27,59.72 80.97,59.72 80.95,59.73 80.93,59.73
  L07_SIG3 w0.085: 80.93,59.73 80.63,59.73 80.18,59.28 79.93,59.28 79.75,59.46 79.49,59.46 79.31,59.28 78.28,59.28 78.18,59.18 77.9,59.18 77.79,59.29 77.79,59.4 77.69,59.5 77.51,59.5 77.4,59.4 77.4,59.29 77.3,59.18 76.89,59.18 76.61,59.46 v1(75.93,59.46) 75.65,59.18 71.29,59.18 70.61,58.51 70.47,58.51 70.4,58.58 70.25,58.58 70.12,58.45 70.12,58.3 70.19,58.23 70.19,58.09 69.55,57.44 67.02,57.44 66.91,57.55 66.91,57.84 67,57.93 v1(67.32,57.93)
QSFP_RX0_N: length 53.6
  L03_SIG1 w0.079: v4(43.48,41.75) 43.22,42.01 arc(43.19,42.03) 43.16,42.04 42.83,42.04 arc(41.87,42.43) 41.48,43.39 41.48,45.7 arc(41.69,46.79) 42.31,47.72 44.08,49.49 arc(45.08,50.15) 46.25,50.39 47.74,50.39 arc(48.62,50.56) 49.38,51.07 51.6,53.29 arc(52.22,54.21) 52.43,55.29 52.43,55.92 arc(52.8,57.75) 53.84,59.31 54.52,59.99 arc(55.08,60.46) 55.73,60.8 59.59,62.4 arc(61.28,62.92) 63.04,63.09 68.08,63.09 arc(68.96,63.18) 69.81,63.43 70.28,63.63 arc(71.16,63.9) 72.08,63.99 77.18,63.99 arc(77.47,64.04) 77.72,64.21 78.14,64.63 arc(78.33,64.76) 78.55,64.8 78.77,64.8 arc(78.84,64.82) 78.88,64.87 78.98,65.03 arc(79.16,65.21) 79.41,65.28 79.56,65.28 arc(79.75,65.22) 79.89,65.08 79.91,65.05 arc(79.97,65.01) 80.03,65.02 v4(80.26,65.15)
QSFP_RX0_P: length 53.6
  L03_SIG1 w0.079: v4(43.48,42.55) 43.22,42.29 arc(43.19,42.27) 43.16,42.27 42.83,42.27 arc(42.03,42.59) 41.7,43.39 41.7,43.53 41.85,43.67 41.85,43.93 41.7,44.08 41.7,44.87 41.85,45.02 41.85,45.27 41.7,45.42 41.7,45.7 arc(41.9,46.71) 42.47,47.55 42.63,47.71 42.83,47.71 43.01,47.89 43.01,48.1 43.19,48.28 43.4,48.28 43.58,48.46 43.58,48.66 43.76,48.84 43.96,48.84 44.14,49.02 44.14,49.23 44.24,49.33 arc(45.16,49.94) 46.25,50.16 46.87,50.16 47.01,50.01 47.27,50.01 47.42,50.16 47.74,50.16 arc(48.71,50.35) 49.54,50.9 51.76,53.13 arc(52.43,54.12) 52.66,55.29 52.66,55.92 arc(53.01,57.67) 54,59.15 54.68,59.83 arc(55.21,60.27) 55.82,60.59 59.68,62.19 arc(61.33,62.69) 63.04,62.86 68.08,62.86 arc(69.01,62.95) 69.89,63.22 70.37,63.42 arc(71.21,63.67) 72.08,63.76 75.74,63.76 75.89,63.61 76.15,63.61 76.29,63.76 76.55,63.76 76.69,63.61 76.95,63.61 77.1,63.76 77.18,63.76 arc(77.56,63.83) 77.88,64.05 78.31,64.47 arc(78.42,64.55) 78.55,64.57 78.77,64.57 arc(78.95,64.62) 79.08,64.75 79.17,64.91 arc(79.27,65.01) 79.41,65.05 79.56,65.05 arc(79.64,65.03) 79.7,64.97 79.72,64.94 arc(79.73,64.88) 79.7,64.84 v4(79.46,64.69)
QSFP_RX1_N: length 41.5
  L03_SIG1 w0.079: v4(80.26,59.63) 80.03,59.5 arc(79.99,59.44) 80,59.37 80.02,59.35 arc(80.08,59.17) 80.03,58.99 79.94,58.82 arc(79.76,58.64) 79.52,58.58 79.4,58.58 arc(79.27,58.54) 79.18,58.45 79.12,58.36 arc(78.95,58.18) 78.71,58.12 76.89,58.12 arc(76.32,58.01) 75.83,57.68 75.57,57.42 arc(74.86,56.95) 74.02,56.78 72.27,56.78 arc(71.46,56.62) 70.76,56.15 arc(70.14,55.75) 69.41,55.59 61.17,55.59 arc(59.82,55.32) 58.68,54.56 58.53,54.41 arc(57.6,53.79) 56.5,53.57 56.08,53.57 arc(55.69,53.49) 55.36,53.28 52.26,50.17 arc(51.58,49.15) 51.34,47.95 51.34,46.38 arc(51.13,45.35) 50.55,44.48 48.7,42.63 arc(48.49,42.49) 48.23,42.44 48.09,42.44 arc(48.06,42.43) 48.03,42.41 v4(47.77,42.15)
QSFP_RX1_P: length 41.5
  L03_SIG1 w0.079: v4(47.77,42.95) 48.03,42.69 arc(48.06,42.67) 48.09,42.67 48.23,42.67 arc(48.4,42.7) 48.54,42.79 48.72,42.97 48.72,43.18 48.9,43.36 49.11,43.36 49.29,43.54 49.29,43.75 49.47,43.93 49.68,43.93 50.39,44.64 arc(50.92,45.44) 51.11,46.38 51.11,47.95 arc(51.37,49.24) 52.1,50.33 55.2,53.44 arc(55.6,53.71) 56.08,53.8 56.5,53.8 arc(57.51,54) 58.37,54.57 58.51,54.72 arc(59.73,55.53) 61.17,55.82 69.4,55.82 arc(70.05,55.96) 70.6,56.32 arc(71.37,56.83) 72.27,57.01 74.02,57.01 arc(74.77,57.16) 75.41,57.59 75.67,57.84 arc(76.23,58.22) 76.89,58.35 77.11,58.35 77.26,58.5 77.51,58.5 77.66,58.35 77.91,58.35 78.06,58.5 78.31,58.5 78.46,58.35 78.71,58.35 arc(78.84,58.38) 78.93,58.47 78.98,58.56 arc(79.16,58.74) 79.4,58.81 79.52,58.81 arc(79.65,58.84) 79.74,58.93 79.84,59.1 arc(79.85,59.16) 79.83,59.22 79.8,59.27 arc(79.75,59.31) 79.68,59.3 v4(79.46,59.17)
QSFP_RX2_N: length 50.1
  L03_SIG1 w0.079: v4(79.46,62.85) 79.68,62.98 arc(79.75,62.99) 79.8,62.95 79.83,62.9 arc(79.85,62.84) 79.84,62.78 79.74,62.61 arc(79.65,62.52) 79.52,62.49 79.4,62.49 arc(79.16,62.42) 78.98,62.24 78.93,62.15 arc(78.84,62.06) 78.71,62.03 78.43,62.03 arc(78.1,62.07) 77.79,62.18 arc(77.51,62.29) 77.21,62.33 73.33,62.33 arc(72.97,62.27) 72.63,62.13 arc(72.25,61.98) 71.86,61.93 68.33,61.93 arc(67.42,61.78) 66.58,61.42 arc(65.65,61.04) 64.65,60.91 59.06,60.91 arc(57,60.5) 55.26,59.34 54.31,58.39 arc(53.54,57.23) 53.27,55.86 53.27,55.38 arc(52.99,53.97) 52.19,52.78 50.27,50.86 arc(49.77,50.12) 49.6,49.24 49.6,49.05 arc(49.53,48.72) 49.35,48.44 49.28,48.37 arc(49.18,48.29) 49.06,48.23 48.94,48.18 arc(48.73,48.07) 48.55,47.92 47.96,47.33 arc(47.82,47.23) 47.64,47.2 47.41,47.2 arc(47.19,47.24) 47,47.36 46.93,47.44 arc(46.63,47.63) 46.28,47.7 46.22,47.7 arc(45.96,47.65) 45.74,47.5 45.23,47 arc(45.08,46.9) 44.91,46.87 44.69,46.87 arc(44.52,46.9) 44.37,47 44.33,47.04 arc(44.07,47.21) 43.77,47.27 43.36,47.27 arc(42.88,47.07) 42.68,46.59 42.68,44.81 arc(42.79,44.55) 43.05,44.44 43.16,44.44 arc(43.19,44.43) 43.22,44.41 v4(43.48,44.15)
QSFP_RX2_P: length 50.1
  L03_SIG1 w0.079: v4(43.48,44.95) 43.22,44.69 arc(43.19,44.67) 43.16,44.67 43.05,44.67 arc(42.95,44.71) 42.91,44.81 42.91,45.11 43.05,45.26 43.05,45.51 42.91,45.66 42.91,45.91 43.05,46.06 43.05,46.32 42.91,46.46 42.91,46.59 arc(43.04,46.91) 43.36,47.04 43.77,47.04 arc(43.98,47) 44.17,46.88 44.21,46.84 arc(44.43,46.69) 44.69,46.64 44.91,46.64 arc(45.17,46.69) 45.39,46.84 45.9,47.34 arc(46.05,47.44) 46.22,47.48 46.28,47.48 arc(46.54,47.42) 46.77,47.27 46.84,47.2 arc(47.1,47.03) 47.41,46.97 47.64,46.97 arc(47.91,47.02) 48.13,47.17 48.71,47.75 arc(48.86,47.88) 49.03,47.97 49.15,48.02 arc(49.3,48.1) 49.44,48.21 49.51,48.28 arc(49.74,48.63) 49.83,49.05 49.83,49.24 arc(49.98,50.03) 50.43,50.7 52.35,52.62 arc(53.2,53.89) 53.49,55.38 53.49,55.86 arc(53.75,57.14) 54.47,58.23 55.42,59.18 arc(57.09,60.29) 59.06,60.68 64.65,60.68 arc(65.71,60.82) 66.69,61.22 arc(67.48,61.56) 68.33,61.7 71.86,61.7 arc(72.31,61.76) 72.74,61.93 arc(73.03,62.05) 73.33,62.11 77.2,62.11 arc(77.45,62.07) 77.68,61.98 arc(78.04,61.85) 78.43,61.8 78.71,61.8 arc(78.95,61.86) 79.12,62.04 79.18,62.13 arc(79.27,62.22) 79.4,62.26 79.52,62.26 arc(79.76,62.32) 79.94,62.5 80.03,62.67 arc(80.08,62.85) 80.02,63.03 80,63.05 arc(79.99,63.12) 80.03,63.18 v4(80.26,63.31)
QSFP_RX3_N: length 40.8
  L03_SIG1 w0.079: v4(47.77,44.55) 48.03,44.81 arc(48.06,44.83) 48.09,44.84 48.17,44.84 arc(48.48,44.97) 48.61,45.28 48.61,46.4 arc(48.66,46.65) 48.8,46.86 49.07,47.13 arc(49.17,47.21) 49.29,47.28 49.63,47.42 arc(49.8,47.51) 49.94,47.63 50.08,47.77 arc(50.42,48.27) 50.54,48.87 50.54,49.05 arc(50.67,49.72) 51.05,50.28 55.35,54.58 arc(55.89,54.94) 56.52,55.07 56.83,55.07 arc(57.28,55.16) 57.66,55.41 57.81,55.56 arc(58.76,56.2) 59.89,56.42 69.03,56.42 arc(69.96,56.61) 70.75,57.14 71.95,58.34 arc(72.9,58.97) 74.01,59.19 74.38,59.19 arc(74.81,59.28) 75.18,59.53 75.4,59.74 arc(75.64,59.9) 75.93,59.96 78.71,59.96 arc(78.95,60.02) 79.12,60.2 79.18,60.29 arc(79.27,60.38) 79.4,60.42 79.52,60.42 arc(79.76,60.48) 79.94,60.66 80.03,60.83 arc(80.08,61.01) 80.02,61.19 80,61.21 arc(79.99,61.28) 80.03,61.34 v4(80.26,61.47)
QSFP_RX3_P: length 40.8
  L03_SIG1 w0.079: v4(47.77,45.35) 48.03,45.09 arc(48.06,45.07) 48.09,45.07 48.17,45.07 arc(48.32,45.13) 48.38,45.28 48.38,45.56 48.23,45.71 48.23,45.96 48.38,46.11 48.38,46.4 arc(48.45,46.74) 48.64,47.02 48.91,47.29 arc(49.05,47.4) 49.2,47.49 49.54,47.63 arc(49.67,47.7) 49.78,47.79 49.92,47.93 arc(50.21,48.36) 50.31,48.87 50.31,49.05 arc(50.46,49.8) 50.88,50.44 55.19,54.75 arc(55.8,55.15) 56.52,55.3 56.83,55.3 arc(57.19,55.37) 57.5,55.58 57.65,55.72 arc(58.68,56.41) 59.89,56.65 69.03,56.65 arc(69.88,56.82) 70.59,57.3 71.79,58.5 arc(72.81,59.18) 74.01,59.42 74.37,59.42 arc(74.72,59.5) 75.02,59.69 75.24,59.9 arc(75.55,60.11) 75.93,60.19 76.32,60.19 76.46,60.33 76.71,60.33 76.85,60.19 77.11,60.19 77.26,60.34 77.51,60.34 77.66,60.19 77.91,60.19 78.06,60.34 78.31,60.34 78.46,60.19 78.71,60.19 arc(78.84,60.22) 78.93,60.31 78.98,60.4 arc(79.16,60.58) 79.4,60.65 79.52,60.65 arc(79.65,60.68) 79.74,60.77 79.84,60.94 arc(79.85,61) 79.83,61.06 79.8,61.11 arc(79.75,61.15) 79.68,61.14 v4(79.46,61.01)
QSFP_TX0_N: length 41.1
  L16_SIG6 w0.079: U8.BM48 84.83,65.03 arc(84.75,65.02) 84.68,65.07 84.66,65.11 arc(84.53,65.23) 84.36,65.28 84.22,65.28 arc(84.06,65.32) 83.94,65.44 83.92,65.48 arc(83.74,65.65) 83.51,65.72 81.81,65.72 arc(81.55,65.65) 81.36,65.46 81.32,65.37 arc(81.24,65.29) 81.12,65.26 80.95,65.26 arc(80.81,65.24) 80.68,65.19 79.28,64.37 arc(79.1,64.24) 78.97,64.06 78.94,64.02 arc(78.84,63.92) 78.71,63.88 76.23,63.88 arc(76.07,63.89) 75.9,63.9 75.26,63.96 arc(75.01,63.98) 74.77,63.99 71.54,63.99 arc(70.68,63.87) 69.88,63.55 arc(69.2,63.27) 68.46,63.17 65.29,63.17 arc(57.42,61.61) 50.76,57.15 48.33,54.73 arc(48.26,54.68) 48.18,54.67 48.09,54.67 arc(48.06,54.67) 48.03,54.69 47.77,54.95
QSFP_TX0_P: length 41.1
  L16_SIG6 w0.079: 47.77,54.15 48.03,54.41 arc(48.06,54.43) 48.09,54.44 48.18,54.44 arc(48.35,54.47) 48.5,54.57 50.92,56.99 arc(57.51,61.4) 65.29,62.94 68.46,62.94 arc(69.25,63.05) 69.99,63.35 arc(70.74,63.65) 71.54,63.76 74.77,63.76 arc(75,63.75) 75.24,63.73 75.88,63.67 arc(76.05,63.66) 76.23,63.65 76.93,63.65 77.08,63.51 77.33,63.51 77.48,63.65 77.73,63.65 77.88,63.51 78.13,63.51 78.28,63.65 78.71,63.65 arc(78.96,63.72) 79.14,63.9 79.16,63.95 arc(79.26,64.08) 79.39,64.18 80.8,64.99 arc(80.87,65.02) 80.95,65.03 81.12,65.03 arc(81.35,65.09) 81.52,65.26 81.56,65.34 arc(81.67,65.45) 81.81,65.49 83.51,65.49 arc(83.63,65.45) 83.72,65.36 83.74,65.32 arc(83.94,65.12) 84.22,65.05 84.36,65.05 arc(84.42,65.03) 84.46,64.99 84.49,64.95 arc(84.5,64.87) 84.46,64.81 U8.BL49
QSFP_TX1_N: length 53.1
  L16_SIG6 w0.079: U8.BA51 82.44,60.21 arc(82.36,60.22) 82.29,60.17 82.27,60.13 arc(82.14,60.01) 81.96,59.96 81.84,59.96 arc(81.69,59.92) 81.57,59.82 81.49,59.71 arc(81.33,59.56) 81.12,59.51 80.93,59.51 arc(80.85,59.5) 80.78,59.47 79.41,58.68 arc(79.29,58.59) 79.2,58.47 79.17,58.41 arc(78.97,58.21) 78.69,58.13 76.84,58.13 arc(76.07,57.98) 75.41,57.54 75.21,57.34 arc(74.75,57.03) 74.2,56.92 72.9,56.92 arc(71.67,56.76) 70.53,56.28 arc(69.43,55.81) 68.26,55.63 62.62,55.63 arc(61.87,55.56) 61.15,55.34 57.69,53.9 arc(57.18,53.75) 56.66,53.7 56.6,53.7 arc(55.88,53.55) 55.26,53.14 50,47.88 arc(49.03,47.23) 47.89,47.01 47.52,47.01 arc(47.15,47.08) 46.84,47.29 arc(46.66,47.41) 46.45,47.45 46.14,47.45 arc(45.99,47.42) 45.87,47.34 45.38,46.85 arc(45.15,46.7) 44.88,46.64 44.79,46.64 arc(44.44,46.71) 44.14,46.92 41.89,49.16 arc(41.71,49.42) 41.65,49.73 41.65,53.21 arc(41.96,53.95) 42.71,54.27 43.16,54.27 arc(43.19,54.27) 43.22,54.29 43.48,54.55
QSFP_TX1_P: length 53.1
  L16_SIG6 w0.079: 43.48,53.75 43.22,54.01 arc(43.19,54.03) 43.16,54.04 42.71,54.04 arc(42.12,53.79) 41.88,53.21 41.88,53.07 42.03,52.92 42.03,52.67 41.88,52.52 41.88,52.21 42.03,52.07 42.03,51.81 41.88,51.66 41.88,51.32 42.03,51.17 42.03,50.91 41.88,50.77 41.88,49.73 arc(41.93,49.51) 42.05,49.32 42.23,49.14 42.44,49.14 42.62,48.96 42.62,48.75 42.8,48.57 43.01,48.57 43.19,48.4 43.19,48.19 43.37,48.01 43.57,48.01 43.75,47.83 43.75,47.62 44.3,47.08 arc(44.52,46.92) 44.79,46.87 44.88,46.87 arc(45.06,46.91) 45.22,47.01 45.71,47.5 arc(45.91,47.63) 46.14,47.68 46.45,47.68 arc(46.74,47.62) 47,47.45 arc(47.11,47.36) 47.24,47.29 arc(47.37,47.25) 47.52,47.23 47.89,47.23 arc(48.94,47.44) 49.84,48.04 55.1,53.3 arc(55.79,53.77) 56.6,53.93 56.66,53.93 arc(57.14,53.97) 57.6,54.11 61.06,55.55 arc(61.83,55.78) 62.62,55.86 68.26,55.86 arc(69.37,56.03) 70.41,56.47 arc(71.61,56.98) 72.9,57.15 74.2,57.15 arc(74.66,57.24) 75.05,57.51 75.25,57.7 arc(75.98,58.19) 76.84,58.36 77.08,58.36 77.21,58.5 77.49,58.5 77.63,58.36 77.88,58.36 78.02,58.5 78.29,58.5 78.43,58.36 78.69,58.36 arc(78.85,58.4) 78.97,58.52 79,58.58 arc(79.13,58.75) 79.29,58.88 80.66,59.67 arc(80.79,59.72) 80.93,59.74 81.12,59.74 arc(81.22,59.77) 81.3,59.84 81.38,59.95 arc(81.58,60.13) 81.84,60.19 81.96,60.19 arc(82.03,60.21) 82.08,60.25 82.1,60.29 arc(82.11,60.36) 82.06,60.42 U8.BB52
QSFP_TX2_N: length 40.6
  L16_SIG6 w0.079: 47.77,52.55 48.03,52.29 arc(48.06,52.27) 48.09,52.27 48.42,52.27 arc(48.58,52.23) 48.72,52.14 arc(48.78,52.1) 48.86,52.08 49.96,52.08 arc(50.5,52.19) 50.96,52.5 52.61,54.15 arc(53.08,54.85) 53.25,55.68 53.25,55.79 arc(53.53,57.21) 54.33,58.41 54.92,58.99 arc(57.04,60.41) 59.55,60.91 63.78,60.91 arc(64.77,60.96) 65.74,61.1 68.73,61.7 arc(69.76,61.85) 70.79,61.9 72.6,61.9 arc(72.94,61.95) 73.25,62.1 arc(73.66,62.29) 74.11,62.36 75.8,62.36 arc(76.1,62.3) 76.36,62.13 arc(76.46,62.06) 76.59,62.04 76.89,62.04 77.04,62.19 77.3,62.19 77.44,62.04 77.7,62.04 77.84,62.19 78.1,62.19 78.25,62.04 78.68,62.04 arc(78.84,62.08) 78.95,62.2 78.98,62.25 arc(79.11,62.42) 79.28,62.55 80.66,63.35 arc(80.79,63.4) 80.93,63.42 81.12,63.42 arc(81.22,63.45) 81.3,63.52 81.38,63.63 arc(81.58,63.81) 81.84,63.87 81.96,63.87 arc(82.03,63.89) 82.08,63.93 82.1,63.97 arc(82.11,64.04) 82.06,64.1 U8.BK52
QSFP_TX2_P: length 40.6
  L16_SIG6 w0.079: 47.77,51.75 48.03,52.01 arc(48.06,52.03) 48.09,52.04 48.42,52.04 arc(48.49,52.02) 48.56,51.98 arc(48.7,51.89) 48.86,51.85 49.96,51.85 arc(50.59,51.98) 51.12,52.34 52.77,53.99 arc(53.29,54.76) 53.47,55.68 53.47,55.79 arc(53.74,57.12) 54.49,58.25 55.08,58.83 arc(57.13,60.2) 59.55,60.68 63.78,60.68 arc(64.79,60.73) 65.78,60.88 68.78,61.48 arc(69.78,61.62) 70.79,61.67 72.6,61.67 arc(73,61.73) 73.38,61.9 arc(73.73,62.07) 74.11,62.13 75.8,62.13 arc(76.02,62.09) 76.2,61.97 arc(76.38,61.85) 76.59,61.81 78.68,61.81 arc(78.95,61.89) 79.15,62.09 79.18,62.14 arc(79.27,62.26) 79.39,62.35 80.78,63.15 arc(80.85,63.18) 80.93,63.19 81.12,63.19 arc(81.33,63.24) 81.49,63.39 81.57,63.5 arc(81.69,63.6) 81.84,63.64 81.96,63.64 arc(82.14,63.69) 82.27,63.81 82.29,63.85 arc(82.36,63.9) 82.44,63.89 U8.BJ51
QSFP_TX3_N: length 43.1
  L16_SIG6 w0.079: 43.48,52.15 43.74,51.89 arc(43.77,51.87) 43.8,51.87 45.07,51.87 arc(45.93,51.69) 46.67,51.21 46.98,50.9 arc(47.4,50.61) 47.89,50.52 48.35,50.52 arc(50.81,51) 52.89,52.4 55.42,54.93 arc(55.97,55.3) 56.62,55.43 56.73,55.43 arc(57.48,55.5) 58.19,55.72 59.05,56.07 arc(62.22,57.03) 65.52,57.36 68.92,57.36 arc(69.34,57.4) 69.74,57.52 70.58,57.87 arc(70.75,57.96) 70.91,58.09 71.03,58.21 arc(71.47,58.58) 71.98,58.84 73.32,59.4 arc(73.6,59.49) 73.9,59.51 74.13,59.51 arc(74.57,59.61) 74.96,59.86 arc(75.34,60.11) 75.79,60.2 77,60.2 77.14,60.35 77.4,60.35 77.55,60.2 77.83,60.2 77.98,60.35 78.23,60.35 78.38,60.2 78.67,60.2 arc(78.83,60.24) 78.94,60.36 78.96,60.4 arc(79.09,60.57) 79.25,60.69 80.66,61.51 arc(80.79,61.56) 80.93,61.58 81.12,61.58 arc(81.22,61.61) 81.3,61.68 81.38,61.79 arc(81.58,61.97) 81.84,62.03 81.96,62.03 arc(82.03,62.05) 82.08,62.09 82.1,62.13 arc(82.11,62.2) 82.06,62.26 U8.BF52
QSFP_TX3_P: length 43.1
  L16_SIG6 w0.079: U8.BE51 82.44,62.05 arc(82.36,62.06) 82.29,62.01 82.27,61.97 arc(82.14,61.85) 81.96,61.8 81.84,61.8 arc(81.69,61.76) 81.57,61.66 81.49,61.55 arc(81.33,61.4) 81.12,61.35 80.93,61.35 arc(80.85,61.34) 80.78,61.31 79.37,60.5 arc(79.25,60.4) 79.16,60.29 79.14,60.25 arc(78.94,60.05) 78.67,59.97 75.79,59.97 arc(75.43,59.9) 75.12,59.69 arc(74.66,59.4) 74.13,59.29 73.9,59.29 arc(73.65,59.26) 73.41,59.19 72.06,58.63 arc(71.6,58.39) 71.2,58.05 71.07,57.92 arc(70.88,57.77) 70.67,57.66 69.83,57.31 arc(69.38,57.18) 68.92,57.13 65.52,57.13 arc(62.26,56.81) 59.14,55.86 58.28,55.5 arc(57.52,55.27) 56.73,55.2 56.62,55.2 arc(56.06,55.09) 55.58,54.77 53.05,52.23 arc(50.89,50.79) 48.35,50.29 47.89,50.29 arc(47.31,50.4) 46.81,50.73 46.5,51.04 arc(45.85,51.48) 45.07,51.64 43.8,51.64 arc(43.77,51.63) 43.74,51.61 43.48,51.35
QSFP_VCC: length 0.8
  TOP w0.33: v1(47.39,49.35) 47.95,49.35 v1(48.09,49.49)
  vias: v1(46.39,49.35)
QSFP_VCCR:
  vias: v1(44.37,48.15) v1(45.13,48.15)
QSFP_VCCT: length 0.7
  TOP w0.33: v1(47.39,48.55) 48.04,48.55 v1(48.09,48.6)
  vias: v1(46.39,48.55)
QSFPDD_1V2_LED1: length 87.6
  L14_SIG5 w0.081: v1(84.24,44.45) 83.88,44.09 83.88,43.85 83.65,43.61 80.04,43.61 79.69,43.97 73.79,43.97 72.65,45.11 59.27,45.11 56.73,42.57 55.58,42.57 43.9,30.89 43.9,30.38 43.44,29.92 40.32,29.92 39.91,30.33 38.96,30.33 38.37,29.75 34.57,29.75 34.46,29.85 25.81,29.85 25.66,29.7 14.7,29.7 12.05,27.05 12.05,25.08 v1(10.42,23.45)
  BOTTOM w0.149: U89.3 9.74,24.34 10.42,23.65 v1(10.42,23.45)
QSFPDD_1V2_LED2: length 89.4
  L14_SIG5 w0.081: v1(10.42,22.43) 13.09,25.1 13.09,25.79 14.41,27.11 15.46,27.11 16.17,27.82 17.62,27.82 18.19,27.26 24.55,27.26 26.46,29.16 33.94,29.16 34.6,28.5 37.14,28.5 37.52,28.88 38.5,28.88 38.94,29.31 43.26,29.31 46.11,32.16 46.11,32.59 55.46,41.94 56.52,41.94 59.29,44.71 72.42,44.71 74.14,42.98 79.66,42.98 80,42.65 80.5,42.65 80.83,42.98 84.25,42.98 84.78,43.51 84.78,43.73 v1(85.04,43.99)
  BOTTOM w0.149: U89.4 9.68,23.94 9.91,23.7 9.91,22.94 v1(10.42,22.43)
QSFPDD_3V3_LPMODE: length 46.7
  TOP w0.149: v1(59.63,27.8) 59.08,28.36 J7.31
  L03_SIG1 w0.081: v1(28.73,17.04) 28.73,18.6 27.85,19.48 27.85,23.32 26.83,24.34 v1(26.17,24.34)
  L14_SIG5 w0.081: v1(59.63,27.8) 59.27,28.17 57.31,28.17 56.32,27.18 51.82,27.18 51.04,26.39 51.04,25.33 50.07,24.36 49.11,24.36 48.62,24.84 35.57,24.84 35.41,24.69 26.52,24.69 v1(26.17,24.34)
QSFPDD_3V3_MODPRS_L: length 130.6
  TOP w0.149: v1(62.36,25.48) 61.86,25.99 60.21,25.99 59.38,25.16 J7.27
  L05_SIG2 w0.081: v1(28.74,23.53) 28.03,23.53 27.11,22.61 14.69,22.61 12.54,24.75 12.54,26.53 10.93,28.14 10.93,33.48 9.91,34.5 9.91,41.43 7.22,44.12 7.22,49.58 7.75,50.12 7.75,53.58 7.33,54.01 7.33,59.22 9.41,61.29 9.41,62.31 8.08,63.64 8.08,76.84 8.51,77.27 8.88,77.27 10.5,78.9 11.64,78.9 12.53,79.78 17.25,79.78 18.55,81.08 20.48,81.08 20.91,80.65 v1(21.18,80.65)
  L07_SIG3 w0.089: v1(28.74,23.53) 29.96,22.3 38.87,22.3 39.89,21.29 44.39,21.29 45.15,20.53 46.38,20.53 v1(47.26,21.41)
  L14_SIG5 w0.081: v1(62.36,25.48) 61.98,25.86 60.59,25.86 59.82,25.1 54.87,25.1 52.33,22.56 48.41,22.56 v1(47.26,21.41)
QSFPDD_3V3_SELN: length 27.6
  TOP w0.149: J7.8 v4(48.22,27.96)
  L03_SIG1 w0.081: v4(48.22,27.96) 47.57,27.96 47.25,27.64 45.35,27.64 44.46,26.75 44.46,24.59 45.41,23.64 v1(45.41,22.43)
  L05_SIG2 w0.081: v1(45.41,22.43) 45.14,22.16 45.14,22.04 44.87,21.77 39.07,21.77 38.32,22.52 31.66,22.52 29.9,24.29 v1(29.39,24.29)
QSFPDD_FAULT_N: length 51.9
  TOP w0.149: U5.D14 31.68,70.15 31.68,68.15 v1(31.18,67.65)
  L03_SIG1 w0.081: v1(34.81,28.94) 35.53,28.22 40.44,28.22 v1(41.03,28.81)
  L07_SIG3 w0.089: v1(34.81,28.94) 34.42,29.32 34.42,36.19 32.48,38.14 32.48,46.69 31.19,47.98 31.19,54.12 30.61,54.69 30.61,64.17 29.47,65.31 29.47,65.95 v1(31.18,67.65)
  BOTTOM w0.152: U20.8 v1(41.03,28.81)
QSFPDD_LED1: length 18.5
  L16_SIG6 w0.081: v1(6.1,23.45) 9.33,20.22 15.48,20.22 18.53,17.16 v1(20.09,17.16)
  BOTTOM w0.149: v1(6.1,23.45) 6.99,24.34 U89.9
QSFPDD_LED2: length 9.9
  L16_SIG6 w0.081: v1(11.23,17.16) 11.23,17.31 v1(6.1,22.43)
  BOTTOM w0.149: U89.8 7.1,23.94 6.87,23.7 6.87,23.19 v1(6.1,22.43)
QSFPDD_PWR_EN: length 53
  L07_SIG3 w0.089: v1(37.46,32.49) 37.75,32.19 37.75,29.14 37.01,28.4 34.53,28.4 33.97,28.96 33.97,35.98 29.28,40.67 29.28,43.51 27.88,44.91 27.88,65.03 28.07,65.23 28.07,66.55 v1(30.18,68.65)
  BOTTOM w0.152: v1(37.46,32.49) 37.46,31.21 37.87,30.8 U20.4
QSFPDD_REFCLK_N: length 24.9
  L14_SIG5 w0.079: v1(68.33,57.93) 68.63,57.93 68.72,57.84 68.72,54.57 71.7,51.59 72.56,51.59 73.21,50.95 73.71,50.95 74.3,51.53 74.3,51.81 74.86,52.38 75.38,52.38 76.07,51.69 80.05,51.69 80.5,52.15 81.19,52.15 81.36,51.98 81.39,51.98 81.4,51.96
  L14_SIG5 w0.081: v1(84.24,51.81) 84.47,51.94 84.49,52.04 84.44,52.12 84.37,52.17 84.06,52.17 83.95,52.11 83.8,51.83 83.59,51.71 83.22,51.71 82.8,52.13 82.47,52.13 82.08,51.74 81.62,51.74 81.4,51.96
  BOTTOM w0.102: R6924.2 85.42,51.73 84.55,51.73 84.48,51.81 v1(84.24,51.81)
QSFPDD_REFCLK_P: length 25
  L14_SIG5 w0.079: 81.54,52.1 81.52,52.12 81.52,52.14 81.29,52.37 80.41,52.37 79.95,51.92 76.16,51.92 75.48,52.6 74.77,52.6 74.07,51.9 74.07,51.63 73.62,51.18 73.3,51.18 72.66,51.82 71.8,51.82 68.95,54.67 68.95,56.59 69.05,56.69 69.12,56.69 69.2,56.77 69.2,57 69.12,57.08 69.05,57.08 68.95,57.18 68.95,57.85 69.03,57.93 v1(69.35,57.93)
  L14_SIG5 w0.081: 81.54,52.1 81.7,51.94 82,51.94 82.39,52.33 82.88,52.33 83.3,51.91 83.54,51.91 83.65,51.98 83.81,52.25 84.01,52.36 84.42,52.36 84.59,52.26 84.63,52.19 84.81,52.14 v1(85.04,52.27)
  BOTTOM w0.102: v1(85.04,52.27) 86.14,52.27 R6923.2
QSFPDD_RX0_N: length 61.3
  L03_SIG1 w0.079: v4(80.26,57.79) 80.03,57.66 arc(79.99,57.6) 80,57.53 80.02,57.51 arc(80.08,57.33) 80.03,57.15 79.94,56.98 arc(79.76,56.8) 79.52,56.74 79.4,56.74 arc(79.27,56.7) 79.18,56.61 79.12,56.52 arc(78.95,56.34) 78.71,56.28 78.58,56.28 arc(78.49,56.26) 78.42,56.21 76.17,53.97 arc(75.46,53.18) 74.82,52.32 74.68,52.12 arc(74.36,51.67) 74.01,51.24 arc(73.47,50.58) 72.97,49.89 70.11,45.61 arc(69.97,45.43) 69.82,45.26 69.62,45.06 arc(69.4,44.88) 69.15,44.75 68.8,44.6 arc(68.61,44.5) 68.44,44.36 68.38,44.3 arc(67.99,43.98) 67.55,43.75 67.04,43.54 arc(66.48,43.37) 65.9,43.31 62.3,43.31 arc(60.67,43.15) 59.11,42.68 57.31,41.93 arc(56.44,41.47) 55.67,40.84 55.38,40.55 arc(55.08,40.22) 54.8,39.87 52.48,36.7 arc(51.33,34.46) 50.93,31.97 50.93,30.64 51.08,30.49 51.08,30.24 50.93,30.09 50.93,29.76 arc(50.7,28.58) 50.03,27.58 49.94,27.49 arc(49.67,27.1) 49.56,26.64 49.56,26.52 arc(49.45,26.07) 49.19,25.69 49.07,25.57 49.07,25.37 48.89,25.19 48.69,25.19 48.45,24.95 arc(48.16,24.52) 48.06,24.02 48.06,23.84 48.21,23.69 48.21,23.44 48.06,23.29 48.06,23.04 48.21,22.89 48.21,22.64 48.06,22.49 48.06,22.23 48.21,22.09 48.21,21.83 48.06,21.69 48.06,21.29 48.21,21.15 48.21,20.89 48.06,20.75 48.06,20.49 48.21,20.34 48.21,20.09 48.06,19.94 48.06,19.69 arc(48.33,19.04) 48.98,18.77 49.23,18.77 49.38,18.92 49.63,18.92 49.78,18.77 49.97,18.77 arc(50.11,18.8) 50.24,18.89 50.4,19.05 arc(50.51,19.22) 50.55,19.41 50.55,20.14 arc(50.52,20.21) 50.44,20.24 50.31,20.24 arc(50.27,20.24) 50.25,20.22 v4(49.99,19.96)
QSFPDD_RX0_P: length 61.3
  L03_SIG1 w0.079: v4(79.46,57.33) 79.68,57.46 arc(79.75,57.47) 79.8,57.43 79.83,57.38 arc(79.85,57.32) 79.84,57.26 79.74,57.09 arc(79.65,57) 79.52,56.97 79.4,56.97 arc(79.16,56.9) 78.98,56.72 78.93,56.63 arc(78.84,56.54) 78.71,56.51 78.58,56.51 arc(78.4,56.47) 78.26,56.38 76.01,54.13 arc(75.28,53.32) 74.63,52.45 74.49,52.24 arc(74.18,51.81) 73.84,51.39 arc(73.28,50.72) 72.78,50.02 69.92,45.74 arc(69.8,45.57) 69.66,45.42 69.46,45.22 arc(69.28,45.07) 69.07,44.96 68.71,44.81 arc(68.48,44.69) 68.28,44.52 68.22,44.46 arc(67.86,44.17) 67.46,43.96 66.95,43.75 arc(66.44,43.59) 65.9,43.54 62.3,43.54 arc(60.63,43.37) 59.02,42.89 57.23,42.14 arc(56.31,41.66) 55.51,41 55.22,40.71 arc(54.91,40.37) 54.62,40 52.3,36.84 arc(51.11,34.53) 50.71,31.97 50.71,29.76 arc(50.49,28.67) 49.87,27.74 49.78,27.65 arc(49.46,27.19) 49.33,26.66 49.33,26.53 arc(49.24,26.16) 49.03,25.85 48.29,25.11 arc(47.95,24.61) 47.84,24.02 47.84,19.69 arc(48.17,18.88) 48.98,18.55 49.97,18.55 arc(50.2,18.59) 50.4,18.72 50.56,18.89 arc(50.72,19.13) 50.78,19.41 50.78,20.14 arc(50.68,20.37) 50.44,20.47 50.31,20.47 arc(50.27,20.48) 50.25,20.5 v4(49.99,20.76)
