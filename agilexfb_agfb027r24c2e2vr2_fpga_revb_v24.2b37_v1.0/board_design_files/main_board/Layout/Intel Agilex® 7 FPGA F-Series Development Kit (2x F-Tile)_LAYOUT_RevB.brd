# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM2_DQS_N2: length 73.2
  L05_SIG2 w0.076: 79.46,76.1 79.48,76.1 79.48,76.1 79.56,76.1 arc(79.64,76.08) 79.71,76.02 79.82,75.85 arc(79.99,75.7) 80.22,75.64 80.29,75.64 arc(80.42,75.61) 80.52,75.53 80.62,75.39 arc(80.81,75.23) 81.04,75.18 81.09,75.18 arc(81.28,75.22) 81.43,75.33 81.64,75.56 arc(81.72,75.62) 81.83,75.64 81.91,75.64 arc(82.01,75.62) 82.1,75.55 82.23,75.37 arc(82.4,75.23) 82.62,75.18 82.8,75.18 arc(82.85,75.17) 82.89,75.13 82.95,75.02 arc(82.96,74.96) 82.92,74.9 v1(82.65,74.81)
  L05_SIG2 w0.081: 79.46,76.1 79.26,76.1 78.93,76.43 78.93,77.03 77.56,78.4 77.56,86.63 78.63,87.69 78.63,92.75 78.26,93.12 75.67,93.12 75.22,93.56 75.22,94.07 74.88,94.41 74.88,95.07 75.17,95.37 78.45,95.37 78.62,95.54 78.62,96.06 78.41,96.27 74.62,96.27 74.32,96.56 74.32,97.29 74.62,97.58 78.29,97.58 78.69,97.98 78.69,99.45 78.37,99.77 78.37,100.41 78.53,100.57 78.53,101.79 78.12,102.19 78.12,103.23 77.32,104.03 75.22,104.03 74.84,104.42 73.69,104.42 73.31,104.03 70.04,104.03 69.69,104.39 69.69,105.11 70.01,105.43 71.73,105.43 72.5,106.2 74.18,106.2 74.94,105.43 78.48,105.43 78.64,105.6 78.64,106.06 78.43,106.27 75.32,106.27 75.08,106.51 75.08,107.26 v1(74.74,107.6)
DDR4_DIMM2_DQS_N3: length 69.1
  L16_SIG6 w0.076: 86.42,82.63 86.42,82.61 86.41,82.61 86.41,82.05 86.28,81.84 arc(86.24,81.7) 86.27,81.56 86.34,81.45 arc(86.4,81.22) 86.32,81.01 86.28,80.96 arc(86.23,80.84) 86.25,80.72 86.35,80.53 arc(86.39,80.33) 86.35,80.13 86.29,80.02 arc(86.26,79.86) 86.3,79.71 86.37,79.57 arc(86.42,79.35) 86.36,79.14 86.31,79.07 arc(86.27,78.93) 86.31,78.79 86.36,78.69 arc(86.42,78.5) 86.36,78.31 86.29,78.18 arc(86.25,78.02) 86.3,77.85 86.36,77.77 arc(86.45,77.69) 86.56,77.66 86.64,77.66 arc(86.89,77.6) 87.08,77.43 87.18,77.27 arc(87.27,77.19) 87.39,77.16 87.53,77.16 arc(87.61,77.18) 87.67,77.24 87.7,77.31 87.67,77.43 v1(87.43,77.57)
  L16_SIG6 w0.081: v1(84.09,107.6) 84.44,107.95 84.44,108.16 84.67,108.38 88.67,108.38 88.89,108.16 88.89,107.3 88.34,106.75 88.34,106.47 88.07,106.2 83.23,106.2 82.99,105.96 82.99,104.26 83.12,104.14 83.42,104.14 83.55,104.26 83.55,105.44 83.78,105.67 84.17,105.67 84.4,105.44 84.4,104.26 84.53,104.14 84.76,104.14 84.89,104.26 84.89,105.44 85.12,105.67 85.51,105.67 85.74,105.44 85.74,104.26 85.87,104.14 86.1,104.14 86.23,104.26 86.23,104.97 86.46,105.2 86.85,105.2 87.08,104.97 87.08,104.26 87.21,104.14 87.44,104.14 87.57,104.26 87.57,105.39 87.8,105.62 88.19,105.62 88.42,105.39 88.42,102.96 88.91,102.48 88.91,101.86 88.77,101.71 88.77,100.37 88.91,100.22 88.91,99.75 88.53,99.37 87.77,99.37 86.36,97.96 84.94,97.96 84.82,97.84 84.82,97.56 84.94,97.43 86.88,97.43 87.11,97.19 87.11,96.54 86.88,96.31 84.95,96.31 84.83,96.18 84.83,95.03 84.55,94.75 84.55,94.33 84.68,94.19 84.68,93.57 84.45,93.34 83.39,93.34 83.28,93.24 83.28,92.9 83.39,92.79 84.35,92.79 84.56,92.58 84.56,84.8 86.42,82.94 86.42,82.63
DDR4_DIMM2_DQS_N4: length 93.4
  L03_SIG1 w0.076: 79.31,75.36 79.33,75.36 79.33,75.36 79.51,75.36 arc(79.64,75.39) 79.74,75.47 79.85,75.61 arc(80.03,75.76) 80.27,75.82 80.29,75.82 arc(80.49,75.77) 80.66,75.64 80.77,75.49 arc(80.89,75.39) 81.04,75.36 81.09,75.36 arc(81.2,75.38) 81.3,75.45 81.48,75.65 arc(81.65,75.77) 81.86,75.82 arc(82.09,75.76) 82.26,75.62 82.36,75.49 82.41,75.44 arc(82.47,75.39) 82.56,75.36 82.63,75.36 arc(82.83,75.4) 82.97,75.55 arc(83.14,75.74) 83.39,75.81 83.54,75.81 arc(83.63,75.84) 83.7,75.9 83.76,76 arc(83.78,76.37) 83.46,76.56 83.37,76.56 arc(83.12,76.63) 82.95,76.83 82.89,76.99 arc(82.86,77.13) 82.89,77.26 82.91,77.29 arc(82.92,77.36) 82.88,77.43 82.86,77.44 v4(82.65,77.57)
  L03_SIG1 w0.081: v4(139.34,107.6) 139.7,107.6 139.78,107.68 139.78,107.89 139.59,108.08 139.17,108.08 138.89,107.79 138.89,107.49 139.08,107.3 139.08,106.67 138.99,106.58 138.99,106.44 138.84,106.29 138.7,106.29 138.5,106.09 138.28,106.09 138.2,106.01 138.2,105.84 138.12,105.76 137.92,105.76 137.84,105.84 137.84,106.01 137.75,106.09 134.13,106.09 131.28,104.91 122.23,104.91 119.54,102.22 114.54,102.22 114.03,102.74 110.5,102.74 109.76,102 104.22,102 104.1,101.87 103.19,101.87 103.06,102 101.8,102 101.12,101.32 101.12,100.77 99.02,98.67 96.7,98.67 94.3,97.68 91.71,95.09 90.4,94.54 87.43,94.54 86.11,93.23 85.57,93.23 76.78,84.44 76.78,77.92 77.09,77.18 78.53,75.74 78.69,75.74 78.79,75.63 78.79,75.47 78.9,75.36 79.31,75.36
DDR4_DIMM2_DQS_N5: length 99.3
  L05_SIG2 w0.076: 81.52,82.31 81.52,82.31 81.32,81.87 arc(81.29,81.7) 81.33,81.53 81.41,81.35 arc(81.44,81.25) 81.43,81.16 arc(81.41,81.13) 81.4,81.1 81.35,81.02 arc(81.31,80.94) 81.3,80.84 81.3,80.73 arc(81.31,80.66) 81.34,80.59 81.41,80.46 arc(81.43,80.41) 81.43,80.36 81.43,80.3 arc(81.42,80.24) 81.4,80.18 81.29,80.01 81.29,80 arc(81.27,79.88) 81.3,79.75 81.32,79.71 arc(81.32,79.65) 81.29,79.6 arc(81.17,79.5) v1(81.05,79.41)
  L05_SIG2 w0.081: v1(148.69,107.6) 149.03,107.26 149.03,106.97 148.91,106.84 148.91,106.64 149.03,106.51 149.03,106.21 149.56,105.68 149.56,104.12 149.46,104.03 148.87,104.03 148.59,104.3 148.59,104.48 149.07,104.96 149.07,105.29 148.64,105.73 148.31,105.73 147.83,105.25 147.65,105.25 146.54,106.36 142.49,106.36 142.35,106.51 136.38,106.51 135.73,107.16 132.76,107.16 132.5,107.42 132.5,108.12 131.57,109.04 120.12,109.04 119.93,108.85 118.36,108.85 118.12,109.09 102.44,109.09 101.17,107.82 100.23,107.82 99.49,107.07 97.65,107.07 97.07,106.49 96.15,106.49 93.97,104.32 93.3,104.32 92.32,103.35 90.53,103.35 89.96,102.77 87.87,102.77 86.7,101.61 86.7,100.93 86.05,100.29 86.05,99.75 86.4,99.41 86.4,98.02 84.31,95.94 84.31,94.31 84.52,94.1 84.52,93.79 83.1,92.36 83.1,88.47 82.66,88.03 82.66,83.84 81.83,83.01 81.52,82.31
DDR4_DIMM2_DQS_N6: length 97.1
  L05_SIG2 w0.076: 92.77,82.64 92.77,82.62 92.77,82.61 92.77,82.3 92.65,82.18 92.48,81.9 arc(92.42,81.71) 92.46,81.52 92.54,81.36 arc(92.57,81.21) 92.52,81.06 arc(92.51,81.04) 92.5,81.02 arc(92.45,80.81) 92.48,80.59 arc(92.5,80.57) 92.51,80.54 92.57,80.45 arc(92.6,80.33) 92.57,80.21 92.52,80.12 arc(92.45,79.85) 92.54,79.58 92.57,79.54 arc(92.6,79.43) 92.58,79.32 92.49,79.15 arc(92.44,78.92) 92.51,78.71 92.55,78.64 arc(92.55,78.64) 92.55,78.64 arc(92.55,78.63) 92.55,78.63 arc(92.59,78.49) 92.56,78.36 92.51,78.25 arc(92.45,78.03) 92.5,77.81 92.54,77.72 arc(92.57,77.66) 92.58,77.59 92.58,77.57 arc(92.58,77.51) 92.56,77.45 92.56,77.44 92.49,77.32 arc(92.45,77.12) 92.49,76.92 92.57,76.75 arc(92.59,76.64) 92.57,76.54 arc(92.56,76.52) 92.55,76.5 92.54,76.48 arc(92.46,76.19) 92.54,75.89 92.55,75.88 arc(92.59,75.72) 92.54,75.57 arc(92.54,75.56) 92.54,75.56 92.47,75.45 arc(92.42,75.31) 92.45,75.16 92.47,75.11 arc(92.48,75.05) 92.45,75 v1(92.21,74.81)
  L05_SIG2 w0.081: v1(158.04,107.6) 158.31,107.33 158.31,102.21 159.34,100.67 159.34,99.98 159.15,99.52 156.93,98.6 155.41,97.07 137.09,97.07 134.56,97.57 124.03,97.57 122.3,97.23 121.33,96.83 119.68,95.18 119.21,94.98 118.34,94.98 117.84,95.19 116.43,96.6 114.78,97.29 113.1,97.79 109.6,98.49 104.19,98.49 102.73,97.89 102.54,97.69 102.04,97.49 100.81,97.49 100.02,97.16 97.52,94.66 96.69,94.66 96.2,94.16 96.2,93.53 94.11,91.44 94.11,86.77 93.48,86.13 93.48,84.03 92.77,83.32 92.77,82.64
DDR4_DIMM2_DQS_N7: length 97.4
  L03_SIG1 w0.081: v4(84.24,82.17) 84.48,82.03 84.6,82.06 84.68,82.19 86.66,84.17 92.29,85.88 96.82,85.88 98.33,86.5 98.59,86.76 99.02,87.81 99.58,88.37 109.57,91.4 115.58,91.4 116.33,92.15 127.74,92.15 129.12,93.53 129.12,94.34 129.96,95.19 129.96,95.47 131.74,97.24 132.57,97.24 133.54,98.21 137.38,98.21 137.65,97.94 140.75,97.94 141.44,98.22 142.58,98.22 143.72,99.37 145.24,99.37 147.01,101.14 147.01,101.56 149.09,103.64 149.65,103.64 150.38,104.37 151.41,104.37 153.33,106.29 157.17,106.29 157.61,105.84 158.59,105.84 159,106.26 159.75,106.26 160.17,105.84 160.89,105.84 161.16,106.1 165.74,106.1 165.91,106.28 165.91,106.99 166.14,107.22 166.62,107.22 166.85,106.99 166.85,106.2 166.95,106.1 167.39,106.1 167.77,106.48 167.77,107.22 v4(167.39,107.6)
DDR4_DIMM2_DQS_N8: length 71.1
  L12_SIG4 w0.076: v1(92.21,77.57) 92.52,77.39 92.6,77.4 92.66,77.49 arc(92.67,77.54) 92.65,77.59 92.5,77.79 arc(92.43,77.98) 92.47,78.17 92.52,78.28 92.55,78.33 arc(92.59,78.5) 92.55,78.66 92.47,78.8 arc(92.43,78.98) 92.5,79.16 92.53,79.19 arc(92.6,79.35) 92.57,79.52 92.48,79.69 arc(92.43,79.86) 92.47,80.03 92.55,80.18 arc(92.58,80.34) 92.54,80.49 92.48,80.6 arc(92.43,80.82) 92.5,81.04 92.55,81.12 arc(92.59,81.22) 92.56,81.33 92.5,81.45 arc(92.44,81.69) 92.5,81.93 92.54,82 arc(92.57,82.08) 92.58,82.17 92.58,82.51 92.57,82.52 92.57,82.54
  L12_SIG4 w0.089: 92.57,82.54 92.57,83.85 90.06,86.36 90.06,87.99 89.62,88.43 89.62,90.29 89.46,90.45 89.04,90.45 88.77,90.72 88.77,91.09 89.04,91.36 89.46,91.36 89.62,91.52 89.62,91.74 89.46,91.9 87.71,91.9 87.44,92.16 87.44,92.54 87.71,92.81 89.46,92.81 89.62,92.97 89.62,93.19 89.46,93.34 87.12,93.34 86.9,93.56 86.9,94.2 87.73,95.02 87.73,98.29 87.94,98.51 90.8,98.51 92.15,99.85 92.15,100.29 91.92,100.51 91.92,101.89 92.15,102.11 92.15,102.83 92,102.98 91.08,102.98 90.84,103.22 90.84,103.9 90.44,104.3 82.76,104.3 81.75,105.32 81.75,106.4 82,106.66 84.98,106.66 85.25,106.38 85.25,105.44 85.41,105.29 86.11,105.29 86.27,105.44 86.27,106.92 86.53,107.18 87.51,107.18 87.77,106.92 87.77,105.43 87.93,105.27 88.34,105.27 88.5,105.43 88.5,106.4 88.76,106.66 89.34,106.66 89.81,106.19 90.75,106.19 91.11,106.55 93.62,106.55 93.77,106.71 93.77,107.27 v1(93.44,107.6)
DDR4_DIMM2_DQS_P0: length 67.2
  L12_SIG4 w0.076: 86.41,82.66 86.41,82.64 86.4,82.63 86.4,82.15 arc(86.39,82.07) 86.36,81.99 86.26,81.8 arc(86.23,81.66) 86.27,81.53 86.32,81.44 arc(86.38,81.24) 86.33,81.03 86.3,80.97 arc(86.25,80.8) 86.29,80.64 86.34,80.54 arc(86.4,80.32) 86.34,80.1 86.29,80.02 arc(86.25,79.87) 86.29,79.72 86.38,79.55 arc(86.43,79.34) 86.35,79.14 86.32,79.1 arc(86.27,78.98) 86.29,78.84 86.36,78.71 arc(86.41,78.47) 86.33,78.24 86.28,78.16 arc(86.24,78.05) 86.26,77.93 86.35,77.77 arc(86.4,77.55) 86.34,77.34 86.26,77.21 arc(86.23,77.09) 86.26,76.97 86.31,76.88 arc(86.37,76.62) 86.3,76.37 86.29,76.34 arc(86.25,76.2) 86.28,76.06 86.33,75.96 arc(86.39,75.74) 86.34,75.53 86.28,75.38 arc(86.25,75.27) 86.28,75.15 86.35,74.99 arc(86.43,74.9) 86.55,74.87 86.65,74.87 arc(86.79,74.9) 86.89,74.99 87,75.15 arc(87.16,75.3) 87.38,75.36 87.67,75.36 arc(87.8,75.32) 87.9,75.23 87.92,75.19 88.04,75.16 v1(88.22,75.27)
  L12_SIG4 w0.089: 86.41,82.66 86.41,83.19 82.93,86.67 82.93,88.26 78.78,92.41 78.78,94.16 75.96,96.98 75.96,99.53 76.3,99.88 76.3,100.85 72.24,104.91 67.27,104.91 66.58,104.23 65.01,104.23 64.66,103.87 61.35,103.87 61.09,104.13 61.09,105.94 60.73,106.31 59.88,106.31 59.5,105.93 59.5,104.6 59.25,104.35 58.73,104.35 58.48,104.6 58.48,106.32 58.12,106.68 57.51,106.68 57.13,106.31 57.13,104.69 56.88,104.43 55.68,104.43 55.41,104.7 55.41,105.78 56.56,106.93 56.56,107.27 v1(56.89,107.6)
DDR4_DIMM2_DQS_P1: length 64.6
  L14_SIG5 w0.076: v1(86.63,79.87) 86.36,79.71 86.28,79.73 86.26,79.76 86.25,79.78 arc(86.23,79.84) 86.24,79.9 86.35,80.16 arc(86.39,80.34) 86.35,80.52 86.24,80.74 arc(86.22,80.85) 86.27,80.96 86.3,81 arc(86.37,81.2) 86.35,81.4 86.31,81.5 arc(86.19,81.66) 86.01,81.75 85.77,81.79 arc(85.64,81.84) 85.54,81.94 85.46,82.06 arc(85.46,82.06) 85.46,82.06 85.4,82.13 85.4,82.13 85.38,82.14
  L14_SIG5 w0.081: 85.38,82.14 85.2,82.32 85.2,82.46 85.02,82.64 84.88,82.64 84.76,82.76 79.27,82.76 76.58,85.45 76.58,87.64 72.56,91.67 67.99,91.67 66.1,93.56 64.06,93.56 63.01,94.6 60.56,94.6 60.4,94.76 60.4,95.82 60.14,96.08 59.7,96.08 59.44,95.82 59.44,94.67 59.32,94.55 59.03,94.55 58.88,94.71 58.88,95.74 58.62,96 58.2,96 58.05,96.15 58.05,96.65 58.2,96.8 59.63,96.8 59.89,97.06 59.89,97.5 59.63,97.77 58.79,97.77 58.64,97.93 58.64,98.44 58.93,98.74 62.36,98.74 63.02,99.41 63.9,99.41 64.42,99.92 64.42,100.56 64.07,100.92 63.68,100.92 63.52,101.08 63.52,101.75 63.27,102 63.27,102.73 63.44,102.9 64.51,102.9 64.8,103.19 64.8,104.94 64.93,105.07 65.53,105.07 65.77,105.32 65.77,105.79 65.5,106.05 64.91,106.05 64.75,106.21 64.75,106.57 64.91,106.73 65.65,106.73 65.91,106.99 65.91,107.27 v1(66.24,107.6)
DDR4_DIMM2_DQS_P2: length 73
  L05_SIG2 w0.076: 79.46,76.28 79.48,76.28 79.48,76.28 79.56,76.28 arc(79.73,76.24) 79.86,76.12 79.97,75.95 arc(80.08,75.85) 80.22,75.82 80.29,75.82 arc(80.49,75.77) 80.66,75.64 80.77,75.49 arc(80.89,75.39) 81.04,75.36 81.09,75.36 arc(81.2,75.38) 81.3,75.45 81.51,75.68 arc(81.65,75.78) 81.83,75.82 81.91,75.82 arc(82.09,75.77) 82.24,75.66 82.37,75.48 arc(82.48,75.39) 82.62,75.36 82.8,75.36 arc(82.94,75.32) 83.04,75.22 arc(83.04,75.22) 83.04,75.22 83.06,75.2 arc(83.14,75.13) 83.24,75.15 v1(83.44,75.27)
  L05_SIG2 w0.081: v1(75.59,107.6) 75.26,107.27 75.26,106.59 75.39,106.46 78.5,106.46 78.82,106.14 78.82,105.52 78.55,105.25 74.87,105.25 74.1,106.02 72.57,106.02 71.8,105.25 70.08,105.25 69.87,105.04 69.87,104.46 70.12,104.22 73.24,104.22 73.62,104.6 74.91,104.6 75.3,104.22 77.4,104.22 78.31,103.31 78.31,102.27 78.71,101.86 78.71,100.49 78.56,100.34 78.56,99.85 78.87,99.53 78.87,97.9 78.37,97.4 74.69,97.4 74.51,97.21 74.51,96.63 74.69,96.45 78.49,96.45 78.8,96.13 78.8,95.46 78.52,95.18 75.25,95.18 75.06,95 75.06,94.49 75.41,94.14 75.41,93.64 75.74,93.3 78.34,93.3 78.81,92.83 78.81,87.62 77.75,86.55 77.75,78.47 79.12,77.1 79.12,76.51 79.34,76.28 79.46,76.28
DDR4_DIMM2_DQS_P3: length 68.9
  L16_SIG6 w0.076: v1(88.22,77.11) 87.98,77.25 87.86,77.22 87.82,77.16 arc(87.7,77.03) 87.53,76.99 87.39,76.99 arc(87.19,77.04) 87.04,77.17 86.93,77.33 arc(86.81,77.44) 86.64,77.48 86.56,77.48 arc(86.36,77.53) 86.21,77.67 86.15,77.76 arc(86.07,78.01) 86.14,78.27 86.21,78.39 arc(86.24,78.5) 86.21,78.6 86.15,78.7 arc(86.09,78.94) 86.17,79.17 86.21,79.23 arc(86.25,79.36) 86.22,79.49 86.14,79.62 arc(86.08,79.86) 86.13,80.1 86.19,80.21 arc(86.22,80.33) 86.19,80.45 86.09,80.64 arc(86.05,80.86) 86.14,81.07 86.18,81.12 arc(86.22,81.24) 86.19,81.36 86.12,81.47 arc(86.06,81.7) 86.13,81.93 86.23,82.1 86.23,82.61 86.23,82.61 86.23,82.63
  L16_SIG6 w0.081: v1(84.94,107.6) 84.62,107.92 84.62,108.08 84.74,108.2 88.59,108.2 88.71,108.08 88.71,107.37 88.16,106.82 88.16,106.55 87.99,106.38 83.15,106.38 82.81,106.04 82.81,104.19 83.05,103.95 83.5,103.95 83.73,104.19 83.73,105.36 83.86,105.49 84.09,105.49 84.22,105.36 84.22,104.19 84.45,103.95 84.84,103.95 85.07,104.19 85.07,105.36 85.2,105.49 85.43,105.49 85.56,105.36 85.56,104.19 85.79,103.95 86.18,103.95 86.41,104.19 86.41,104.89 86.54,105.02 86.77,105.02 86.9,104.89 86.9,104.19 87.13,103.95 87.52,103.95 87.75,104.19 87.75,105.31 87.88,105.44 88.11,105.44 88.24,105.31 88.24,102.89 88.73,102.4 88.73,101.93 88.58,101.79 88.58,100.29 88.73,100.15 88.73,99.83 88.45,99.55 87.69,99.55 86.28,98.15 84.87,98.15 84.63,97.91 84.63,97.48 84.87,97.25 86.8,97.25 86.93,97.12 86.93,96.62 86.8,96.49 84.88,96.49 84.64,96.26 84.64,95.11 84.37,94.83 84.37,94.25 84.5,94.12 84.5,93.65 84.38,93.53 83.31,93.53 83.1,93.32 83.1,92.82 83.31,92.61 84.27,92.61 84.38,92.51 84.38,84.72 86.23,82.87 86.23,82.63
DDR4_DIMM2_DQS_P4: length 93.5
  L03_SIG1 w0.076: v4(83.44,77.11) 83.34,77.17 arc(83.3,77.19) 83.25,77.22 arc(83.15,77.24) 83.05,77.18 83.05,77.17 arc(83.04,77.12) 83.05,77.06 83.12,76.9 arc(83.22,76.78) 83.37,76.74 83.46,76.74 arc(83.93,76.46) 83.91,75.91 83.85,75.81 arc(83.71,75.68) 83.54,75.64 83.39,75.64 arc(83.24,75.59) 83.13,75.47 arc(82.92,75.24) 82.61,75.18 82.54,75.19 arc(82.39,75.23) 82.27,75.32 82.23,75.38 arc(82.22,75.38) 82.22,75.39 82.12,75.51 arc(82.01,75.61) 81.86,75.64 arc(81.73,75.61) 81.62,75.53 81.43,75.33 arc(81.28,75.22) 81.09,75.18 81.04,75.18 arc(80.81,75.23) 80.62,75.39 80.52,75.53 arc(80.42,75.61) 80.29,75.64 80.27,75.64 arc(80.11,75.6) 79.99,75.5 79.88,75.36 arc(79.72,75.23) 79.51,75.18 79.33,75.18 79.33,75.18 79.31,75.18
  L03_SIG1 w0.081: 79.31,75.18 78.83,75.18 76.93,77.07 76.6,77.89 76.6,84.51 85.49,93.41 86.04,93.41 87.35,94.72 90.36,94.72 91.61,95.24 94.2,97.83 96.66,98.85 98.95,98.85 100.94,100.84 100.94,101.39 101.72,102.18 103.14,102.18 103.26,102.05 104.02,102.05 104.15,102.18 109.68,102.18 110.42,102.92 114.1,102.92 114.62,102.41 119.47,102.41 122.16,105.09 131.24,105.09 134.1,106.27 138.43,106.27 138.9,106.75 138.9,107.22 138.71,107.41 138.71,107.87 139.1,108.26 139.66,108.26 139.96,107.96 139.96,107.83 v4(140.19,107.6)
DDR4_DIMM2_DQS_P5: length 99.1
  L05_SIG2 w0.076: v1(81.85,79.87) 81.58,79.75 arc(81.52,79.75) 81.48,79.79 81.46,79.83 arc(81.44,79.88) 81.45,79.93 arc(81.46,79.95) 81.47,79.96 81.55,80.09 arc(81.59,80.19) 81.61,80.3 81.61,80.36 arc(81.6,80.45) 81.56,80.54 81.49,80.67 arc(81.48,80.7) 81.48,80.73 81.48,80.84 arc(81.48,80.89) 81.5,80.93 81.55,81 arc(81.58,81.05) 81.6,81.1 arc(81.62,81.27) 81.57,81.43 81.49,81.61 arc(81.47,81.7) 81.49,81.8 81.65,82.17 81.66,82.17 81.66,82.19
  L05_SIG2 w0.081: 81.66,82.19 81.98,82.91 82.84,83.77 82.84,87.96 83.28,88.39 83.28,92.29 84.71,93.71 84.71,94.18 84.5,94.39 84.5,95.86 86.58,97.95 86.58,99.48 86.24,99.83 86.24,100.22 86.88,100.86 86.88,101.53 87.94,102.59 90.04,102.59 90.61,103.16 92.4,103.16 93.37,104.14 94.05,104.14 96.22,106.31 97.15,106.31 97.73,106.89 99.56,106.89 100.3,107.63 101.24,107.63 102.52,108.91 118.05,108.91 118.28,108.67 120.01,108.67 120.2,108.86 131.49,108.86 132.31,108.04 132.31,107.34 132.68,106.97 135.66,106.97 136.31,106.32 142.27,106.32 142.42,106.18 146.46,106.18 147.57,105.07 147.91,105.07 148.38,105.54 148.56,105.54 148.89,105.22 148.89,105.04 148.41,104.56 148.41,104.23 148.8,103.84 149.54,103.84 149.74,104.05 149.74,105.76 149.22,106.28 149.22,107.27 v1(149.54,107.6)
DDR4_DIMM2_DQS_P6: length 97.1
  L05_SIG2 w0.076: 92.95,82.64 92.95,82.62 92.95,82.61 92.95,82.23 92.79,82.07 92.63,81.81 arc(92.6,81.7) 92.62,81.59 92.7,81.44 arc(92.74,81.2) 92.67,80.97 arc(92.66,80.96) 92.66,80.95 arc(92.62,80.8) 92.65,80.66 arc(92.65,80.65) 92.66,80.63 92.72,80.54 arc(92.78,80.33) 92.72,80.12 92.67,80.04 arc(92.63,79.86) 92.69,79.68 92.71,79.64 arc(92.78,79.44) 92.74,79.24 92.65,79.06 arc(92.62,78.93) 92.66,78.8 92.7,78.73 arc(92.7,78.73) 92.71,78.72 arc(92.77,78.5) 92.72,78.28 92.66,78.17 arc(92.63,78.03) 92.66,77.89 92.7,77.8 arc(92.74,77.71) 92.76,77.61 92.76,77.59 arc(92.75,77.48) 92.72,77.38 92.72,77.36 arc(92.72,77.36) 92.72,77.36 92.65,77.24 arc(92.62,77.11) 92.65,76.99 92.73,76.83 arc(92.77,76.65) 92.74,76.47 arc(92.72,76.44) 92.7,76.4 92.69,76.39 arc(92.64,76.19) 92.69,75.98 92.7,75.97 arc(92.77,75.72) 92.69,75.47 arc(92.69,75.47) 92.69,75.47 92.68,75.46 92.62,75.35 arc(92.6,75.3) 92.61,75.24 92.63,75.19 arc(92.67,75.15) 92.74,75.15 v1(93,75.27)
  L05_SIG2 w0.081: 92.95,82.64 92.95,83.24 93.66,83.95 93.66,86.06 94.3,86.69 94.3,91.37 96.38,93.45 96.38,94.09 96.77,94.47 97.59,94.47 100.12,97 100.84,97.3 102.07,97.3 102.64,97.54 102.84,97.73 104.22,98.31 109.58,98.31 113.06,97.62 114.72,97.11 116.32,96.45 117.73,95.04 118.3,94.8 119.25,94.8 119.79,95.02 121.44,96.67 122.35,97.05 124.05,97.39 134.54,97.39 137.07,96.89 155.48,96.89 157.03,98.44 159.29,99.38 159.52,99.94 159.52,100.72 158.5,102.26 158.5,107.2 v1(158.89,107.6)
DDR4_DIMM2_DQS_P7: length 97.5
  L03_SIG1 w0.081: v4(168.24,107.6) 167.95,107.31 167.95,106.4 167.47,105.92 166.87,105.92 166.67,106.12 166.67,106.91 166.54,107.04 166.22,107.04 166.09,106.91 166.09,106.2 165.81,105.92 161.23,105.92 160.97,105.66 160.1,105.66 159.68,106.08 159.08,106.08 158.66,105.66 157.54,105.66 157.1,106.1 153.4,106.1 151.49,104.19 150.45,104.19 149.72,103.46 149.17,103.46 147.2,101.49 147.2,101.06 145.32,99.18 143.8,99.18 142.65,98.04 141.48,98.04 140.79,97.75 137.57,97.75 137.3,98.03 133.62,98.03 132.65,97.06 131.81,97.06 130.15,95.39 130.15,95.11 129.3,94.26 129.3,93.45 127.82,91.97 116.41,91.97 115.66,91.22 109.59,91.22 99.68,88.21 99.18,87.71 98.74,86.66 98.43,86.35 96.86,85.69 92.32,85.69 86.76,84.01 84.83,82.08 84.76,81.97 84.79,81.85 v4(85.04,81.71)
DDR4_DIMM2_DQS_P8: length 71.1
  L12_SIG4 w0.076: 92.76,82.54 92.76,82.52 92.76,82.51 92.76,82.17 arc(92.74,82.04) 92.7,81.92 92.66,81.85 arc(92.62,81.69) 92.66,81.53 92.72,81.41 arc(92.77,81.21) 92.7,81.02 92.65,80.94 arc(92.61,80.82) 92.64,80.69 92.7,80.58 arc(92.76,80.34) 92.71,80.1 92.63,79.95 arc(92.61,79.86) 92.63,79.77 92.72,79.6 arc(92.78,79.33) 92.67,79.08 92.64,79.04 arc(92.61,78.97) 92.62,78.88 92.7,78.75 arc(92.77,78.5) 92.7,78.24 92.68,78.2 92.62,78.09 arc(92.61,77.99) 92.64,77.9 92.79,77.69 arc(92.84,77.55) 92.81,77.4 92.77,77.33 92.79,77.23 v1(93,77.11)
  L12_SIG4 w0.089: 92.76,82.54 92.76,83.93 90.25,86.44 90.25,88.06 89.81,88.51 89.81,90.37 89.54,90.64 89.12,90.64 88.96,90.79 88.96,91.02 89.12,91.17 89.54,91.17 89.81,91.44 89.81,91.82 89.54,92.09 87.79,92.09 87.63,92.24 87.63,92.46 87.79,92.62 89.54,92.62 89.81,92.89 89.81,93.27 89.54,93.53 87.2,93.53 87.09,93.64 87.09,94.12 87.92,94.94 87.92,98.21 88.02,98.32 90.88,98.32 92.34,99.77 92.34,100.37 92.12,100.59 92.12,101.81 92.34,102.03 92.34,102.91 92.08,103.17 91.16,103.17 91.03,103.3 91.03,103.98 90.52,104.49 82.84,104.49 81.94,105.4 81.94,106.32 82.08,106.47 84.9,106.47 85.06,106.3 85.06,105.36 85.33,105.1 86.19,105.1 86.46,105.36 86.46,106.84 86.61,106.99 87.43,106.99 87.58,106.84 87.58,105.35 87.85,105.08 88.42,105.08 88.69,105.35 88.69,106.32 88.84,106.47 89.26,106.47 89.73,106 90.83,106 91.19,106.36 93.69,106.36 93.96,106.63 93.96,107.27 v1(94.29,107.6)
DDR4_DIMM2_ODT0: length 104.1
  L14_SIG5 w0.081: v1(91.41,79.87) 92.43,79.87 92.87,79.43 93.15,79.43 93.63,78.95 93.96,78.95 94.47,78.44 94.72,78.44 95.18,78.9 95.46,78.9 95.82,79.25 95.82,80.11 96.04,80.34 96.37,80.34 96.6,80.57 96.6,82.51 94.66,84.46 93.78,84.46 93.32,84.92 92.79,84.92 91.39,86.33 90.71,86.33 90.39,86.65 90.39,87.1 90.01,87.48 90.01,88.02 89.7,88.33 88.88,88.33 87.28,89.92 85.41,89.92 81.97,93.36 81.97,94.08 81.5,94.55 81.5,94.97 80.33,96.13 80.33,96.88 80.72,97.26 80.72,99.13 81.08,99.49 81.08,100.45 82,101.37 82,101.9 82.16,102.06 82.69,102.06 85.81,105.18 87.19,105.18 87.77,105.77 89.02,105.77 89.55,105.24 91.93,105.24 92.11,105.42 92.11,105.72 92.27,105.88 93.89,105.88 94.53,105.24 97.21,105.24 97.91,104.54 98.84,104.54 98.95,104.43 101.45,104.43 102.94,102.94 103.84,102.94 104.08,102.71 104.08,102.21 104.29,101.99 104.63,101.99 104.88,101.74 104.88,100.64 105.12,100.41 113.24,100.41 113.96,101.13 116.08,101.13 117.47,102.52 119.54,102.52 122.84,105.82 122.84,106.33 123.55,107.05 130.08,107.05 130.78,106.35 130.78,105.49 131.62,104.65 131.62,102.72 131.08,102.17 128.86,102.17 v1(128.29,101.6)
DDR4_DIMM2_ODT1: length 104.2
  L14_SIG5 w0.081: v1(131.77,101.6) 131.14,101.6 130.38,100.83 129.99,100.83 129.4,101.42 128.83,101.42 128.35,100.94 128.06,100.94 127.86,101.15 127.86,104.1 127.43,104.53 124.28,104.53 123.63,103.89 123.63,101.45 123.41,101.23 122.53,101.23 122.02,101.73 122.02,102.39 121.78,102.63 120.84,102.63 120.16,101.94 120.16,101.46 119.87,101.17 117.24,101.17 116.39,100.32 114.5,100.32 113.21,99.03 112.03,99.03 111.51,99.55 111.27,99.55 110.76,99.04 110.27,99.04 109.82,99.49 109.47,99.49 108.88,98.91 107.85,98.91 107.23,99.53 106.95,99.53 106.41,98.98 105.18,98.98 103.75,100.41 103.44,100.41 103.24,100.6 103.24,101.05 103.07,101.23 101.77,101.23 100.75,102.25 100.75,102.41 99.76,103.4 98.56,103.4 98.43,103.53 97.49,103.53 96.8,104.23 94,104.23 93.82,104.41 92.71,104.41 92.53,104.23 91.13,104.23 90.38,103.48 87.8,103.48 87.03,102.71 86.39,102.71 86.13,102.44 86.13,102.07 86.34,101.85 86.34,101.56 85.16,100.38 83.96,100.38 83.71,100.13 83.71,99.83 84.05,99.5 84.76,99.5 84.89,99.36 84.89,95.06 84.51,94.67 84.51,93.99 87.53,90.96 87.87,90.96 89.32,89.51 90.23,89.51 91.97,87.77 91.97,87.17 93.14,85.99 93.67,85.99 94.2,85.46 95.32,85.46 98.21,82.57 98.71,82.57 98.97,82.31 98.97,79.2 98.71,78.95 98.36,78.95 97.92,78.51 97.64,78.51 97.11,77.98 96.78,77.98 96.3,78.46 95.99,78.46 95.54,78.01 95.18,78.01 94.77,77.6 94.34,77.6 93.89,78.06 93.56,78.06 93.12,78.49 92.82,78.49 92.35,78.96 92.07,78.96 91.62,79.41 v1(90.61,79.41)
DDR4_DIMM2_PAR: length 98.3
  L16_SIG6 w0.081: v1(92.21,78.49) 92.6,78.88 92.6,79.08 92.78,79.26 93.2,79.43 93.43,79.66 93.43,82.33 93.74,82.64 93.74,82.94 93.91,83.11 93.91,83.25 93.8,83.37 93.8,83.51 93.9,83.6 94.03,83.6 94.15,83.49 94.29,83.49 94.39,83.59 94.39,83.73 94.27,83.84 94.27,83.98 94.37,84.08 94.51,84.08 94.62,83.96 94.76,83.96 94.86,84.06 94.86,84.2 94.75,84.32 94.75,84.45 94.84,84.55 94.98,84.55 95.1,84.44 95.24,84.44 95.33,84.54 95.33,84.68 95.22,84.79 95.22,84.93 95.32,85.03 95.46,85.03 95.57,84.91 95.71,84.91 96.22,85.42 96.22,85.93 96.32,86.02 96.76,86.02 96.85,86.12 96.85,86.26 96.76,86.36 96.32,86.36 96.22,86.46 96.22,88.3 96.32,88.4 96.45,88.4 96.55,88.3 96.55,87.36 96.65,87.26 96.79,87.26 96.89,87.36 96.89,88.83 97.2,89.14 97.2,89.28 97.1,89.38 96.96,89.38 96.34,88.75 96.2,88.75 96.1,88.85 96.1,88.99 96.97,89.85 97.32,89.85 97.64,89.53 97.94,89.53 98.06,89.64 98.06,89.79 97.97,89.88 97.97,90.03 98.07,90.13 98.22,90.13 98.42,89.94 98.56,89.94 98.67,90.05 98.67,90.19 98.48,90.39 98.48,90.54 98.58,90.64 98.73,90.64 98.91,90.47 99.05,90.47 99.16,90.58 99.16,90.72 98.99,90.9 98.99,91.05 99.09,91.15 99.24,91.15 99.4,91 100.14,91 100.81,91.68 100.81,91.82 100.67,91.97 100.52,91.97 99.99,91.43 99.84,91.43 99.68,91.59 99.68,91.73 100.28,92.32 101.57,92.32 101.68,92.44 101.68,92.69 101.58,92.79 101.23,92.79 101.12,92.89 101.12,93.04 101.23,93.15 101.42,93.15 101.52,93.25 101.52,93.48 101.42,93.58 101.2,93.58 101.1,93.69 101.1,93.84 101.2,93.94 101.42,93.94 101.52,94.05 101.52,94.2 101.42,94.3 101.02,94.3 100.92,94.41 100.92,94.56 101.02,94.66 101.42,94.66 101.52,94.77 101.52,96.33 101.65,96.46 101.82,96.46 101.94,96.34 101.94,95.34 102.05,95.23 102.2,95.23 102.3,95.34 102.3,95.65 102.41,95.76 102.64,95.76 102.74,95.86 102.74,96.01 102.64,96.12 102.41,96.12 102.3,96.22 102.3,96.38 102.41,96.48 102.58,96.48 102.68,96.58 102.68,97.05 102.78,97.15 102.92,97.15 103.02,97.05 103.02,96.34 103.11,96.25 103.25,96.25 103.35,96.34 103.35,97.05 103.45,97.15 103.59,97.15 103.69,97.05 103.69,96.58 103.78,96.48 103.92,96.48 104.02,96.58 104.02,97.05 104.12,97.15 104.31,97.15 104.41,97.05 104.41,96.94 104.5,96.84 104.64,96.84 104.74,96.94 104.74,97.05 104.83,97.15 110.14,97.15 110.4,96.89 113.55,96.89 115.17,98.51 115.17,99.07 115.27,99.16 116,99.16 116.1,99.26 116.1,99.4 116,99.5 115.27,99.5 115.17,99.6 115.17,100.8 115.27,100.9 115.41,100.9 115.51,100.8 115.51,100.4 115.6,100.3 115.74,100.3 115.84,100.4 115.84,100.8 115.94,100.9 116.08,100.9 116.18,100.8 116.18,100.2 116.27,100.1 116.41,100.1 116.51,100.2 116.51,101.14 116.61,101.23 116.75,101.23 116.85,101.14 116.85,100.66 116.95,100.56 117.11,100.56 117.24,100.69 117.24,101.02 117.41,101.19 119.25,101.19 119.35,101.29 119.35,101.43 119.25,101.53 117.22,101.53 117.12,101.63 117.12,101.77 117.22,101.86 119.19,101.86 119.29,101.96 119.29,102.1 119.19,102.2 117.34,102.2 117.24,102.3 117.24,102.97 117.34,103.07 117.5,103.07 117.6,102.97 117.6,102.63 117.69,102.53 119.66,102.53 119.76,102.44 119.76,102.16 120.02,101.89 120.02,101.42 120.22,101.23 120.92,101.23 121.07,101.08 121.07,100.67 121.32,100.41 121.68,100.41 121.93,100.66 121.93,104.05 122.03,104.16 122.49,104.16 122.59,104.27 122.59,104.43 122.49,104.54 122.03,104.54 121.93,104.64 121.93,104.85 122.03,104.95 122.49,104.95 122.59,105.06 122.59,105.25 122.49,105.35 122.03,105.35 121.93,105.46 121.93,105.61 122.03,105.71 122.49,105.71 122.59,105.82 122.59,105.96 122.49,106.06 121.21,106.06 121.04,106.23 121.04,106.74 121.21,106.92 121.82,106.92 121.92,107.02 121.92,107.16 121.82,107.26 120.98,107.26 v1(120.64,107.6)
DDR4_DIMM2_REFCLK_N: length 76.6
  L07_SIG3 w0.081: v1(93.8,79.41) 94.04,79.55 94.16,79.52 94.2,79.44 94.19,79.29 94.03,79.08 93.92,79.04 93.64,79.04 93.52,79.11 93.36,79.38 93.15,79.51 92.81,79.51 92.6,79.36 92.46,79.12 92.34,79.05 92.08,79.05 91.96,79.11 91.81,79.38 91.59,79.51 91.28,79.51 91,79.35 90.87,79.12 90.74,79.05 90.48,79.05 90.37,79.11 90.21,79.38 90,79.51 89.63,79.51 89.43,79.39 89.29,79.14 89.12,79.05 88.8,79.05 88.36,78.61 88.18,78.61 87.9,78.53 87.65,78.17 87.56,78.13 87.33,78.13 87.1,78.06 86.85,77.72 86.75,77.67 86.52,77.67 86.28,77.57 86.06,77.26 85.93,77.2 85.64,77.2 85.62,77.21 85.6,77.21
  L07_SIG3 w0.085: v1(65.41,41.42) 65.72,41.42 65.81,41.51 65.81,42.18 63.94,44.04 61.53,44.04 61.01,44.56 59.87,44.56 58.51,45.93 58.51,60.12 59.19,60.81 65.71,60.81 66.47,61.57 68.18,61.57 69.93,63.32 69.93,64.41 72.16,66.64 75.67,66.64 v1(75.95,66.92) 76.23,66.64 76.55,66.64 77.71,67.8 77.71,71.8 78.7,72.79 78.7,76.72 79.19,77.21 84.29,77.21 84.39,77.31 84.39,77.51 84.49,77.61 84.68,77.61 84.78,77.51 84.78,77.31 84.88,77.21 85.6,77.21
  BOTTOM w0.102: R6933.1 R6909.2
DDR4_DIMM2_REFCLK_P: length 76.5
  L07_SIG3 w0.081: v1(94.6,79.87) 94.35,79.73 94.33,79.62 94.4,79.49 94.38,79.22 94.15,78.92 93.95,78.84 93.59,78.84 93.38,78.96 93.22,79.24 93.1,79.31 92.87,79.31 92.75,79.22 92.6,78.97 92.39,78.85 92.02,78.85 91.82,78.97 91.66,79.24 91.54,79.31 91.33,79.31 91.14,79.2 91.01,78.97 90.79,78.85 90.43,78.85 90.23,78.97 90.07,79.24 89.94,79.31 89.68,79.31 89.57,79.25 89.43,79 89.18,78.85 88.88,78.85 88.44,78.42 88.21,78.42 88.02,78.36 87.78,78.02 87.61,77.93 87.35,77.93 87.22,77.89 86.99,77.57 86.8,77.47 86.56,77.47 86.4,77.41 86.19,77.11 85.98,77 85.64,77 85.62,76.98 85.6,76.98
  L07_SIG3 w0.085: v1(66.43,41.42) 66.12,41.42 66.03,41.51 66.03,42.27 64.04,44.27 61.62,44.27 61.1,44.79 59.97,44.79 58.73,46.03 58.73,60.03 59.29,60.58 65.8,60.58 66.57,61.34 68.28,61.34 70.16,63.23 70.16,64.32 72.26,66.41 74.52,66.41 74.62,66.31 74.62,66.21 74.72,66.1 74.91,66.1 75.01,66.21 75.01,66.31 75.11,66.41 75.67,66.41 v1(75.95,66.13) 76.23,66.41 76.65,66.41 77.93,67.7 77.93,71.71 78.92,72.7 78.92,76.62 79.28,76.98 85.6,76.98
  BOTTOM w0.102: R6932.1 75.13,66.15 75.94,66.15 v1(75.95,66.13)
DDR4_DIMM2_RESET_N: length 103.2
  L16_SIG6 w0.081: v1(98.54,101.6) 98.54,105.07 98.41,105.2 98.04,105.2 97.93,105.3 97.93,105.63 97.85,105.71 97.36,105.71 97.28,105.79 97.28,105.95 97.39,106.06 98.97,106.06 99.07,106.16 99.07,106.3 98.97,106.4 98.69,106.4 98.59,106.5 98.59,107.06 98.49,107.16 98.35,107.16 98.26,107.06 98.26,106.5 98.16,106.4 98.02,106.4 97.92,106.5 97.92,107.12 97.82,107.22 97.68,107.22 97.59,107.12 97.59,106.5 97.49,106.4 97.35,106.4 97.25,106.5 97.25,107.12 97.15,107.22 97.01,107.22 96.91,107.12 96.91,105.8 96.82,105.7 96.68,105.7 96.58,105.8 96.58,107.12 96.48,107.22 96.34,107.22 96.24,107.12 96.24,105.81 96.15,105.71 96.01,105.71 95.91,105.81 95.91,107.18 95.81,107.27 95.67,107.27 95.57,107.18 95.57,105.84 95.48,105.74 94.74,105.74 94.64,105.84 94.64,106.03 94.74,106.13 95.1,106.13 95.2,106.23 95.2,106.37 95.1,106.47 94.86,106.47 94.76,106.57 94.76,107.05 94.99,107.28 94.99,107.42 94.89,107.52 94.75,107.52 94.28,107.06 94.28,105.8 94.18,105.7 94.04,105.7 93.94,105.8 93.94,107.19 93.84,107.29 93.71,107.29 93.61,107.19 93.61,105.98 93.51,105.88 93.37,105.88 93.27,105.98 93.27,107.24 93.17,107.34 93.04,107.34 92.94,107.24 92.94,105.64 92.84,105.54 92.7,105.54 92.6,105.64 92.6,107.08 92.5,107.18 92.36,107.18 92.27,107.08 92.27,105.79 92.17,105.69 92.03,105.69 91.93,105.79 91.93,107.13 91.83,107.23 91.69,107.23 91.6,107.13 91.6,105.73 91.5,105.63 91.36,105.63 91.26,105.73 91.26,107.13 91.16,107.23 90.98,107.23 90.88,107.12 90.88,106.78 90.78,106.68 90.58,106.68 90.51,106.6 90.51,106.42 90.58,106.34 90.7,106.34 90.8,106.24 90.8,106.1 90.69,105.98 90.19,105.98 90.09,105.88 90.09,105.74 90.19,105.64 90.38,105.64 90.48,105.54 90.48,105.4 90.38,105.3 90.19,105.3 90.1,105.2 90.1,105.06 90.19,104.96 90.57,104.96 90.67,104.86 90.67,104.72 90.57,104.62 90.14,104.62 90.04,104.52 90.04,104.38 90.14,104.28 90.57,104.28 90.67,104.18 90.67,102.21 90.77,102.12 90.9,102.12 91,102.21 91,104.13 91.1,104.23 91.24,104.23 91.34,104.13 91.34,101.02 91.24,100.92 90.72,100.92 90.62,100.83 90.62,100.69 90.72,100.59 91.24,100.59 91.34,100.49 91.34,99.71 91.19,99.56 90.91,99.56 90.53,99.17 90.53,97.9 89.65,97.02 89.65,96.36 89.55,96.26 88.89,96.26 88.8,96.16 88.8,96.03 88.89,95.93 89.55,95.93 89.65,95.83 89.65,95.69 89.55,95.59 88.9,95.59 88.81,95.49 88.81,95.35 88.9,95.26 89.55,95.26 89.65,95.16 89.65,95.02 89.55,94.92 88.94,94.92 88.84,94.82 88.84,94.68 88.94,94.59 89.49,94.59 89.65,94.43 89.65,93.85 89.09,93.3 89.09,91.73 89.19,91.63 89.33,91.63 89.43,91.73 89.43,92.98 89.53,93.08 89.67,93.08 89.77,92.98 89.77,88.36 89.67,88.26 89.53,88.26 89.43,88.36 89.43,91.02 89.33,91.12 89.19,91.12 89.09,91.02 89.09,85 89.19,84.9 89.33,84.9 89.43,85 89.43,86.25 89.53,86.35 89.67,86.35 89.77,86.25 89.77,83.16 89.67,83.07 89.53,83.07 89.43,83.16 89.43,84.37 89.33,84.47 89.19,84.47 89.09,84.37 89.09,82.88 88.6,82.38 88.6,79.83 v1(89.02,79.41)
  BOTTOM w0.149: R155.1 98.55,102.54 R156.2
DDR4_DIMM2_SA0:
  vias: v1(172.49,102.68)
DDR4_DIMM2_SA1:
  vias: v1(173.34,101.6)
DDR4_DIMM2_SA2:
  vias: v1(134.24,107.6)
DDR4_DIMM2_TDQS_N9: length 67.4
  L12_SIG4 w0.076: 83.49,82.52 83.5,82.5 83.5,82.5 83.75,82.25 83.93,81.96 arc(84.02,81.68) 83.95,81.4 83.89,81.31 arc(83.86,81.2) 83.88,81.09 83.93,80.98 arc(83.98,80.73) 83.9,80.49 83.88,80.48 arc(83.84,80.34) 83.88,80.21 83.95,80.08 arc(84.01,79.87) 83.96,79.66 83.87,79.52 arc(83.84,79.39) 83.88,79.26 83.95,79.17 arc(84.01,78.98) 83.97,78.78 83.88,78.6 arc(83.85,78.47) 83.89,78.34 83.94,78.27 arc(83.94,78.27) 83.94,78.26 arc(84.01,78.04) 83.95,77.82 83.9,77.71 arc(83.86,77.57) 83.9,77.43 84,77.22 arc(84.03,77.05) 83.97,76.88 83.88,76.77 arc(83.84,76.68) 83.86,76.59 83.96,76.37 arc(84.01,76.15) 83.94,75.94 83.9,75.88 arc(83.86,75.73) 83.9,75.57 83.94,75.51 arc(84.01,75.26) 83.93,75.01 83.92,75 arc(83.87,74.83) 83.9,74.66 83.94,74.57 arc(84.03,74.47) 84.15,74.44 84.33,74.44 arc(84.38,74.43) 84.43,74.42 arc(84.6,74.32) 84.72,74.16 84.74,74.11 arc(84.83,74.01) 84.96,73.97 85.14,73.97 arc(85.33,73.92) 85.48,73.77 85.55,73.63 arc(85.65,73.53) 85.79,73.49 85.89,73.49 arc(86,73.52) 86.09,73.6 86.22,73.8 arc(86.37,73.94) 86.57,73.99 86.72,73.99 arc(86.93,73.93) 87.08,73.76 87.14,73.65 arc(87.24,73.52) 87.4,73.48 87.53,73.48 arc(87.59,73.49) 87.64,73.52 87.7,73.63 87.67,73.75 v1(87.43,73.89)
  L12_SIG4 w0.089: v1(56.04,101.6) 55.71,101.27 55.71,100.59 55.57,100.44 55.57,99.92 56.07,99.42 56.23,99.42 56.3,99.49 56.47,99.49 56.58,99.38 56.58,99.21 56.51,99.14 56.51,98.98 56.76,98.72 72.44,98.72 72.8,98.36 72.8,97.84 72.45,97.49 67.22,97.49 67.06,97.32 67.06,96.89 67.21,96.74 68.71,96.74 69.14,96.31 69.14,95.46 69.43,95.16 70.28,95.16 70.58,95.46 70.58,96.37 70.94,96.74 72.04,96.74 72.44,96.33 72.44,94.55 72.95,94.03 73.23,94.03 79.41,87.85 79.41,86.59 83.49,82.52
DDR4_DIMM2_TDQS_N10: length 67
  L14_SIG5 w0.076: 86.54,82.34 86.56,82.32 86.56,82.32 86.9,81.98 87.02,81.78 arc(87.04,81.67) 87.01,81.56 86.99,81.53 arc(86.91,81.27) 86.97,81.01 86.99,80.97 arc(87.03,80.83) 86.99,80.69 86.91,80.51 arc(86.86,80.29) 86.93,80.08 86.98,80.01 arc(87.02,79.89) 87,79.77 86.91,79.59 arc(86.86,79.37) 86.93,79.16 86.98,79.08 arc(87.02,78.97) 87,78.87 86.93,78.73 arc(86.85,78.64) 86.74,78.61 86.52,78.61 arc(86.36,78.56) 86.24,78.44 86.2,78.38 86.08,78.35 v1(85.83,78.49)
  L14_SIG5 w0.081: v1(65.39,101.6) 65.06,101.93 65.06,102.09 65.19,102.22 65.34,102.22 65.97,101.59 65.97,101.43 65.84,101.31 65.84,101.15 65.96,101.03 66.12,101.03 66.24,101.16 66.4,101.16 66.66,100.9 66.66,99.85 66.47,99.66 66.47,99.14 66.79,98.82 66.79,95.66 66.58,95.45 66.04,95.45 65.84,95.65 65.84,97.24 66.04,97.44 66.04,98.77 65.81,99 65,99 64.76,98.77 64.76,96.13 64.6,95.97 64.21,95.97 64.05,96.13 64.05,98.31 63.83,98.53 63.06,98.53 62.76,98.23 61.88,98.23 61.63,97.97 61.63,97.25 61.88,96.99 62.64,96.99 62.79,96.84 62.79,96.41 62.64,96.26 61.19,96.26 60.93,96 60.93,95.33 61.19,95.07 63.67,95.07 64.39,94.35 65.6,94.35 65.9,94.05 66.51,94.05 66.87,94.42 67.34,94.42 67.75,94.01 67.75,92.75 68.23,92.27 72.63,92.27 77.25,87.65 77.25,85.68 79.62,83.31 85.57,83.31 85.71,83.17 85.71,83.03 85.64,82.97 85.64,82.83 85.74,82.73 85.88,82.73 85.94,82.8 86.08,82.8 86.54,82.34
DDR4_DIMM2_TDQS_N11: length 69.1
  L05_SIG2 w0.076: v1(82.65,73.89) 82.89,73.75 82.91,73.72 arc(82.93,73.68) 82.93,73.64 82.89,73.57 arc(82.84,73.53) 82.78,73.51 82.3,73.51 82.18,73.64 81.46,73.64 81.34,73.51 81.01,73.51 80.56,73.06 80.22,73.06 arc(80.13,73.08) 80.06,73.13 79.81,73.38 arc(79.65,73.48) 79.47,73.52 79.02,73.52 79.02,73.52 79,73.52
  L05_SIG2 w0.081: v1(74.74,101.6) 74.42,101.28 74.42,100.74 74.16,100.48 72.67,100.48 71.76,99.57 71.76,99.24 70.82,98.3 64.11,98.3 63.91,98.1 63.91,96.75 64.15,96.52 64.88,96.52 65.11,96.75 65.11,97.19 65.36,97.44 67.11,97.44 67.55,97 69.38,97 69.68,96.7 69.68,95.37 69.39,95.08 65.08,95.08 64.09,94.09 64.09,91.88 64.39,91.59 72.73,91.59 76.3,88.01 76.3,83.2 76,82.9 74.26,82.9 73.9,82.53 73.9,81.85 74.54,81.21 75.97,81.21 76.3,80.87 76.3,77.81 77.63,76.48 77.63,75.92 78.22,75.33 78.22,74.22 78.42,74.02 78.54,74.02 78.62,74.1 78.73,74.1 78.89,73.94 78.89,73.82 78.81,73.75 78.81,73.63 78.92,73.52 79,73.52
DDR4_DIMM2_TDQS_N12: length 63.8
  L16_SIG6 w0.076: v1(87.43,75.73) 87.71,75.89 87.76,75.88 87.8,75.81 arc(87.82,75.7) 87.78,75.59 87.75,75.55 87.7,75.46 arc(87.63,75.39) 87.53,75.36 87.35,75.36 arc(87.14,75.3) 86.99,75.15 86.89,74.98 arc(86.81,74.9) 86.7,74.87 86.54,74.87 arc(86.47,74.89) 86.41,74.94 86.28,75.12 arc(86.09,75.3) 85.83,75.36 85.79,75.36 arc(85.57,75.3) 85.4,75.15 85.3,74.99 arc(85.21,74.91) 85.1,74.88 84.98,74.88 arc(84.85,74.91) 84.76,75 84.7,75.11 arc(84.52,75.29) 84.28,75.36 84.15,75.36 arc(84.03,75.39) 83.95,75.48 83.9,75.57 arc(83.74,75.75) 83.51,75.82 83.42,75.82 arc(83.25,75.86) 83.14,75.98 83.09,76.07 arc(82.93,76.23) 82.71,76.29 82.56,76.29 arc(82.45,76.32) 82.37,76.41 82.31,76.51 arc(82.15,76.68) 81.93,76.74 81.75,76.74 arc(81.62,76.77) 81.53,76.87 81.48,76.97 arc(81.33,77.13) 81.11,77.19 81.03,77.19 arc(80.88,77.23) 80.76,77.34 80.69,77.45 arc(80.52,77.6) 80.31,77.66 80.18,77.66 arc(80.05,77.69) 79.96,77.79 79.92,77.87 arc(79.75,78.05) 79.51,78.12 79.12,78.12 79.12,78.12 79.1,78.12
  L16_SIG6 w0.081: 79.1,78.12 78.98,78.12 78.53,78.57 78.53,78.68 78.7,78.86 78.7,78.97 78.57,79.11 78.46,79.11 78.28,78.93 78.17,78.93 77.96,79.13 77.96,80.23 78.21,80.48 78.68,80.48 79.03,80.83 79.03,81.33 78.68,81.68 78.21,81.68 77.96,81.93 77.96,82.63 78.21,82.87 80.62,82.87 80.97,83.22 80.97,83.73 80.62,84.08 78.21,84.08 77.96,84.33 77.96,84.68 78.21,84.93 80.62,84.93 80.97,85.28 80.97,85.78 80.62,86.14 78.21,86.14 77.96,86.38 77.96,86.73 78.21,86.98 80.62,86.98 80.97,87.33 80.97,87.84 80.62,88.19 78.17,88.19 77.99,88.37 77.99,88.85 78.17,89.03 80.56,89.03 80.82,89.29 80.82,89.93 80.54,90.21 78.9,90.21 78.72,90.39 78.72,94.19 77.53,95.38 77.53,99.41 78.48,100.36 83.11,100.36 83.76,101.02 83.76,101.27 v1(84.1,101.6)
DDR4_DIMM2_TDQS_N13: length 95.1
  L03_SIG1 w0.076: 79.29,76.1 79.3,76.1 79.31,76.1 79.46,76.1 arc(79.69,76.15) 79.88,76.3 79.97,76.42 arc(80.09,76.52) 80.25,76.56 80.29,76.56 arc(80.41,76.53) 80.5,76.47 80.69,76.26 arc(80.86,76.14) 81.06,76.1 81.06,76.1 arc(81.29,76.15) 81.47,76.3 81.56,76.42 arc(81.69,76.52) 81.84,76.56 81.88,76.56 arc(82,76.53) 82.09,76.47 82.28,76.26 arc(82.44,76.14) 82.64,76.1 82.8,76.1 arc(82.85,76.09) 82.89,76.05 82.92,76 arc(82.93,75.92) 82.88,75.86 v4(82.65,75.73)
  L03_SIG1 w0.081: 79.29,76.1 79.07,76.1 78.67,76.26 77.57,77.36 77.28,78.06 77.28,83.95 82.88,89.55 83.59,89.55 87.38,93.34 91.13,93.34 93.13,95.35 93.75,95.35 95.82,97.42 100.67,97.42 100.9,97.65 100.9,99.25 101.37,99.72 102.14,99.72 102.67,99.19 102.67,98.71 102.79,98.59 103.43,98.59 103.55,98.71 103.55,99.19 103.89,99.53 105.11,99.53 105.42,99.22 105.42,98.44 105.54,98.32 106.09,98.32 106.21,98.44 106.21,99.28 106.46,99.53 107.64,99.53 107.96,99.21 107.96,98.32 108.1,98.18 108.61,98.18 108.75,98.32 108.75,99.29 108.99,99.53 113.38,99.53 114.72,100.88 119.42,100.88 120.04,101.5 120.04,101.85 120.39,102.2 123.11,102.2 123.6,102.69 123.6,103.59 124.32,104.31 134.01,104.31 134.11,104.21 134.93,104.21 135.18,104.46 135.18,105.14 135.47,105.42 136.14,105.42 136.37,105.19 136.37,104.45 136.6,104.21 137.97,104.21 139,103.18 139,101.94 v4(139.34,101.6)
DDR4_DIMM2_TDQS_N14: length 100.3
  L05_SIG2 w0.076: 83.68,82.26 83.68,82.24 83.68,82.24 83.68,82.14 arc(83.69,82.05) 83.72,81.98 83.83,81.78 arc(83.85,81.68) 83.81,81.57 83.77,81.52 arc(83.69,81.31) 83.72,81.09 83.81,80.9 arc(83.83,80.77) 83.78,80.65 83.74,80.6 arc(83.65,80.38) 83.71,80.14 83.8,79.99 arc(83.84,79.86) 83.79,79.72 83.7,79.59 arc(83.61,79.51) 83.49,79.48 83.41,79.48 arc(83.26,79.45) 83.13,79.36 82.89,79.13 arc(82.79,79.06) 82.66,79.03 82.63,79.03 arc(82.44,79) 82.27,78.89 82.07,78.68 arc(81.98,78.62) 81.88,78.6 81.7,78.6 arc(81.57,78.57) 81.48,78.48 81.45,78.44 81.24,78.38 v1(81.05,78.49)
  L05_SIG2 w0.081: v1(148.69,101.6) 148.47,101.83 148.47,102.22 147.58,103.11 145.06,103.11 144.3,103.87 140.22,103.87 139.08,105 134.96,105 134.7,105.27 132.87,105.27 132.77,105.16 126.12,105.16 126,105.29 126,105.95 125.76,106.18 125.08,106.18 124.85,105.95 124.85,105.29 124.72,105.16 123.53,105.16 123.35,105.34 123.35,106.15 123.07,106.43 122.28,106.43 122,106.15 122,105.34 121.74,105.07 121.29,105.07 121.07,105.3 121.07,105.92 119.7,107.29 117.4,107.29 115.93,105.83 113.66,105.83 113.38,106.11 104.23,106.11 103.57,105.45 102.7,105.45 102.36,105.12 100.07,105.12 99.62,104.67 98.49,104.67 98.16,104.33 96.73,104.33 95.38,102.99 95.38,102.68 93.92,101.21 92.92,101.21 92.13,100.42 92.13,99.83 91.45,99.15 90.68,99.15 88.41,96.88 88.41,95.78 86.85,94.22 86.85,89.71 86.73,89.58 86.39,89.58 86.26,89.71 86.26,91.92 86.03,92.15 85.54,92.15 85.31,91.92 85.31,84.03 83.68,82.4 83.68,82.26
DDR4_DIMM2_TDQS_N15: length 99.4
  L05_SIG2 w0.076: 92.15,83.1 92.15,83.08 92.15,83.07 92.15,82.79 91.86,82.31 arc(91.84,82.26) 91.84,82.21 91.84,82.12 arc(91.84,82.06) 91.87,82.02 91.92,81.94 arc(91.95,81.86) 91.96,81.79 91.96,81.63 arc(91.95,81.53) 91.9,81.45 91.85,81.39 arc(91.83,81.34) 91.82,81.29 91.82,81.2 arc(91.83,81.16) 91.85,81.13 91.92,81 arc(91.98,80.79) 91.92,80.58 91.84,80.44 arc(91.81,80.31) 91.85,80.19 91.92,80.1 arc(91.98,79.9) 91.94,79.7 91.85,79.52 arc(91.82,79.39) 91.86,79.26 91.9,79.19 arc(91.91,79.18) 91.92,79.16 arc(91.97,78.95) 91.92,78.74 91.85,78.61 arc(91.84,78.58) 91.84,78.55 91.84,78.45 arc(91.85,78.39) 91.87,78.33 91.92,78.24 arc(91.95,78.14) 91.97,78.04 91.97,77.95 arc(91.95,77.87) 91.92,77.8 91.86,77.71 arc(91.84,77.67) 91.83,77.63 91.83,77.56 arc(91.84,77.5) 91.85,77.45 91.93,77.29 arc(91.97,77.07) 91.91,76.86 91.87,76.8 arc(91.82,76.65) 91.87,76.49 91.94,76.38 arc(91.99,76.19) 91.94,76 91.94,76 91.84,75.85 arc(91.81,75.76) 91.83,75.68 91.91,75.49 arc(91.96,75.24) 91.88,74.99 91.86,74.94 arc(91.69,74.78) 91.46,74.71 91.38,74.71 arc(91.3,74.7) 91.23,74.65 91.15,74.57 arc(91.06,74.39) 91.09,74.2 arc(91.17,73.91) 91.09,73.61 91.05,73.55 arc(91.02,73.42) 91.05,73.3 91.1,73.22 arc(91.22,73.1) 91.39,73.06 91.44,73.06 arc(91.55,73.08) 91.65,73.14 91.87,73.37 arc(92.02,73.47) 92.19,73.5 92.35,73.5 arc(92.4,73.51) 92.44,73.55 92.48,73.61 arc(92.49,73.69) 92.44,73.76 v1(92.21,73.89)
  L05_SIG2 w0.081: v1(158.04,101.6) 157.68,101.24 157.68,100.51 155.69,98.52 154.6,98.52 154.09,98.01 153.05,98.01 152.11,97.62 151.69,97.54 137.29,97.54 136.94,97.89 135.47,97.89 134.22,98.41 133.68,98.41 133.52,98.25 131.66,98.25 131.48,98.43 131.05,98.43 130.93,98.32 120.15,98.32 119.68,98.79 117.54,98.79 117.34,98.6 117.34,97.62 117.1,97.37 116.39,97.37 116.15,97.62 116.15,98.97 115.98,99.14 114.39,99.14 113.9,99.63 113.5,99.63 113.26,99.39 113.26,98.78 113.01,98.53 112.66,98.53 112.41,98.78 112.41,99.23 112.27,99.37 107.71,99.37 107.49,99.6 106.62,99.6 106.17,99.15 105.22,99.15 105,99.37 104.3,99.37 103.76,98.84 102.7,98.84 102.2,98.34 101.72,98.34 101.34,97.97 100.09,97.97 99.32,97.19 99.05,97.19 98.81,97.44 98.54,97.44 98.3,97.19 98.3,96.93 98.54,96.68 98.54,96.38 97.3,95.14 95.91,95.14 95.56,94.79 95.56,94.39 95.7,94.26 95.7,93.69 93.59,91.57 93.59,88.76 93,88.17 93,84.79 92.75,84.53 92.75,84.42 92.83,84.34 92.83,84.22 92.67,84.06 92.55,84.06 92.47,84.14 92.36,84.14 92.15,83.94 92.15,83.1
DDR4_DIMM2_TDQS_N16: length 98.8
  L03_SIG1 w0.076: 88.09,82.12 88.08,82.11 88.08,82.11 88.02,82.06 arc(87.98,82.01) 87.94,81.96 87.8,81.74 arc(87.71,81.65) 87.59,81.62 87.4,81.62 arc(87.36,81.62) 87.32,81.61 arc(87.23,81.57) 87.16,81.5 87.03,81.32 arc(86.9,81.2) 86.73,81.16 86.56,81.16 arc(86.45,81.13) 86.36,81.06 86.3,80.98 arc(86.27,80.92) 86.26,80.85 86.26,80.71 arc(86.26,80.68) 86.28,80.65 86.33,80.57 arc(86.37,80.49) 86.39,80.41 86.39,80.28 arc(86.38,80.21) 86.36,80.16 86.31,80.05 arc(86.21,79.92) 86.07,79.83 86.05,79.82 arc(85.94,79.79) 85.82,79.78 85.75,79.78 arc(85.58,79.82) 85.45,79.93 85.32,80.1 arc(85.2,80.2) 85.05,80.24 84.88,80.24 arc(84.74,80.28) 84.64,80.38 84.63,80.4 arc(84.55,80.46) 84.45,80.45 v4(84.24,80.33)
  L03_SIG1 w0.081: 88.09,82.12 88.81,82.85 92.97,84.07 100.27,84.07 101.53,84.6 101.66,84.9 101.52,85.23 101.59,85.39 101.9,85.52 102.07,85.45 102.2,85.13 102.51,85 102.93,85.18 103.06,85.48 102.84,86.01 102.89,86.15 103.25,86.3 103.38,86.24 103.6,85.71 103.91,85.58 105.68,86.32 106.09,86.73 106.57,87.89 107.19,88.51 111.15,89.68 116.74,89.68 117.55,90.49 130.13,90.49 132.96,93.32 132.96,94.37 134.07,95.48 134.65,95.48 135.47,96.3 141.13,96.3 141.34,96.39 143.38,96.39 147.5,98.09 148.18,98.09 148.73,98.32 149.12,98.71 149.12,99.03 148.98,99.17 148.98,99.34 149.1,99.46 149.27,99.46 149.41,99.32 149.7,99.32 150.25,99.86 150.25,100.29 153.92,103.96 156.6,103.96 156.98,103.57 157.64,103.57 158,103.93 158.44,103.93 158.58,103.79 159.77,103.79 159.91,103.93 160.49,103.93 161.49,102.94 164.07,102.94 165.96,101.04 166.83,101.04 167.07,101.28 167.07,101.5 167.17,101.6 v4(167.39,101.6)
DDR4_DIMM2_TDQS_N17: length 70.2
  L12_SIG4 w0.076: 93.24,82.57 93.24,82.56 93.24,82.55 93.24,82.14 arc(93.25,82.06) 93.28,81.99 93.38,81.8 arc(93.4,81.65) 93.35,81.52 93.34,81.5 arc(93.26,81.28) 93.31,81.05 93.4,80.89 arc(93.41,80.83) 93.4,80.76 93.3,80.55 arc(93.25,80.29) 93.34,80.04 93.38,79.98 arc(93.41,79.87) 93.38,79.77 93.34,79.7 arc(93.25,79.38) 93.37,79.07 93.37,79.06 arc(93.41,78.96) 93.38,78.84 93.33,78.77 arc(93.24,78.54) 93.28,78.3 93.34,78.17 arc(93.38,78.01) 93.33,77.86 93.32,77.84 arc(93.26,77.55) 93.35,77.26 93.36,77.24 arc(93.41,77.1) 93.37,76.95 93.31,76.84 arc(93.24,76.76) 93.14,76.73 92.87,76.73 arc(92.68,76.68) 92.54,76.54 92.44,76.37 arc(92.4,76.22) 92.45,76.06 92.49,75.98 92.46,75.88 v1(92.21,75.73)
  L12_SIG4 w0.089: 93.24,82.57 93.24,84.18 91.32,86.1 91.32,88.22 91.2,88.34 90.69,88.34 90.43,88.61 90.43,88.99 90.69,89.26 91.16,89.26 91.32,89.41 91.32,89.63 91.16,89.79 90.62,89.79 90.35,90.06 90.35,90.44 90.62,90.7 91.16,90.7 91.32,90.86 91.32,91.08 91.16,91.24 90.59,91.24 90.33,91.5 90.33,91.88 90.59,92.15 91.16,92.15 91.32,92.31 91.32,92.53 91.16,92.68 90.56,92.68 90.29,92.95 90.29,93.33 90.56,93.6 91.16,93.6 91.32,93.75 91.32,94.1 90.89,94.53 88.84,94.53 88.56,94.81 88.56,97.57 88.83,97.83 89.47,97.83 89.83,97.47 89.83,95.81 90.04,95.6 90.79,95.6 90.88,95.68 90.88,97.44 91.27,97.83 91.79,97.83 92.09,97.53 92.09,95.6 92.32,95.37 92.76,95.37 92.86,95.48 92.86,98.95 93,99.1 93,99.59 92.85,99.74 92.85,100.37 93.08,100.59 93.72,100.59 94.34,101.21 94.34,101.63 94.75,102.03 94.75,103.08 95.19,103.52 95.91,103.52 96.2,103.8 96.2,105.52 96.07,105.65 95.74,105.65 95.62,105.52 95.62,104.43 95.38,104.19 94.96,104.19 94.72,104.43 94.72,105.52 94.6,105.65 94.28,105.65 94.15,105.52 94.15,105.15 93.91,104.91 92.88,104.91 92.64,105.16 92.64,105.59 92.54,105.69 91.91,105.69 91.81,105.59 91.81,104.36 91.93,104.24 93.81,104.24 94.05,104 94.05,103.25 93.79,102.99 93.26,102.99 93.11,102.84 93.11,102.68 93.23,102.56 93.34,102.56 93.46,102.45 93.46,102.29 93.34,102.17 93.23,102.17 93.11,102.06 93.11,101.68 93.19,101.61 v1(93.44,101.61)
EN_5V0: length 3.5
  TOP w0.254: U94.A3 v1(195.59,58.5)
  BOTTOM w0.254: C1093.1 R862.1 195.65,58.56 v1(195.59,58.5)
EN_G0: length 69.3
  L07_SIG3 w0.089: v1(27.18,68.65) 26.68,69.15 26.68,70.08 25.71,71.05 22.08,71.05 21.68,71.45 21.68,71.85 21.38,72.15 20.98,72.15 20.68,72.45 20.68,72.85 20.38,73.15 19.98,73.15 19.68,73.45 19.68,73.85 19.38,74.15 17.88,74.15 16.39,75.64 16.39,75.9 15.25,77.04 15.25,77.42 14.61,78.06 14.61,81.74 14.1,82.25 14.1,84.15 10.47,87.79 10.47,91.21 9.86,91.82 9.86,95.35 10.4,95.89 10.4,96.55 10.19,96.75 10.19,100.93 15.51,106.25 17.53,106.25 18.3,107.01 18.3,107.9 18.8,108.41 18.8,108.92 18.55,109.17 18.55,109.81 18.84,110.1 26.58,110.1 v1(27.95,108.73)
  BOTTOM w0.149: v1(27.18,68.65) 26.68,68.15 26.68,66.82 R75.2
EN_G1: length 419.2
  TOP w0.149: v1(13.09,59.9) 13.85,60.66 16.26,60.66 16.82,61.22 16.82,62.11 19.06,64.34 26.17,64.34 28.84,67.01 30.23,67.01 30.68,67.45 30.68,68.15 v1(31.18,68.65)
  TOP w0.203: 184.68,52.28 184.59,52.36 U61.20
  TOP w0.254: R600.1 v1(162.38,30.43) ; R592.1 v1(162.38,88.47) ; R576.1 v1(162.38,59.51) ; 184.68,52.28 184.81,52.15 v1(186.38,52.15) ; R584.1 v1(162.38,73.99) ; R568.1 v1(162.38,45.04)
  L05_SIG2 w0.081: v1(13.09,59.9) 13.52,60.33 14.1,60.33 14.38,60.05 14.38,59.57 14.26,59.44 14.26,58.73 14.83,58.16 14.83,51.71 15.64,50.9 15.64,42.22 17.37,40.49 17.37,38.24 16.58,37.46 16.58,30.93 16.86,30.65 17.3,30.65 17.62,30.34 17.62,29.21 19.48,27.35 24.3,27.35 24.65,27.69 32.24,27.69 33.76,26.16 33.76,25.76 34.3,25.23 40.12,25.23 41.01,26.11 43.39,26.11 44.69,24.81 46.35,24.81 48.13,23.02 48.13,19.16 48.89,18.41 60.52,18.41 62.28,16.65 62.65,16.65 64.01,15.29 65.07,15.29 65.77,14.59 65.77,14.12 67.67,12.22 79.89,12.22 80.05,12.38 81.81,12.38 82.2,12.76 126.01,12.76 127.28,14.03 131.42,14.03 135.85,18.47 147.07,18.47 147.38,18.77 160.08,18.77 160.33,19.03 165.72,19.03 166.2,19.51 166.2,23.12 v1(165.49,23.83)
  L07_SIG3 w0.089: v1(44.01,92.53) 43.57,92.98 41.6,92.98 41.16,92.53 41.16,89.99 40.77,89.61 39.63,89.61 39.12,89.11 39.12,85.04 39,84.91 39,81.61 39.76,80.85 39.76,75.21 39.38,74.83 39.38,67.26 v1(40.39,66.25)
  L14_SIG5 w0.081: v1(62.03,67.51) 61.39,67.51 60.91,67.31 54.48,67.31 53.24,66.07 40.57,66.07 v1(40.39,66.25) 32.96,66.25 32.43,66.77 32.43,67.4 v1(31.18,68.65)
  L14_SIG5 w0.203: v1(162.38,88.47) 160.91,87 159.67,87 159.27,86.59 159.27,82.25 160.15,81.36 160.79,81.36 161.11,81.04 161.11,75.96 160.41,75.26 160.41,74.25 160.66,73.99 v1(162.38,73.99) 162.38,73.55 161.45,72.62 159.67,72.62 159.14,72.09 159.14,67.77 160.03,66.88 160.92,66.88 161.42,66.37 161.42,62.05 162.69,60.78 162.69,59.83 v1(162.38,59.51) 161.23,60.66 160.59,60.66 160.41,60.48 160.41,59.77 160.15,59.51 159.77,59.51 159.44,59.18 159.44,53.11 160.15,52.4 160.79,52.4 161.3,51.89 161.3,46.12 v1(162.38,45.04) 163.27,45.93 166.38,45.93 169.68,49.23 175.9,49.23 176.92,50.24 184.47,50.24 v1(186.38,52.15) v1(187.27,53.04)
  L16_SIG6 w0.081: v1(162.38,45.04) 161.17,43.83 161.17,43.39 159.77,41.99 159.77,38.31 160.15,37.92 160.92,37.92 161.64,37.2 161.64,31.17 v1(162.38,30.43) 160.41,28.46 160.41,28.15 159.77,27.51 159.77,24.84 160.28,24.34 161.55,24.34 162.06,23.83 v1(165.49,23.83)
  BOTTOM w0.149: R74.2 29.73,67.33 29.73,67.9 29.98,68.15 30.68,68.15 v1(31.18,68.65)
  BOTTOM w0.254: R620.1 62.68,66.5 62.03,67.15 v1(62.03,67.51)
