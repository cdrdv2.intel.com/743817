# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM2_CK_N1: length 106
  L12_SIG4 w0.076: v1(100.18,80.33) 100.42,80.54 100.44,80.62 100.41,80.66 arc(100.37,80.82) 100.42,80.97 100.52,81.13 arc(100.68,81.28) 100.9,81.34 101.06,81.34 arc(101.18,81.37) 101.27,81.45 101.3,81.48 arc(101.36,81.65) 101.33,81.82 101.22,82.04 arc(101.19,82.21) 101.23,82.37 101.26,82.45 arc(101.27,82.46) 101.27,82.48 101.27,83.01 101.26,83.01 101.26,83.03
  L12_SIG4 w0.089: 101.26,83.03 101.26,83.32 101.1,83.48 99.63,83.48 99.3,83.81 99.3,91.28 100,91.99 100.68,91.99 101.33,92.64 101.33,94.38 101.56,94.61 101.56,97.12 100.69,97.99 100.69,102.09 100.38,102.4 100.38,105.09 101.4,106.11 113.4,106.11 113.69,105.82 116.28,105.82 117.37,106.92 119.51,106.92 121.37,105.06 133.15,105.06 134.09,104.13 136.65,104.13 136.83,104.31 136.83,105.67 136.66,105.84 136.14,105.84 135.92,105.63 135.92,105.35 135.64,105.07 135.14,105.07 134.79,105.41 134.79,106.16 134,106.96 130.77,106.96 130.64,106.83 130.64,106.16 130.4,105.92 129.35,105.92 129.11,106.16 129.11,106.83 128.99,106.96 126.1,106.96 125.97,106.83 125.97,106.08 125.73,105.84 125.1,105.84 124.86,106.08 124.86,108.29 124.73,108.42 124.19,108.42 124.07,108.29 124.07,107.31 123.49,106.73 123.49,106.09 123.25,105.85 122.62,105.85 122.38,106.09 122.38,106.59 121.77,107.2 121.77,108 121.64,108.13 121.35,108.13 121.22,108 121.22,107.2 120.98,106.96 120.48,106.96 119.47,107.97 114,107.97 113.9,107.87 113.9,107.78 113.79,107.68 113.65,107.68 113.55,107.78 113.55,107.87 113.45,107.97 112.79,107.97 112.66,107.85 112.66,107.7 112.76,107.6 v1(112.99,107.6)
DDR4_DIMM2_CK_P0: length 105.3
  L16_SIG6 w0.076: v1(93,79.87) 92.76,79.73 92.65,79.76 92.62,79.81 arc(92.6,79.88) 92.62,79.94 92.73,80.13 arc(92.78,80.34) 92.71,80.56 92.65,80.65 arc(92.61,80.77) 92.64,80.9 92.7,81 arc(92.75,81.22) 92.69,81.44 92.65,81.52 arc(92.61,81.67) 92.65,81.83 92.76,82.02 92.76,82.38 92.7,82.53 92.7,82.86 92.7,82.86 92.7,82.88
  L16_SIG6 w0.081: v1(112.14,101.6) 112.48,101.94 112.48,102.14 112.7,102.37 112.92,102.37 113.07,102.52 113.07,102.74 112.93,102.88 111.21,102.88 110.54,102.2 109.42,102.2 109.17,102.46 109.17,102.99 109.46,103.28 109.97,103.28 110.52,103.83 112.85,103.83 113.02,104 113.02,104.25 112.85,104.42 110.05,104.42 109.77,104.7 109.77,105.1 110.05,105.38 112.91,105.38 113.09,105.55 113.09,105.82 112.98,105.92 110.41,105.92 110.2,106.13 110.2,106.91 110.44,107.14 110.71,107.14 110.84,107.28 110.84,107.81 111.05,108.01 111.55,108.01 111.75,107.81 111.75,107.06 111.85,106.96 113.28,106.96 113.37,107.06 113.37,108.19 113.58,108.39 114.08,108.39 114.29,108.19 114.29,106.96 114.39,106.86 115,106.86 115.1,106.96 115.1,108.19 115.31,108.39 116.3,108.39 116.54,108.16 116.54,107.65 116.28,107.39 116.28,105.87 116.07,105.67 114.22,105.67 114.05,105.49 114.05,105.25 114.22,105.08 116.59,105.08 116.86,104.8 116.86,104.4 116.59,104.12 114.15,104.12 113.98,103.95 113.98,103.7 114.15,103.53 116.1,103.53 116.3,103.33 116.3,102.58 116.07,102.35 115.41,102.35 115.21,102.15 114.5,102.15 113.63,101.27 113.63,99.61 113.4,99.39 113,99.39 112.87,99.26 112.87,98.62 112.06,97.81 111.75,97.81 111.43,98.14 111.43,98.43 111.79,98.79 111.79,99.53 111.66,99.65 110.97,99.65 110.87,99.56 110.87,98.4 110.62,98.14 110.28,98.14 110,98.42 110,99.58 109.83,99.75 109.35,99.75 109.17,99.58 109.17,98.31 108.89,98.03 108.28,98.03 108.01,98.31 108.01,99.24 107.83,99.41 107.57,99.41 107.3,99.68 107.3,100.94 107.21,101.03 106.9,101.03 106.8,100.93 106.8,99.39 106.64,99.22 106.64,98.26 106.43,98.05 106.02,98.05 105.82,98.26 105.82,98.67 105.72,98.77 105.44,98.77 105.35,98.67 105.35,98.35 105.14,98.15 104.85,98.15 104.7,98.3 104.24,98.3 103.91,98.62 102.53,98.62 102.2,98.3 101.28,98.3 101.04,98.05 99.98,98.05 99.3,97.37 98.84,97.37 98.56,97.1 98.56,95.16 99.23,94.49 99.23,92.6 97.6,90.96 96.58,90.96 94.28,88.67 94.28,85.28 92.7,83.7 92.7,82.88
DDR4_DIMM2_CK_P1: length 106
  L12_SIG4 w0.076: v1(100.97,80.79) 100.68,80.69 100.59,80.71 100.56,80.75 arc(100.55,80.81) 100.57,80.88 100.67,81.04 arc(100.77,81.13) 100.9,81.16 101.06,81.16 arc(101.26,81.21) 101.41,81.34 101.44,81.38 arc(101.54,81.63) 101.49,81.89 101.38,82.12 arc(101.37,82.21) 101.39,82.29 101.43,82.38 arc(101.44,82.43) 101.45,82.48 101.45,83.01 101.45,83.01 101.45,83.03
  L12_SIG4 w0.089: v1(112.14,107.6) 112.71,108.16 119.55,108.16 120.56,107.15 120.9,107.15 121.03,107.28 121.03,108.08 121.27,108.32 121.72,108.32 121.96,108.08 121.96,107.28 122.57,106.66 122.57,106.16 122.7,106.04 123.17,106.04 123.3,106.16 123.3,106.81 123.88,107.39 123.88,108.37 124.11,108.61 124.81,108.61 125.05,108.37 125.05,106.16 125.18,106.03 125.66,106.03 125.78,106.16 125.78,106.91 126.02,107.15 129.06,107.15 129.3,106.91 129.3,106.24 129.43,106.11 130.32,106.11 130.45,106.24 130.45,106.91 130.69,107.15 134.08,107.15 134.99,106.24 134.99,105.49 135.22,105.26 135.56,105.26 135.73,105.43 135.73,105.71 136.06,106.04 136.73,106.04 137.02,105.74 137.02,104.23 136.73,103.93 134.01,103.93 133.07,104.87 121.29,104.87 119.43,106.73 117.45,106.73 116.36,105.63 113.61,105.63 113.32,105.92 101.48,105.92 100.57,105.01 100.57,102.48 100.88,102.16 100.88,98.07 101.75,97.2 101.75,94.53 101.52,94.3 101.52,92.57 100.76,91.8 100.08,91.8 99.49,91.21 99.49,83.89 99.7,83.67 101.18,83.67 101.45,83.4 101.45,83.03
DDR4_DIMM2_CKE0: length 98.5
  L16_SIG6 w0.081: v1(100.24,101.6) 100.24,102.82 100.34,102.92 100.5,102.92 100.6,102.82 100.6,101.84 100.69,101.74 100.83,101.74 100.93,101.84 100.93,102.14 101.03,102.24 101.17,102.24 101.27,102.14 101.27,101.68 101.36,101.58 101.5,101.58 101.6,101.68 101.6,102.44 101.7,102.54 102.19,102.54 102.58,102.93 104.25,102.93 104.42,103.1 104.42,104.62 104.31,104.72 104.16,104.72 104.06,104.63 104.06,103.37 103.96,103.27 103.34,103.27 103.24,103.37 103.24,104.14 103.33,104.23 103.58,104.23 103.68,104.33 103.68,104.62 103.58,104.72 102.94,104.72 102.84,104.63 102.84,103.38 102.74,103.28 102.6,103.28 102.51,103.38 102.51,104.63 102.41,104.72 102.27,104.72 102.17,104.63 102.17,103.07 102.07,102.97 101.93,102.97 101.84,103.07 101.84,104.63 101.74,104.72 101.6,104.72 101.5,104.63 101.5,103.34 101.4,103.25 100.78,103.25 100.68,103.34 100.68,104.29 100.78,104.39 101.05,104.39 101.14,104.49 101.14,104.63 101.05,104.72 100.38,104.72 100.28,104.63 100.28,103.47 100.17,103.36 100.02,103.36 99.9,103.48 99.9,104.61 99.79,104.72 99.55,104.72 99.45,104.62 99.45,103.25 99.8,102.91 99.8,102.3 99.7,102.2 99.47,102.2 99.37,102.1 99.37,101.96 99.47,101.87 99.7,101.87 99.8,101.77 99.8,101.63 99.7,101.53 99.47,101.53 99.37,101.43 99.37,101.35 98.8,100.77 97.59,100.77 97.3,101.06 97.3,101.75 97.07,101.98 97.07,103.09 96.97,103.19 96.83,103.19 96.73,103.09 96.73,102.37 96.63,102.27 96.49,102.27 96.4,102.37 96.4,103.58 96.3,103.68 96.16,103.68 96.06,103.58 96.06,102.78 95.96,102.68 95.82,102.68 95.72,102.78 95.72,103.57 95.63,103.67 95.49,103.67 95.39,103.57 95.39,102.44 95.29,102.34 95.15,102.34 95.05,102.44 95.05,103.55 94.96,103.65 94.82,103.65 94.72,103.55 94.72,102.6 94.62,102.5 94.48,102.5 94.38,102.6 94.38,103.54 94.29,103.64 94.15,103.64 94.05,103.54 94.05,102.62 93.95,102.52 93.81,102.52 93.71,102.62 93.71,103.12 93.61,103.22 93.48,103.22 93.38,103.12 93.38,102.14 93.52,101.99 93.78,101.99 94.05,101.72 94.56,101.72 94.83,101.99 96.15,101.99 96.38,101.76 96.38,101.55 96.62,101.31 96.62,101.17 96.52,101.07 95.8,101.07 95.71,100.98 95.71,100.84 95.8,100.74 96.85,100.74 96.95,100.64 96.95,100.5 96.85,100.4 95.45,100.4 95.35,100.5 95.35,101.13 95.25,101.23 95.11,101.23 95.02,101.13 95.02,100.5 94.92,100.4 94.78,100.4 94.68,100.5 94.68,101.29 94.58,101.39 94.44,101.39 94.35,101.29 94.35,100.5 94.25,100.4 94.11,100.4 94.01,100.5 94.01,101.13 93.91,101.23 93.77,101.23 93.67,101.13 93.67,100.5 93.58,100.4 93.44,100.4 93.34,100.5 93.34,101.13 93.24,101.23 93.1,101.23 93,101.13 93,100.85 92.91,100.75 92.77,100.75 92.67,100.85 92.67,101.13 92.57,101.23 92.43,101.23 92.33,101.13 92.33,100.56 92.5,100.39 92.84,100.39 93.01,100.22 93.01,99.25 92.78,99.02 91.83,99.02 91.34,98.53 91.34,97.53 91.13,97.33 91.13,94.47 91.36,94.25 91.36,93.9 91.06,93.6 90.75,93.6 90.6,93.46 90.6,88.44 90.74,88.3 91.06,88.3 91.25,88.11 91.25,86.65 90.63,86.04 90.63,82.74 90.23,82.34 90.23,80.09 90.46,79.86 90.76,79.86 91,79.62 91,78.44 v1(91.41,78.03)
DDR4_DIMM2_CKE1: length 98.7
  L16_SIG6 w0.081: v1(99.39,107.6) 99.39,107.86 98.9,108.36 89.93,108.36 89.67,108.1 89.67,106.72 88.98,106.03 88.98,103.42 89.66,102.74 89.66,99.41 89.06,98.81 88.03,98.81 87.3,98.08 87.3,97.82 87.67,97.44 87.67,96.37 87.97,96.07 87.97,95.87 87.87,95.77 85.51,95.77 85.38,95.64 85.38,94.45 85.48,94.35 85.66,94.35 85.76,94.45 85.76,95.29 85.86,95.39 86.05,95.39 86.16,95.29 86.16,95.1 86.26,95 86.42,95 86.52,95.1 86.52,95.29 86.63,95.39 87.88,95.39 87.98,95.29 87.98,95.15 87.88,95.04 87.22,95.04 87.11,94.94 87.11,94.54 86.88,94.31 86.88,94.03 86.78,93.92 86.23,93.92 86.13,93.82 86.13,93.67 86.23,93.56 86.78,93.56 86.88,93.46 86.88,93.31 86.78,93.2 86.06,93.2 85.95,93.09 85.95,92.95 86.06,92.84 86.78,92.84 86.88,92.73 86.88,92.58 86.78,92.48 86.06,92.48 85.95,92.37 85.95,92.22 86.06,92.12 86.78,92.12 86.88,92.01 86.88,91.86 86.78,91.76 86.06,91.76 85.95,91.65 85.95,91.5 86.06,91.4 86.78,91.4 86.88,91.29 86.88,91.14 86.78,91.04 86.06,91.04 85.95,90.93 85.95,90.78 86.06,90.68 86.78,90.68 86.88,90.57 86.88,90.42 86.78,90.31 86.06,90.31 85.95,90.21 85.95,90.06 86.06,89.95 86.78,89.95 86.88,89.85 86.88,89.7 86.78,89.59 86.06,89.59 85.95,89.49 85.95,89.34 86.06,89.23 86.78,89.23 86.88,89.13 86.88,88.98 86.78,88.87 86.06,88.87 85.95,88.77 85.95,88.62 86.06,88.51 86.78,88.51 86.88,88.41 86.88,86.8 86.78,86.71 86.64,86.71 86.54,86.8 86.54,88.02 86.43,88.14 85.67,88.14 85.57,88.24 85.57,93.31 85.45,93.43 85.27,93.43 85.17,93.33 85.17,87.6 85.28,87.49 85.68,87.49 85.79,87.37 85.79,87.21 85.68,87.1 85.28,87.1 85.17,86.99 85.17,86.41 85.27,86.31 87.33,86.31 87.43,86.21 87.43,86.07 87.33,85.97 85.27,85.97 85.17,85.87 85.17,85.74 85.27,85.64 87.33,85.64 87.43,85.54 87.43,85.4 87.33,85.3 85.38,85.3 85.28,85.2 85.28,85.06 85.38,84.97 87.33,84.97 87.43,84.87 87.43,84.73 87.33,84.63 85.9,84.63 85.81,84.53 85.81,84.39 85.9,84.3 87.33,84.3 87.43,84.2 87.43,84.06 87.33,83.96 86.49,83.96 86.39,83.86 86.39,83.72 86.49,83.63 87.33,83.63 87.43,83.53 87.43,83.39 87.33,83.29 87.12,83.29 87.02,83.19 87.02,83.05 87.12,82.96 87.33,82.96 87.43,82.86 87.43,82.72 87.33,82.62 87.12,82.62 87.02,82.52 87.02,79.18 87.23,78.97 87.59,78.97 88.04,78.51 88.27,78.51 88.73,78.06 89.24,78.06 89.67,78.49 v1(90.61,78.49)
DDR4_DIMM2_CS_N0: length 101.9
  L14_SIG5 w0.081: v1(125.74,101.6) 126.32,101.6 126.45,101.48 126.45,100.29 126.59,100.15 126.91,100.15 127.05,100.29 127.05,104 126.93,104.13 126.12,104.13 126,104.01 126,102.82 125.88,102.71 125.56,102.71 125.44,102.82 125.44,104.01 125.32,104.13 124.57,104.13 124.44,104 124.44,100.69 124.17,100.42 122.19,100.42 121.9,100.71 121.9,101.02 121.69,101.23 120.48,101.23 119.94,100.69 117.47,100.69 116,99.22 114.7,99.22 113.91,98.43 104.35,98.43 103.24,99.55 103.24,100.12 102.9,100.45 101.99,100.45 100.19,102.25 100.19,102.46 99.59,103.06 98.42,103.06 98.29,103.2 96.39,103.2 95.69,103.89 93.79,103.89 93.65,104.03 92.92,104.03 92.78,103.89 91.27,103.89 90.5,103.12 88.04,103.12 87.09,102.17 87.09,101.78 85.55,100.24 85.55,99.98 85.32,99.75 85.32,93.66 87.67,91.32 88.03,91.32 89.39,89.95 90.26,89.95 92.42,87.79 92.42,87.19 93.25,86.36 93.79,86.36 94.35,85.8 95.56,85.8 98.29,83.07 98.69,83.07 99.78,81.99 99.78,78.77 99.47,78.46 99.17,78.46 98.71,78.01 98.36,78.01 97.92,77.57 97.59,77.57 97.14,77.12 96.78,77.12 96.35,77.55 95.99,77.55 95.49,77.04 95.18,77.04 94.77,76.63 94.44,76.63 94.04,77.04 93.63,77.04 93.1,77.57 92.79,77.57 92.35,78.02 92.07,78.02 91.6,78.49 91.19,78.49 90.73,78.03 v1(89.82,78.03)
DDR4_DIMM2_CS_N1: length 99.5
  L16_SIG6 w0.081: v1(129.99,101.6) 131.14,101.6 131.24,101.5 131.24,101.33 131.14,101.23 130.45,101.23 130.32,101.1 130.32,100.57 130.5,100.39 132.32,100.39 132.43,100.51 132.43,100.7 132.34,100.8 131.7,100.8 131.6,100.9 131.6,101.03 131.7,101.13 132.81,101.13 132.9,101.03 132.9,100.56 133,100.46 133.71,100.46 133.82,100.57 133.82,100.76 133.92,100.87 135.8,100.87 135.9,100.77 135.9,100.64 135.8,100.53 134.9,100.53 134.67,100.31 134.67,99.77 134.47,99.57 133.58,99.57 133.34,99.34 133.13,99.34 132.48,99.98 132.34,99.98 132.2,99.85 132.2,99.7 132.39,99.52 132.39,99.38 132.23,99.22 132.09,99.22 131.73,99.57 131.08,99.57 130.95,99.45 130.8,99.45 130.41,99.84 130.26,99.84 130.15,99.74 130.15,99.59 130.55,99.19 130.55,99.04 130.46,98.95 130.46,98.81 130.55,98.71 130.69,98.71 131.17,99.19 131.31,99.19 131.4,99.09 131.4,98.95 131.12,98.66 131.12,98.52 131.22,98.43 131.36,98.43 131.83,98.9 131.97,98.9 132.07,98.8 132.07,98.66 131.73,98.32 131.73,98.18 131.88,98.03 132.04,98.03 132.4,98.39 132.52,98.39 132.68,98.23 132.68,98.1 130.83,96.24 130.69,96.24 130.59,96.34 130.59,96.48 131.4,97.29 131.4,97.43 131.3,97.53 131.16,97.53 130.1,96.47 129.96,96.47 129.86,96.57 129.86,96.7 130.86,97.7 130.86,97.84 130.76,97.93 130.62,97.93 130.39,97.7 130.24,97.7 130.13,97.81 130.13,97.96 130.29,98.11 130.29,98.26 130.18,98.37 130.03,98.37 129.62,97.96 129.62,97.81 129.98,97.45 129.98,97.3 129.37,96.68 129.37,96.46 129.65,96.17 129.65,95.88 129.31,95.53 128.98,95.53 128.58,95.13 128.58,94.85 127.98,94.26 127.84,94.26 127.7,94.4 127.7,94.54 128.14,94.98 128.14,95.19 128.74,95.78 128.74,95.92 128.64,96.02 128.5,96.02 127.46,94.98 127.46,94.85 127.02,94.4 127.02,92.97 126.92,92.87 126.71,92.87 126.6,92.98 126.6,93.33 126.52,93.41 126.34,93.41 126.2,93.27 126.2,92.71 126.05,92.56 125.52,92.56 125.42,92.66 125.42,92.88 125.32,92.98 125.18,92.98 125.08,92.88 125.08,92.66 124.98,92.56 124.84,92.56 124.75,92.66 124.75,92.88 124.65,92.98 124.51,92.98 124.41,92.88 124.41,92.66 124.31,92.56 122.95,92.56 122.85,92.66 122.85,92.83 122.75,92.93 122.61,92.93 122.51,92.83 122.51,92.66 122.42,92.56 122.28,92.56 122.18,92.66 122.18,92.83 122.08,92.93 121.94,92.93 121.84,92.83 121.84,92.66 121.75,92.56 121.33,92.56 121.23,92.66 121.23,92.75 121.13,92.85 120.99,92.85 120.89,92.75 120.89,92.66 120.8,92.56 116.84,92.56 116.28,92 106.75,92 105.73,90.97 105.29,90.97 102.35,88.03 102.35,86.57 98.85,83.08 98.85,82.94 98.95,82.84 99.09,82.84 99.89,83.63 100.03,83.63 100.12,83.54 100.12,83.4 98.97,82.24 98.97,78.23 98.74,78.01 98.38,78.01 97.92,77.55 97.59,77.55 97.11,77.07 96.76,77.07 96.32,76.63 95.99,76.63 95.56,77.07 95.21,77.07 94.72,77.55 94.5,77.55 94.02,78.03 v1(93,78.03)
DDR4_DIMM2_DBI_N0: length 67.4
  L12_SIG4 w0.076: 83.35,82.38 83.36,82.37 83.37,82.37 83.61,82.13 83.79,81.87 arc(83.84,81.68) 83.79,81.49 83.74,81.4 arc(83.68,81.21) 83.72,81.02 83.77,80.9 arc(83.8,80.74) 83.75,80.59 83.74,80.58 arc(83.66,80.35) 83.72,80.12 83.8,79.99 arc(83.83,79.87) 83.8,79.75 83.72,79.61 arc(83.66,79.38) 83.74,79.16 83.8,79.07 arc(83.83,78.97) 83.81,78.86 83.72,78.69 arc(83.67,78.46) 83.74,78.25 83.78,78.18 arc(83.79,78.18) 83.79,78.18 arc(83.79,78.17) 83.79,78.17 arc(83.83,78.03) 83.8,77.9 83.74,77.79 arc(83.68,77.57) 83.74,77.35 83.84,77.15 arc(83.85,77.07) 83.82,76.99 83.73,76.88 arc(83.67,76.7) 83.7,76.52 83.8,76.29 arc(83.83,76.16) 83.79,76.04 83.75,75.98 arc(83.68,75.73) 83.75,75.48 83.79,75.42 arc(83.83,75.26) 83.78,75.11 arc(83.78,75.1) 83.77,75.1 arc(83.69,74.84) 83.74,74.58 83.78,74.49 arc(83.93,74.32) 84.15,74.26 84.33,74.26 arc(84.35,74.26) 84.37,74.25 arc(84.48,74.19) 84.56,74.08 84.59,74.03 arc(84.74,73.86) 84.96,73.8 85.14,73.8 arc(85.24,73.77) 85.32,73.69 85.4,73.55 arc(85.56,73.38) 85.79,73.31 85.89,73.31 arc(86.08,73.36) 86.23,73.5 86.36,73.7 arc(86.45,73.78) 86.57,73.81 86.72,73.81 arc(86.84,73.78) 86.92,73.68 86.98,73.57 arc(87.15,73.37) 87.4,73.3 87.53,73.3 arc(87.67,73.33) 87.78,73.41 87.86,73.54 87.98,73.57 v1(88.22,73.43)
  L12_SIG4 w0.089: v1(55.19,101.6) 55.52,101.27 55.52,100.66 55.38,100.52 55.38,99.84 56.68,98.53 72.36,98.53 72.61,98.28 72.61,97.92 72.37,97.68 67.14,97.68 66.86,97.4 66.86,96.81 67.13,96.55 68.64,96.55 68.95,96.23 68.95,95.38 69.36,94.97 70.36,94.97 70.77,95.38 70.77,96.29 71.02,96.55 71.96,96.55 72.25,96.26 72.25,94.47 72.87,93.84 73.15,93.84 79.22,87.77 79.22,86.51 83.35,82.38
DDR4_DIMM2_DBI_N1: length 66.8
  L14_SIG5 w0.076: v1(86.63,78.03) 86.39,78.17 86.35,78.29 86.39,78.35 arc(86.44,78.41) 86.52,78.43 86.74,78.43 arc(86.95,78.49) 87.1,78.66 87.16,78.79 arc(87.19,78.99) 87.13,79.17 87.08,79.25 arc(87.04,79.38) 87.07,79.51 87.15,79.68 arc(87.2,79.9) 87.13,80.11 87.08,80.18 arc(87.04,80.3) 87.06,80.43 87.15,80.61 arc(87.2,80.83) 87.15,81.05 87.12,81.09 arc(87.09,81.27) 87.14,81.44 87.16,81.47 arc(87.22,81.67) 87.17,81.87 87.05,82.09 86.69,82.45 86.69,82.45 86.67,82.47
  L14_SIG5 w0.081: 86.67,82.47 85.64,83.49 79.69,83.49 77.43,85.76 77.43,87.72 72.7,92.45 68.3,92.45 67.93,92.82 67.93,94.09 67.42,94.6 66.8,94.6 66.44,94.24 65.98,94.24 65.68,94.53 64.47,94.53 63.75,95.25 61.26,95.25 61.11,95.41 61.11,95.92 61.26,96.07 62.72,96.07 62.98,96.33 62.98,96.91 62.72,97.17 61.96,97.17 61.81,97.33 61.81,97.9 61.96,98.05 62.83,98.05 63.13,98.35 63.75,98.35 63.87,98.23 63.87,96.05 64.14,95.78 64.67,95.78 64.94,96.05 64.94,98.69 65.08,98.82 65.73,98.82 65.86,98.7 65.86,97.51 65.66,97.31 65.66,95.57 65.96,95.27 66.66,95.27 66.98,95.58 66.98,98.9 66.66,99.22 66.66,99.58 66.85,99.77 66.85,100.97 65.41,102.41 65.12,102.41 64.88,102.17 64.88,101.93 v1(64.54,101.6)
DDR4_DIMM2_DBI_N2: length 69.3
  L05_SIG2 w0.076: v1(83.44,73.43) 83.2,73.57 arc(83.14,73.58) 83.09,73.55 83.07,73.53 arc(83.07,73.53) 83.07,73.53 83.04,73.48 arc(82.93,73.37) 82.78,73.33 82.23,73.33 82.1,73.46 81.54,73.46 81.41,73.33 81.08,73.33 80.63,72.88 80.22,72.88 arc(80.07,72.91) 79.93,73 79.68,73.25 arc(79.59,73.32) 79.47,73.34 79.02,73.34 79.02,73.34 79,73.34
  L05_SIG2 w0.081: v1(73.89,101.6) 74.24,101.25 74.24,100.82 74.08,100.67 72.59,100.67 71.58,99.65 71.58,99.32 70.75,98.49 64.04,98.49 63.73,98.18 63.73,96.68 64.07,96.34 64.95,96.34 65.3,96.68 65.3,97.12 65.43,97.25 67.04,97.25 67.48,96.81 69.31,96.81 69.5,96.62 69.5,95.45 69.32,95.26 65,95.26 63.91,94.17 63.91,91.81 64.31,91.4 72.66,91.4 76.12,87.94 76.12,83.27 75.93,83.08 74.19,83.08 73.71,82.6 73.71,81.77 74.46,81.02 75.89,81.02 76.12,80.8 76.12,77.73 77.45,76.41 77.45,75.84 78.04,75.25 78.04,74.15 78.29,73.89 78.85,73.34 79,73.34
DDR4_DIMM2_DBI_N3: length 63.9
  L16_SIG6 w0.076: 79.1,77.94 79.12,77.94 79.12,77.94 79.51,77.94 arc(79.65,77.9) 79.76,77.79 79.81,77.71 arc(79.96,77.54) 80.18,77.48 80.31,77.48 arc(80.44,77.45) 80.54,77.35 80.61,77.24 arc(80.79,77.07) 81.03,77.02 81.11,77.02 arc(81.23,76.98) 81.32,76.89 81.37,76.79 arc(81.53,76.62) 81.75,76.56 81.93,76.56 arc(82.06,76.52) 82.15,76.43 82.21,76.32 arc(82.36,76.17) 82.56,76.12 82.71,76.12 arc(82.84,76.08) 82.93,75.99 82.98,75.89 arc(83.16,75.71) 83.42,75.64 83.51,75.64 arc(83.65,75.6) 83.74,75.49 83.79,75.4 arc(83.94,75.24) 84.15,75.18 84.28,75.18 arc(84.43,75.14) 84.54,75.03 84.6,74.92 arc(84.76,74.76) 84.98,74.7 85.1,74.7 arc(85.3,74.75) 85.45,74.89 85.55,75.05 arc(85.65,75.15) 85.79,75.18 85.83,75.18 arc(86,75.14) 86.14,75.02 86.26,74.84 arc(86.38,74.73) 86.54,74.69 86.7,74.69 arc(86.9,74.74) 87.05,74.89 87.14,75.06 arc(87.23,75.15) 87.35,75.18 87.53,75.18 arc(87.72,75.23) 87.86,75.37 87.9,75.45 87.92,75.48 arc(88,75.69) 87.95,75.9 87.92,75.95 87.94,76.02 v1(88.22,76.19)
  L16_SIG6 w0.081: 79.1,77.94 78.9,77.94 77.78,79.05 77.78,80.31 78.13,80.66 78.6,80.66 78.84,80.9 78.84,81.26 78.6,81.5 78.13,81.5 77.78,81.85 77.78,82.71 78.13,83.06 80.55,83.06 80.79,83.3 80.79,83.66 80.55,83.9 78.13,83.9 77.78,84.25 77.78,84.76 78.13,85.11 80.55,85.11 80.79,85.35 80.79,85.71 80.55,85.95 78.13,85.95 77.78,86.3 77.78,86.81 78.13,87.16 80.55,87.16 80.79,87.41 80.79,87.76 80.55,88 78.1,88 77.8,88.3 77.8,88.92 78.1,89.21 80.49,89.21 80.64,89.36 80.64,89.85 80.46,90.03 78.83,90.03 78.54,90.32 78.54,94.12 77.35,95.31 77.35,99.49 78.41,100.55 83.03,100.55 83.58,101.1 83.58,101.27 v1(83.25,101.6)
DDR4_DIMM2_DBI_N4: length 94.9
  L03_SIG1 w0.076: v4(83.44,76.19) 83.24,76.07 arc(83.14,76.05) 83.06,76.12 83.04,76.14 arc(82.94,76.24) 82.8,76.28 82.64,76.28 arc(82.52,76.3) 82.41,76.38 82.22,76.59 arc(82.07,76.7) 81.88,76.74 81.84,76.74 arc(81.61,76.68) 81.42,76.53 81.33,76.41 arc(81.21,76.31) 81.06,76.28 81.06,76.28 arc(80.93,76.3) 80.82,76.38 80.63,76.59 arc(80.48,76.7) 80.29,76.74 80.25,76.74 arc(80.01,76.68) 79.83,76.53 79.74,76.41 arc(79.62,76.31) 79.46,76.28 79.31,76.28 79.31,76.28 79.29,76.28
  L03_SIG1 w0.081: 79.29,76.28 79.1,76.28 78.77,76.42 77.73,77.46 77.46,78.09 77.46,83.88 82.95,89.37 83.66,89.37 87.45,93.16 91.2,93.16 93.21,95.16 93.83,95.16 95.9,97.23 100.74,97.23 101.09,97.58 101.09,99.18 101.45,99.54 102.07,99.54 102.49,99.12 102.49,98.64 102.72,98.41 103.5,98.41 103.73,98.64 103.73,99.11 103.97,99.35 105.03,99.35 105.24,99.14 105.24,98.37 105.47,98.13 106.16,98.13 106.39,98.37 106.39,99.2 106.54,99.35 107.56,99.35 107.78,99.13 107.78,98.24 108.03,98 108.69,98 108.93,98.24 108.93,99.22 109.06,99.35 113.45,99.35 114.8,100.7 119.49,100.7 120.22,101.42 120.22,101.78 120.46,102.02 123.19,102.02 123.78,102.61 123.78,103.51 124.39,104.13 133.93,104.13 134.03,104.03 135.01,104.03 135.37,104.39 135.37,105.06 135.55,105.24 136.06,105.24 136.18,105.12 136.18,104.37 136.52,104.03 137.9,104.03 138.07,103.86 138.07,103.74 137.94,103.61 137.94,103.5 138.1,103.34 138.21,103.34 138.34,103.47 138.46,103.47 138.82,103.1 138.82,101.93 v4(138.49,101.6)
DDR4_DIMM2_DBI_N5: length 100.4
  L05_SIG2 w0.076: v1(81.85,78.03) 81.61,78.16 81.58,78.3 81.63,78.39 arc(81.66,78.42) 81.7,78.43 81.88,78.43 arc(82.05,78.46) 82.19,78.56 82.4,78.76 arc(82.5,78.83) 82.63,78.86 82.66,78.86 arc(82.85,78.9) 83.02,79 83.25,79.24 arc(83.32,79.29) 83.41,79.3 83.49,79.3 arc(83.69,79.35) 83.84,79.49 83.94,79.62 arc(84.02,79.85) 83.95,80.09 83.87,80.23 arc(83.83,80.37) 83.88,80.49 83.92,80.54 arc(84,80.75) 83.97,80.97 83.89,81.16 arc(83.87,81.29) 83.92,81.42 83.95,81.47 arc(84.03,81.66) 83.98,81.87 83.88,82.06 arc(83.86,82.1) 83.86,82.14 83.86,82.24 83.86,82.24 83.86,82.26
  L05_SIG2 w0.081: 83.86,82.26 83.86,82.32 85.49,83.95 85.49,91.84 85.62,91.97 85.95,91.97 86.08,91.84 86.08,89.63 86.31,89.4 86.8,89.4 87.04,89.63 87.04,94.15 88.59,95.7 88.59,96.8 90.76,98.97 91.53,98.97 92.31,99.75 92.31,100.34 93,101.03 93.99,101.03 95.56,102.6 95.56,102.91 96.8,104.15 98.23,104.15 98.56,104.48 99.7,104.48 100.15,104.94 102.44,104.94 102.77,105.27 103.65,105.27 104.3,105.93 113.3,105.93 113.59,105.64 116.01,105.64 117.47,107.11 119.62,107.11 120.89,105.85 120.89,105.22 121.22,104.89 121.82,104.89 122.19,105.26 122.19,106.08 122.36,106.25 123,106.25 123.17,106.08 123.17,105.26 123.45,104.98 124.8,104.98 125.03,105.21 125.03,105.87 125.16,106 125.69,106 125.81,105.87 125.81,105.21 126.05,104.98 132.84,104.98 132.95,105.09 134.62,105.09 134.88,104.82 139.01,104.82 140.15,103.68 144.23,103.68 144.98,102.93 147.5,102.93 147.66,102.77 147.66,102.63 147.59,102.57 147.59,102.43 147.69,102.33 147.83,102.33 147.89,102.39 148.03,102.39 148.28,102.14 148.28,101.72 148.16,101.6 v1(147.84,101.6)
DDR4_DIMM2_DBI_N6: length 99.5
  L05_SIG2 w0.076: 91.97,83.1 91.97,83.08 91.97,83.07 91.97,82.84 91.71,82.4 arc(91.67,82.31) 91.66,82.21 91.66,82.12 arc(91.67,82.01) 91.72,81.92 91.77,81.84 arc(91.78,81.81) 91.78,81.79 91.78,81.63 arc(91.78,81.59) 91.76,81.56 91.71,81.49 arc(91.66,81.4) 91.65,81.29 91.65,81.2 arc(91.66,81.12) 91.69,81.03 91.77,80.91 arc(91.8,80.79) 91.77,80.67 91.69,80.53 arc(91.64,80.31) 91.71,80.09 91.77,80 arc(91.81,79.89) 91.78,79.78 91.69,79.61 arc(91.64,79.38) 91.71,79.17 91.75,79.1 arc(91.76,79.09) 91.76,79.09 arc(91.79,78.95) 91.76,78.81 91.7,78.69 arc(91.67,78.62) 91.66,78.55 91.66,78.45 arc(91.67,78.35) 91.71,78.25 91.76,78.16 arc(91.78,78.1) 91.79,78.04 91.79,77.95 arc(91.79,77.92) 91.77,77.9 91.71,77.82 arc(91.67,77.73) 91.65,77.63 91.65,77.56 arc(91.66,77.46) 91.69,77.37 91.77,77.21 arc(91.8,77.08) 91.76,76.96 91.72,76.9 arc(91.65,76.65) 91.72,76.4 91.79,76.28 arc(91.82,76.19) 91.79,76.09 arc(91.79,76.09) 91.79,76.08 91.75,76.03 91.7,75.95 arc(91.64,75.78) 91.67,75.6 91.75,75.42 arc(91.78,75.25) 91.73,75.08 91.7,75.03 arc(91.6,74.93) 91.46,74.89 91.38,74.89 arc(91.23,74.86) 91.11,74.78 91.02,74.69 arc(90.88,74.42) 90.94,74.11 arc(90.99,73.91) 90.94,73.7 90.9,73.64 arc(90.84,73.42) 90.9,73.21 90.94,73.13 arc(91.13,72.95) 91.39,72.88 91.44,72.88 arc(91.62,72.91) 91.77,73.02 92,73.24 arc(92.09,73.3) 92.19,73.32 92.35,73.32 arc(92.49,73.36) 92.6,73.46 92.63,73.51 arc(92.7,73.57) 92.78,73.56 v1(93,73.43)
  L05_SIG2 w0.081: v1(157.19,101.6) 157.5,101.29 157.5,100.59 155.62,98.71 154.53,98.71 154.01,98.19 153.02,98.19 152.06,97.8 151.68,97.72 137.37,97.72 137.01,98.07 135.51,98.07 134.26,98.59 133.6,98.59 133.44,98.43 131.73,98.43 131.55,98.61 130.97,98.61 130.86,98.5 120.22,98.5 119.75,98.97 117.46,98.97 117.16,98.67 117.16,97.69 117.03,97.56 116.47,97.56 116.33,97.69 116.33,99.05 116.06,99.32 114.46,99.32 113.98,99.81 113.43,99.81 113.08,99.46 113.08,98.85 112.94,98.71 112.74,98.71 112.59,98.85 112.59,99.31 112.34,99.56 107.79,99.56 107.56,99.78 106.54,99.78 106.09,99.33 105.3,99.33 105.07,99.56 104.23,99.56 103.69,99.02 102.62,99.02 102.13,98.53 101.64,98.53 101.26,98.15 100.02,98.15 99.24,97.37 99.13,97.37 98.88,97.62 98.46,97.62 98.11,97.27 98.11,96.85 98.36,96.6 98.36,96.45 97.23,95.32 95.84,95.32 95.38,94.87 95.38,94.32 95.52,94.18 95.52,93.76 93.4,91.65 93.4,88.83 92.82,88.25 92.82,84.86 91.97,84.01 91.97,83.1
DDR4_DIMM2_DBI_N7: length 99
  L03_SIG1 w0.076: v4(85.04,80.79) 84.81,80.66 arc(84.76,80.59) 84.77,80.5 84.79,80.47 arc(84.83,80.43) 84.88,80.42 85.05,80.42 arc(85.29,80.36) 85.47,80.2 85.59,80.04 arc(85.66,79.98) 85.75,79.96 85.82,79.96 arc(85.91,79.96) 85.99,79.99 86.01,80 arc(86.09,80.05) 86.15,80.13 86.2,80.23 arc(86.21,80.25) 86.21,80.28 86.21,80.41 arc(86.2,80.44) 86.19,80.46 86.13,80.54 arc(86.09,80.62) 86.08,80.71 86.08,80.85 arc(86.1,80.97) 86.16,81.09 86.22,81.17 arc(86.37,81.29) 86.56,81.34 86.73,81.34 arc(86.82,81.36) 86.89,81.42 87.01,81.6 arc(87.13,81.71) 87.27,81.78 arc(87.33,81.79) 87.4,81.8 87.59,81.8 arc(87.62,81.81) 87.65,81.83 87.8,82.06 arc(87.84,82.12) 87.9,82.18 87.95,82.24 87.95,82.24 87.96,82.25
  L03_SIG1 w0.081: 87.96,82.25 88.07,82.36 88.07,82.49 88.01,82.55 88.01,82.69 88.11,82.79 88.25,82.79 88.3,82.73 88.44,82.73 88.72,83.01 92.94,84.26 100.23,84.26 101.39,84.74 101.46,84.9 101.33,85.23 101.45,85.53 101.9,85.72 102.21,85.59 102.34,85.27 102.51,85.2 102.79,85.32 102.86,85.48 102.64,86.01 102.75,86.29 103.25,86.49 103.52,86.38 103.74,85.85 103.91,85.78 105.57,86.47 105.94,86.84 106.42,87.99 107.09,88.67 111.13,89.86 116.66,89.86 117.48,90.68 130.05,90.68 132.77,93.4 132.77,94.44 133.99,95.66 134.58,95.66 135.39,96.48 141.09,96.48 141.3,96.57 143.34,96.57 147.46,98.28 148.15,98.28 148.63,98.47 148.94,98.78 148.94,98.95 148.8,99.09 148.8,99.41 149.02,99.64 149.34,99.64 149.48,99.5 149.63,99.5 150.06,99.94 150.06,100.37 153.84,104.15 156.67,104.15 157.06,103.76 157.57,103.76 157.92,104.11 158.52,104.11 158.66,103.97 159.69,103.97 159.84,104.11 160.57,104.11 161.57,103.12 164.14,103.12 164.47,102.79 164.61,102.79 164.66,102.85 164.8,102.85 164.9,102.75 164.9,102.61 164.84,102.56 164.84,102.42 166.04,101.22 166.76,101.22 166.89,101.36 166.89,101.51 166.8,101.6 v4(166.54,101.6)
DDR4_DIMM2_DBI_N8: length 70.3
  L12_SIG4 w0.076: v1(93,76.19) 92.75,76.04 92.65,76.07 92.6,76.15 arc(92.58,76.22) 92.6,76.29 92.69,76.45 arc(92.77,76.53) 92.87,76.56 93.14,76.56 arc(93.33,76.61) 93.47,76.75 93.53,76.86 arc(93.58,77.11) 93.51,77.34 93.5,77.36 arc(93.43,77.56) 93.48,77.76 93.49,77.77 arc(93.55,78.01) 93.51,78.25 93.44,78.38 arc(93.42,78.53) 93.47,78.66 93.53,78.74 arc(93.59,78.96) 93.51,79.17 93.51,79.18 arc(93.43,79.39) 93.49,79.61 93.53,79.67 arc(93.59,79.88) 93.52,80.08 93.49,80.13 arc(93.43,80.3) 93.46,80.47 93.56,80.69 arc(93.59,80.83) 93.55,80.97 93.46,81.13 arc(93.44,81.27) 93.48,81.39 93.5,81.41 arc(93.58,81.64) 93.53,81.88 93.44,82.07 arc(93.43,82.1) 93.42,82.14 93.42,82.55 93.43,82.56 93.43,82.57
  L12_SIG4 w0.089: v1(92.59,101.61) 92.85,101.61 92.92,101.68 92.92,102.92 93.19,103.18 93.71,103.18 93.85,103.33 93.85,103.92 93.73,104.05 91.86,104.05 91.62,104.28 91.62,105.67 91.83,105.89 92.62,105.89 92.83,105.67 92.83,105.24 92.96,105.1 93.83,105.1 93.96,105.23 93.96,105.6 94.2,105.84 94.68,105.84 94.91,105.6 94.91,104.51 95.04,104.38 95.3,104.38 95.43,104.51 95.43,105.6 95.67,105.84 96.15,105.84 96.39,105.6 96.39,103.72 95.99,103.32 95.26,103.32 94.94,103 94.94,101.96 94.53,101.55 94.53,101.14 93.8,100.4 93.16,100.4 93.04,100.29 93.04,99.82 93.19,99.67 93.19,99.02 93.05,98.87 93.05,95.4 92.84,95.18 92.24,95.18 91.9,95.52 91.9,97.45 91.71,97.64 91.35,97.64 91.07,97.37 91.07,95.61 90.87,95.41 89.96,95.41 89.64,95.73 89.64,97.39 89.39,97.64 88.91,97.64 88.75,97.49 88.75,94.89 88.92,94.72 90.97,94.72 91.51,94.18 91.51,93.68 91.24,93.41 90.64,93.41 90.48,93.25 90.48,93.03 90.64,92.87 91.24,92.87 91.51,92.61 91.51,92.23 91.24,91.96 90.67,91.96 90.52,91.8 90.52,91.58 90.67,91.43 91.24,91.43 91.51,91.16 91.51,90.78 91.24,90.51 90.7,90.51 90.55,90.36 90.55,90.14 90.7,89.98 91.24,89.98 91.51,89.71 91.51,89.33 91.24,89.06 90.77,89.06 90.62,88.91 90.62,88.69 90.77,88.53 91.28,88.53 91.51,88.3 91.51,86.18 93.43,84.25 93.43,82.57
DDR4_DIMM2_DQ0: length 66.3
  L12_SIG4 w0.089: v1(86.63,73.43) 86.63,73.11 86.04,72.52 85.69,72.52 85.28,72.93 84.87,72.93 84.43,73.37 84.16,73.37 83.64,73.9 83.34,73.9 82.88,74.36 82.48,74.36 82.01,74.82 81.66,74.82 81.25,75.24 80.9,75.24 80.47,75.67 80.21,75.67 79.65,76.24 79.26,76.24 78.86,76.64 78.86,78.29 78.37,78.78 78.37,87.46 72.79,93.04 68.65,93.04 64.88,96.8 62.03,96.8 61.88,96.96 61.88,97.18 62.03,97.34 64.94,97.34 65.1,97.49 65.1,97.71 64.94,97.87 61.13,97.87 60.15,96.89 56.98,96.89 56.82,97.05 56.82,97.28 56.98,97.44 59.62,97.44 59.78,97.6 59.78,97.82 59.62,97.98 56.14,97.98 55.15,98.97 54.77,98.97 53.91,99.84 53.91,101.19 v1(53.49,101.6)
DDR4_DIMM2_DQ1: length 66
  L12_SIG4 w0.089: v1(85.83,73.89) 85.83,74.15 85.16,74.82 84.9,74.82 84.65,75.08 84.65,82.43 80.39,86.69 80.39,88.21 75.49,93.11 75.49,93.95 73.9,95.54 73.9,98.58 72.61,99.87 72.61,100.13 72.36,100.38 59.26,100.38 58.17,101.46 58.17,102.31 57.64,102.84 55.89,102.84 55.69,103.05 55.69,103.39 55.49,103.59 55.17,103.59 54.97,103.39 54.97,103.05 54.76,102.84 54.19,102.84 53.99,103.05 53.99,103.86 53.79,104.06 53.47,104.06 53.27,103.86 53.27,103.05 53.06,102.84 52.43,102.84 52.23,103.05 52.23,104.78 52.43,104.98 53.86,104.98 54.06,105.19 54.06,105.5 53.86,105.71 52.43,105.71 52.23,105.91 52.23,106.31 52.48,106.56 53.3,106.56 v1(54.34,107.6)
DDR4_DIMM2_DQ2: length 70.3
  L12_SIG4 w0.089: v1(85.83,74.81) 85.45,75.19 85.45,82.88 81.1,87.24 81.1,88.47 76.91,92.66 76.91,94.36 74.89,96.38 74.89,98.52 74.32,99.09 74.32,100.8 74.08,101.05 72,101.05 71.77,101.28 71.77,103.59 71.48,103.88 71.03,103.88 70.88,103.73 70.88,101.12 70.72,100.97 70.24,100.97 70.09,101.12 70.09,103.39 69.94,103.54 69.35,103.54 69.2,103.39 69.2,101.13 69.05,100.97 68.56,100.97 68.41,101.13 68.41,102.72 68.26,102.87 67.69,102.87 67.49,102.67 67.49,101.18 67.28,100.97 66.89,100.97 66.68,101.18 66.68,102.6 66.48,102.8 65.29,102.8 65.09,102.6 65.09,102.2 64.89,102 64.57,102 64.36,102.2 64.36,102.6 64.16,102.8 63.49,102.8 63.28,102.6 63.28,101.15 63.08,100.95 62.64,100.95 62.44,101.15 62.44,102.6 62.25,102.79 61.77,102.79 61.58,102.6 61.58,101.12 61.38,100.92 60.91,100.92 60.7,101.12 60.7,103.02 60.5,103.22 59.66,103.22 59.44,103 v1(59.44,101.6)
DDR4_DIMM2_DQ3: length 70.3
  L12_SIG4 w0.089: v1(60.29,107.6) 60.7,107.19 66.51,107.19 66.67,107.04 66.67,106.8 66.51,106.64 65.18,106.64 65.02,106.48 65.02,106.19 65.18,106.03 69.24,106.03 69.39,106.19 69.39,106.42 69.24,106.57 67.7,106.57 67.54,106.73 67.54,106.96 67.7,107.12 71.8,107.12 71.96,106.96 71.96,106.7 71.8,106.55 70.45,106.55 70.3,106.39 70.3,106.12 70.45,105.96 72.19,105.96 72.92,106.68 73.26,106.68 76.51,103.44 76.51,103.22 76.38,103.09 76.16,103.09 74.04,105.21 73.82,105.21 73.67,105.06 73.67,104.84 76.2,102.31 76.44,102.31 76.87,101.87 76.87,97.27 79.45,94.69 79.45,92.6 84.01,88.04 84.01,86.32 87.04,83.3 87.04,75.87 86.86,75.7 86.86,75.5 v1(86.63,75.27)
DDR4_DIMM2_DQ4: length 68.7
  L12_SIG4 w0.089: v1(51.79,101.6) 52.23,101.17 52.23,99.51 53.51,98.23 53.87,98.23 56.33,95.78 57.27,95.78 57.53,95.52 57.53,94.64 57.69,94.48 58.29,94.48 58.44,94.64 58.44,95.22 58.59,95.38 58.88,95.38 59.04,95.22 59.04,94.64 59.19,94.48 63.08,94.48 63.41,94.15 63.41,93.16 63.75,92.82 66.19,92.82 66.34,92.67 66.34,92.45 66.19,92.29 63.5,92.29 63.34,92.13 63.34,91.91 63.5,91.76 72.68,91.76 76.86,87.58 76.86,78.47 77.64,77.69 77.64,75.96 79.2,74.4 79.65,74.4 80.21,73.83 80.47,73.83 80.9,73.4 81.25,73.4 81.66,72.98 82.01,72.98 82.48,72.52 82.88,72.52 83.34,72.06 83.64,72.06 84.16,71.53 84.43,71.53 84.87,71.09 85.28,71.09 85.67,70.69 86.04,70.69 86.47,71.12 86.8,71.12 87.28,71.61 87.64,71.61 88.09,72.06 88.42,72.06 88.91,72.55 89.19,72.55 89.42,72.77 89.42,73.49 v1(89.02,73.89)
DDR4_DIMM2_DQ5: length 68.7
  L12_SIG4 w0.089: v1(89.82,73.43) 90.24,73.01 90.24,72.32 90,72.09 89.64,72.09 89.19,71.63 88.88,71.63 88.37,71.12 88.07,71.12 87.61,70.67 87.23,70.67 86.82,70.26 86.52,70.26 86,69.74 85.71,69.74 85.28,70.17 84.87,70.17 84.43,70.61 84.16,70.61 83.64,71.14 83.34,71.14 82.88,71.6 82.48,71.6 82.01,72.06 81.66,72.06 81.25,72.48 80.9,72.48 80.47,72.91 80.21,72.91 79.65,73.48 79.3,73.48 77.04,75.74 77.04,77.34 76.15,78.23 76.15,87.67 72.57,91.25 63.08,91.25 61.31,93.02 57.64,93.02 51.72,98.94 51.37,99.79 51.37,101.86 51.56,102.05 51.56,106.52 v1(52.64,107.6)
DDR4_DIMM2_DQ6: length 68.4
  L12_SIG4 w0.089: v1(57.74,101.6) 57.16,102.19 53.47,102.19 53.04,101.76 53.04,99.71 54.18,98.57 54.91,98.57 55.47,98.01 55.47,97.47 56.68,96.26 59.02,96.26 59.44,95.84 61.35,95.84 61.69,96.18 63.99,96.18 64.15,96.03 64.15,95.81 63.99,95.65 62.08,95.65 61.92,95.49 61.92,95.27 62.08,95.12 64.96,95.12 67.82,92.26 72.86,92.26 77.51,87.61 77.51,78.94 78.22,78.23 78.22,76.27 79.17,75.32 79.65,75.32 80.21,74.75 80.47,74.75 80.9,74.32 81.25,74.32 81.66,73.9 82.01,73.9 82.48,73.44 82.88,73.44 83.34,72.98 83.64,72.98 84.16,72.45 84.43,72.45 84.87,72.01 85.28,72.01 85.69,71.6 86.01,71.6 86.47,72.06 86.82,72.06 87.31,72.55 87.66,72.55 88.07,72.95 88.33,72.95 88.63,73.26 88.63,74.41 v1(89.02,74.81)
DDR4_DIMM2_DQ7: length 68.6
  L12_SIG4 w0.089: v1(89.82,75.27) 88.88,75.27 88.4,75.75 88.02,75.75 87.82,75.94 87.82,83.16 84.71,86.27 84.71,88.03 80.29,92.45 80.29,95.23 77.71,97.8 77.71,98.76 77.84,98.9 78.02,98.9 78.16,98.76 78.16,98.16 78.29,98.03 78.47,98.03 78.6,98.16 78.6,103.19 77.78,104.01 77.59,104.01 77.46,103.88 77.46,103.7 78.06,103.1 78.06,102.92 77.93,102.79 77.74,102.79 75.88,104.65 75.88,104.84 76.01,104.97 76.19,104.97 76.92,104.24 77.1,104.24 77.23,104.37 77.23,104.55 74.77,107.01 74.59,107.01 74.46,106.88 74.46,106.7 75.57,105.59 75.57,105.41 75.44,105.28 75.25,105.28 73.48,107.05 73.48,107.89 73.28,108.09 59.08,108.09 v1(58.59,107.6)
DDR4_DIMM2_DQ8: length 65.4
  L14_SIG5 w0.081: v1(87.43,78.49) 87.13,78.19 87.13,77.93 86.75,77.55 86.44,77.55 85.97,77.07 85.56,77.07 85.43,77.21 85.43,80.06 85.17,80.32 84.89,80.32 84.45,80.76 84.15,80.76 83.63,81.28 83.28,81.28 82.88,81.67 82.38,81.67 81.99,81.28 81.55,81.28 81.15,81.68 80.81,81.68 80.41,81.28 80.03,81.28 79.57,81.74 79.08,81.74 75.68,85.15 75.68,87.51 72.26,90.93 67.2,90.93 65.42,92.71 63.49,92.71 62.68,93.52 58.38,93.52 58.18,93.71 58.18,95.09 57.99,95.29 57.52,95.29 57.3,95.51 57.3,95.84 57.17,95.98 56.21,95.98 56.08,96.11 56.08,96.31 56.21,96.44 57.17,96.44 57.3,96.58 57.3,96.77 57.17,96.9 56.21,96.9 56.08,97.04 56.08,97.23 56.21,97.37 57.67,97.37 57.81,97.5 57.81,97.69 57.67,97.83 56.21,97.83 56.08,97.96 56.08,98.16 56.21,98.29 57.85,98.29 57.99,98.43 57.99,98.62 57.85,98.75 56.21,98.75 56.08,98.89 56.08,99.08 56.21,99.22 57.17,99.22 57.45,99.49 58.77,99.49 59.18,99.9 59.71,99.9 60.16,99.45 62.02,99.45 62.38,99.8 62.38,100.55 62.84,101.02 v1(62.84,101.6)
DDR4_DIMM2_DQ9: length 63.4
  L14_SIG5 w0.081: v1(63.69,107.6) 63.69,107.13 63.32,106.75 63.17,106.75 62.92,107 62.92,107.14 63.22,107.44 63.22,108.11 63.53,108.42 67.04,108.42 67.54,107.91 67.54,107.42 67.93,107.04 67.93,104.79 67.8,104.67 67.64,104.67 67.52,104.79 67.52,106.64 67.39,106.77 67.22,106.77 67.1,106.64 67.1,102.42 67.22,102.29 67.43,102.29 67.56,102.42 67.56,103.97 67.69,104.09 67.89,104.09 68.02,103.97 68.02,102.29 67.52,101.79 67.52,96.39 67.63,96.27 69.13,96.27 69.25,96.16 69.25,95.87 69.13,95.76 67.63,95.76 67.52,95.65 67.52,95.25 67.67,95.11 68.12,95.11 68.41,94.82 68.41,93.14 68.58,92.97 72.83,92.97 77.96,87.85 77.96,85.9 79.9,83.96 85.83,83.96 87.24,82.55 87.58,82.55 87.84,82.29 87.84,79.82 v1(87.43,79.41)
DDR4_DIMM2_DQ10: length 63.6
  L14_SIG5 w0.081: v1(68.79,101.6) 68.45,101.6 68.31,101.45 68.31,100.48 68.44,100.36 68.64,100.36 68.77,100.48 68.77,100.99 68.9,101.12 69.11,101.12 69.23,100.99 69.23,99.8 69.6,99.44 69.6,97.17 69.49,97.06 69.33,97.06 69.21,97.17 69.21,99.32 69.1,99.44 68.94,99.44 68.83,99.32 68.83,97.18 68.71,97.07 68.55,97.07 68.44,97.18 68.44,99.54 68.33,99.65 68.17,99.65 68.06,99.54 68.06,96.78 68.17,96.66 69.49,96.66 69.6,96.55 69.6,96.05 69.74,95.91 70.42,95.91 70.55,95.78 70.55,95.46 70.44,95.35 68.9,95.35 68.81,95.26 68.81,94.96 68.9,94.87 71.47,94.87 71.6,94.74 71.6,94.5 71.47,94.38 69.31,94.38 69.17,94.23 69.17,93.61 69.31,93.47 72.86,93.47 78.39,87.94 78.39,86.17 80.21,84.36 80.39,84.36 80.54,84.5 80.54,84.68 78.85,86.37 78.85,86.55 79,86.7 79.18,86.7 81.57,84.3 85.97,84.3 87.31,82.96 87.8,82.96 88.6,82.16 88.6,80.25 v1(88.22,79.87)
DDR4_DIMM2_DQ11: length 65.5
  L14_SIG5 w0.081: v1(69.64,107.6) 69.64,108.04 69.54,108.14 68.98,108.14 68.83,108.28 68.83,108.55 68.96,108.68 70.85,108.68 70.98,108.54 70.98,108.28 70.85,108.15 70.23,108.15 70.12,108.03 70.12,105.73 69.99,105.6 69.78,105.6 69.65,105.73 69.65,107.08 69.52,107.21 69.32,107.21 69.19,107.08 69.19,105.9 69.06,105.77 68.85,105.77 68.73,105.9 68.73,106.99 68.6,107.11 68.39,107.11 68.26,106.99 68.26,105.36 68.54,105.09 69.32,105.09 69.41,105 69.41,104.7 69.32,104.61 68.72,104.61 68.5,104.39 68.5,102.2 68.63,102.07 68.84,102.07 68.96,102.2 68.96,103.68 69.09,103.81 69.3,103.81 69.43,103.68 69.43,102.41 69.55,102.28 69.76,102.28 69.89,102.41 69.89,104.63 70.01,104.76 70.22,104.76 70.35,104.63 70.35,102.07 70.06,101.78 70.06,96.87 80.01,86.92 80.01,86.54 81.81,84.74 86.03,84.74 87.44,83.34 88.02,83.34 88.8,82.55 89.18,82.55 89.42,82.31 89.42,79.23 89.14,78.95 88.78,78.95 88.22,78.39 v1(88.22,78.03)
DDR4_DIMM2_DQ12: length 72
  L14_SIG5 w0.081: v1(61.14,101.6) 60.51,102.23 58.52,102.23 58.35,102.41 58.35,102.87 58.48,103.01 58.87,103.01 59,103.15 59,103.6 58.87,103.74 58.48,103.74 58.35,103.87 58.35,105.94 58.17,106.11 57.93,106.11 57.76,105.94 57.76,102.33 57.61,102.18 57.27,102.18 57.1,102.36 57.1,103.09 56.93,103.26 56.68,103.26 56.51,103.09 56.51,102.36 56.34,102.18 56.09,102.18 55.92,102.36 55.92,103.61 55.75,103.78 55.5,103.78 55.33,103.61 55.33,102.36 55.16,102.18 54.78,102.18 54.62,102.35 54.62,103.09 54.44,103.26 54.14,103.26 53.96,103.09 53.96,99.23 53.36,98.63 53.36,96.06 54.76,94.65 54.76,93.86 54.91,93.72 arc(55.04,93.63) 55.19,93.6 56.29,93.6 57.5,92.4 62.15,92.4 64.16,90.38 64.16,85.86 66.47,83.55 66.47,82.1 67.64,80.93 70.56,80.93 71.28,81.65 76.6,81.65 79.3,78.95 79.6,78.95 80.07,78.49 80.36,78.49 80.75,78.88 81.26,78.88 81.65,78.49 82,78.49 82.38,78.87 82.89,78.87 83.27,78.49 v1(84.24,78.49)
DDR4_DIMM2_DQ13: length 72
  L14_SIG5 w0.081: v1(85.04,78.03) 84.13,78.03 83.71,77.61 83.28,77.61 82.86,78.03 82.47,78.03 82.09,77.64 81.52,77.64 81.13,78.03 80.81,78.03 80.43,77.65 80.09,77.65 79.66,78.08 79.33,78.08 78.82,78.6 78.82,78.87 76.51,81.18 71.79,81.18 70.44,79.83 68.84,79.83 68.1,80.57 67.42,80.57 65.94,82.05 65.94,83.57 63.78,85.73 63.78,90.19 62.01,91.97 57.27,91.97 55.99,93.25 55.18,93.25 arc(54.92,93.3) 54.69,93.45 53.98,94.16 53.98,94.32 52.87,95.43 52.87,99.37 53.12,99.62 53.12,106.81 53.45,107.14 56.11,107.14 56.42,106.83 56.42,103.94 56.65,103.71 56.9,103.71 57.14,103.94 57.14,106.63 57.34,106.83 61.22,106.83 v1(61.99,107.6)
DDR4_DIMM2_DQ14: length 72.1
  L14_SIG5 w0.081: v1(85.04,79.87) 84.04,79.87 83.58,80.33 83.24,80.33 82.82,80.75 82.34,80.75 81.92,80.33 81.71,80.33 81.28,80.75 80.84,80.75 80.42,80.33 79.99,80.33 79.52,80.8 79.03,80.8 77.41,82.42 69,82.42 65.7,85.72 65.7,90.09 65.52,90.28 65.21,90.28 65.07,90.42 65.07,90.79 65.2,90.92 65.81,90.92 65.95,91.06 65.95,91.27 65.81,91.41 65.2,91.41 65.07,91.55 65.07,92.19 64.93,92.33 64.64,92.33 64.51,92.19 64.51,91.74 64.37,91.61 64.18,91.61 64.04,91.74 64.04,92.19 63.91,92.33 63.34,92.33 62.51,93.16 57.8,93.16 57.18,93.78 57.18,94.13 57.29,94.25 57.29,94.81 57.04,95.06 56.05,95.06 55.74,95.37 55.74,99.61 55.47,99.88 55.47,100.19 55.74,100.47 61.69,100.47 62.43,101.21 62.43,103.26 64.1,104.93 64.1,107.81 64.35,108.05 66.38,108.05 66.66,107.78 66.66,102.04 v1(67.09,101.6)
DDR4_DIMM2_DQ15: length 72.5
  L14_SIG5 w0.081: v1(67.94,107.6) 67.94,108.09 67.28,108.75 63.39,108.75 62.42,107.78 62.42,107.41 61.34,106.34 58.99,106.34 58.84,106.18 58.84,105.7 58.99,105.55 60.74,105.55 61.08,105.21 61.08,103.55 60.79,103.26 59.84,103.26 59.7,103.13 59.7,102.83 59.84,102.69 61.45,102.69 61.59,102.56 61.59,101.4 61.21,101.02 55.46,101.02 54.81,100.37 54.81,98.87 55.18,98.5 55.18,94.94 55.7,94.42 56.44,94.42 56.65,94.21 56.65,93.73 57.58,92.8 62.32,92.8 64.63,90.49 64.63,86.11 68.71,82.03 77.15,82.03 79.35,79.83 79.64,79.83 80.06,79.41 80.45,79.41 80.84,79.8 81.28,79.8 81.67,79.41 82.09,79.41 82.47,79.79 82.93,79.79 83.31,79.41 v1(84.24,79.41)
DDR4_DIMM2_DQ16: length 75
  L05_SIG2 w0.081: v1(72.19,101.6) 71.82,101.22 71.59,101.22 71.34,100.97 71.34,100.52 71.18,100.36 70.72,100.36 70.56,100.52 70.56,100.87 70.43,100.99 70.16,100.99 70.03,100.87 70.03,99.25 69.89,99.11 68.88,99.11 68.77,99.22 68.77,99.47 68.88,99.58 69.13,99.58 69.22,99.68 69.22,101.03 69.07,101.19 68.53,101.19 68.39,101.04 68.39,100.46 68.27,100.34 68.02,100.34 67.91,100.46 67.91,101.04 67.79,101.15 67.54,101.15 67.43,101.04 67.43,99.98 67.3,99.85 67.12,99.85 66.99,99.98 66.99,101.08 66.86,101.21 66.63,101.21 66.5,101.08 66.5,100.6 66.33,100.43 64.62,100.43 64.46,100.6 64.46,100.92 64.62,101.08 65.82,101.08 66.13,101.39 66.13,101.63 65.8,101.96 65.8,102.64 65.67,102.78 65.48,102.78 65.35,102.64 65.35,102.14 65.21,102 65,102 64.86,102.14 64.86,102.64 64.73,102.78 64.47,102.78 64.3,102.61 64.3,102.12 63.78,101.6 63.78,100.64 63.28,100.14 63.28,99.54 62.98,99.24 62.98,94.48 63.27,94.19 63.27,91.6 64.25,90.62 65.12,90.62 65.29,90.46 65.29,89.24 65.36,89.16 65.67,89.16 65.79,89.28 65.79,90.57 65.92,90.7 66.22,90.7 66.32,90.6 66.32,85.19 67.22,84.29 67.22,83.75 68.52,82.44 70.25,82.44 71.24,81.46 72.8,81.46 75.3,78.96 75.3,77.85 76.97,76.18 76.97,75.67 77.53,75.11 77.53,73.94 79.01,72.46 79.65,72.46 80.02,72.08 80.52,72.08 80.93,72.5 81.3,72.5 81.71,72.91 82.01,72.91 82.42,72.51 82.81,72.51 83.26,72.95 83.58,72.95 83.85,73.22 83.85,74.42 v1(84.24,74.81)
DDR4_DIMM2_DQ17: length 74.7
  L05_SIG2 w0.081: v1(73.04,107.6) 72.61,107.17 70.64,107.17 70.23,106.76 66.99,106.76 66.63,107.12 65.56,107.12 65.44,106.99 65.44,105.64 61.6,101.81 61.6,101.4 60.76,100.56 60.76,99.44 60.61,99.29 60.61,98.83 60.38,98.61 58.34,98.61 58.07,98.34 58.07,95.98 58.34,95.71 60.36,95.71 60.61,95.46 60.61,94.49 60.76,94.34 60.76,91.34 64.27,87.84 64.27,85.35 65.94,83.67 65.94,81.8 67.99,79.76 69.05,79.76 69.61,79.21 69.61,78.26 70.82,77.04 72.15,77.04 73.95,75.25 73.95,74.12 78.26,69.8 78.26,69.59 78.57,69.29 78.85,69.29 79.28,68.86 79.58,68.86 80.05,69.33 80.5,69.33 80.96,69.8 81.22,69.8 81.68,70.26 82.04,70.26 82.5,69.8 82.8,69.8 83.23,70.22 83.57,70.22 84.03,70.68 84.37,70.68 84.8,71.12 85.27,71.12 85.73,71.57 86,71.57 86.24,71.82 86.24,73.16 86,73.4 85.74,73.4 85.42,73.72 85.42,74.88 v1(85.04,75.27)
DDR4_DIMM2_DQ18: length 71
  L05_SIG2 w0.081: v1(84.24,73.89) 84.62,73.51 84.62,72.8 84.3,72.48 84.03,72.48 83.59,72.03 83.33,72.03 82.87,71.58 82.49,71.58 82.07,72.01 81.61,72.01 81.18,71.58 80.9,71.58 80.46,71.14 80.03,71.14 79.56,71.61 78.67,71.61 77.71,72.57 77.71,73.17 77.12,73.75 77.12,74.99 76.59,75.52 76.59,76.02 74.86,77.75 74.12,77.75 73.13,78.74 73.13,80.51 72.71,80.93 71.13,80.93 70,82.06 68.33,82.06 66.81,83.58 66.81,84.14 65.75,85.2 65.75,87.9 62.89,90.76 62.89,92.94 62.39,93.44 62.39,100.37 63.29,101.27 63.29,102.28 64.21,103.19 67.03,103.19 67.31,103.47 67.31,104.96 67.45,105.1 67.64,105.1 67.78,104.96 67.78,103.47 67.91,103.34 68.1,103.34 68.24,103.47 68.24,104.96 68.37,105.1 68.57,105.1 68.7,104.96 68.7,103.47 68.84,103.34 76.1,103.34 77.83,101.6 v1(78.14,101.6)
DDR4_DIMM2_DQ19: length 71.6
  L05_SIG2 w0.081: v1(78.99,107.6) 78.53,108.07 77.64,108.07 77.3,108.41 73.62,108.41 73.46,108.25 73.46,106.94 73.25,106.73 71.57,106.73 71.12,106.28 67.31,106.28 66.78,105.75 66.78,104.44 66.45,104.1 64.54,104.1 62.39,101.96 62.39,101.36 61.58,100.54 61.58,91.41 65.26,87.73 65.26,84.94 66.38,83.82 66.38,83.37 68.82,80.93 70.35,80.93 71.66,79.62 71.66,78.9 75.7,74.86 75.7,72.88 77.5,71.07 78.92,71.07 79.05,70.94 79.05,69.95 79.27,69.74 79.72,69.74 80.17,70.19 80.46,70.19 80.97,70.7 81.23,70.7 81.6,71.08 82,71.08 82.38,70.7 82.85,70.7 83.29,71.14 83.62,71.14 84.1,71.61 84.42,71.61 84.85,72.04 85.17,72.04 85.42,72.29 85.42,73.05 v1(85.04,73.43)
DDR4_DIMM2_DQ20: length 70.6
  L05_SIG2 w0.081: v1(81.85,74.35) 81.85,74.63 81.74,74.74 81.59,74.74 81.2,74.35 80.89,74.35 80.51,73.97 79.95,73.97 79.57,74.35 79.2,74.35 78.69,74.86 78.69,75.51 78.11,76.09 78.11,76.66 76.77,78.01 76.77,88.4 72.91,92.26 65.16,92.26 64.93,92.49 64.93,93.02 65.19,93.27 70.71,93.27 70.96,93.52 70.96,94.19 70.78,94.36 70.78,94.96 70.92,95.09 71.98,95.09 72.12,95.23 72.12,95.42 71.98,95.56 70.92,95.56 70.78,95.69 70.78,95.88 70.92,96.02 71.98,96.02 72.12,96.15 72.12,96.35 71.98,96.48 70.81,96.48 70.67,96.62 70.67,96.81 70.81,96.94 71.98,96.94 72.12,97.08 72.12,97.27 71.98,97.41 71.39,97.41 71.26,97.53 71.26,97.79 71.43,97.96 72.07,97.96 72.46,98.35 73.44,98.35 73.58,98.49 73.58,98.68 73.44,98.82 72.78,98.82 72.64,98.95 72.64,99.26 72.81,99.43 75.84,99.43 76.13,99.73 76.13,101.04 74.31,102.87 68.6,102.87 68.48,102.75 68.48,102.27 68.6,102.14 70.33,102.14 70.49,101.98 v1(70.49,101.6)
DDR4_DIMM2_DQ21: length 70
  L05_SIG2 w0.081: v1(71.34,107.6) 70.48,108.46 62.39,108.46 62.2,108.65 62.2,109.56 62.43,109.79 83.14,109.79 83.68,109.25 83.68,107.38 83.92,107.13 83.92,105.9 83.63,105.61 83.63,105.09 82.56,104.02 82.56,103.36 81.16,101.96 81.16,101.15 80.25,100.24 80.25,97.01 79.92,96.68 79.92,94.5 80.23,94.19 80.23,93.62 79.94,93.34 79.94,86.57 78.54,85.18 78.54,78.84 80.33,77.06 81.5,77.06 81.85,76.71 v1(81.85,76.19)
DDR4_DIMM2_DQ22: length 70.7
  L05_SIG2 w0.081: v1(76.44,101.59) 77.76,100.27 77.76,99.06 77.59,98.9 74.99,98.9 74.9,98.81 74.9,98.59 74.99,98.5 76.57,98.5 76.69,98.38 76.69,98.19 76.58,98.08 74,98.08 73.9,97.98 73.9,97.47 73.76,97.34 72.65,97.34 72.52,97.2 72.52,97.01 72.65,96.87 73.67,96.87 73.8,96.74 73.8,96.55 73.67,96.41 72.63,96.41 72.49,96.28 72.49,96.08 72.63,95.95 74.21,95.95 74.35,95.81 74.35,95.62 74.21,95.49 72.61,95.49 72.47,95.35 72.47,95.16 72.61,95.02 73.76,95.02 73.9,94.89 73.9,94.63 73.39,94.13 73.39,93.74 73.58,93.55 74.21,93.55 74.35,93.41 74.35,93.19 74.21,93.06 73.43,93.06 73.29,92.92 73.29,92.73 73.43,92.6 74.21,92.6 74.35,92.46 74.35,91.54 74.48,91.4 74.67,91.4 74.81,91.54 74.81,92.5 74.94,92.64 75.14,92.64 75.27,92.5 75.27,90.39 75.41,90.26 75.6,90.26 75.73,90.39 75.73,92.33 75.87,92.46 76.06,92.46 76.2,92.33 76.2,89.61 76.33,89.48 76.52,89.48 76.66,89.61 76.66,92.24 76.79,92.37 76.98,92.37 77.12,92.24 77.12,88.85 77.26,88.72 77.45,88.72 77.58,88.85 77.58,92.24 77.72,92.37 78.02,92.37 78.12,92.27 78.12,87.94 77.1,86.92 77.1,78.18 78.47,76.81 78.47,76.21 79.05,75.63 79.05,75.44 79.25,75.24 79.66,75.24 80.09,74.81 v1(81.05,74.81)
DDR4_DIMM2_DQ23: length 70.1
  L05_SIG2 w0.081: v1(77.29,107.6) 77.77,107.12 79.3,107.12 79.45,107.27 79.45,107.88 79.57,108.01 81.36,108.01 81.49,108.13 81.49,108.35 81.38,108.46 78.49,108.46 78.34,108.61 78.34,108.86 78.5,109.02 81.64,109.02 81.96,108.7 81.96,107.35 82.12,107.19 82.98,107.19 83.17,107 83.17,105.94 82.94,105.71 82.94,105.42 82.51,104.98 82.51,104.73 82.42,104.64 81.85,104.64 81.76,104.73 81.76,105.72 82.12,106.09 82.12,106.56 82,106.68 79.48,106.68 79.37,106.57 79.37,106.26 79.51,106.12 80.52,106.12 80.66,105.99 80.66,105.8 80.52,105.66 79.51,105.66 79.37,105.53 79.37,105.34 79.51,105.2 80.52,105.2 80.66,105.06 80.66,104.87 80.52,104.74 78.86,104.74 78.73,104.6 78.73,104.41 78.86,104.28 80.52,104.28 80.66,104.14 80.66,103.95 80.52,103.81 79.1,103.81 78.96,103.68 78.96,103.41 79.11,103.26 80.68,103.26 81.41,103.99 81.6,103.99 81.82,103.78 81.82,103.59 80.88,102.65 79.61,102.65 79.41,102.45 79.41,86.98 78.21,85.78 78.21,78.7 80.3,76.61 80.5,76.61 81.05,76.06 v1(81.05,75.73)
DDR4_DIMM2_DQ24: length 63.3
  L16_SIG6 w0.081: v1(81.54,101.6) 81.02,102.12 79.56,102.12 79.03,102.66 74.16,102.66 73.92,102.9 73.92,103.37 74.66,104.1 80.15,104.1 80.8,103.46 81.86,103.46 82.67,102.64 85.45,102.64 86.19,101.91 86.19,101.25 85.86,100.92 84.32,100.92 83.68,100.28 83.68,99.81 83.46,99.59 78.81,99.59 78.64,99.42 78.64,99.14 78.77,99.01 80.42,99.01 80.56,98.87 80.56,98.69 80.42,98.56 78.77,98.56 78.63,98.42 78.63,95.74 79.38,94.99 79.38,91.14 79.79,90.73 80.89,90.73 81.55,90.07 81.55,82.59 82.42,81.72 82.78,81.72 83.07,81.44 83.07,76.91 83.32,76.66 83.62,76.66 84.08,76.2 84.41,76.2 84.89,75.73 v1(85.83,75.73)
DDR4_DIMM2_DQ25: length 63.5
  L16_SIG6 w0.081: v1(82.39,107.6) 81.4,106.61 77.12,106.61 76.67,106.16 76.67,104.87 77.09,104.45 80.65,104.45 81.28,103.82 82,103.82 82.79,103.03 85.74,103.03 86.04,102.73 86.81,102.73 87.08,102.47 87.08,102.01 86.62,101.55 86.62,101.17 85.99,100.54 85.57,100.54 85.33,100.3 85.33,99.81 85.08,99.56 84.14,99.56 83.78,99.21 81.78,99.21 80.65,98.08 79.18,98.08 79.02,97.92 79.02,97.15 79.16,97.01 79.77,97.01 79.91,96.88 79.91,96.61 79.77,96.48 79.16,96.48 79.02,96.34 79.02,96.02 79.82,95.22 79.82,94.68 80.32,94.18 80.32,93.86 79.74,93.27 79.74,91.36 80.02,91.08 81.13,91.08 81.95,90.26 81.95,88.61 82.62,87.94 82.62,86.59 82.33,86.3 82.09,86.3 81.92,86.13 81.92,85.95 82.06,85.81 82.39,85.81 82.52,85.68 82.52,85.49 82.39,85.35 82.06,85.35 81.92,85.22 81.92,85.02 82.06,84.89 82.39,84.89 82.52,84.75 82.52,84.56 82.39,84.43 82.06,84.43 81.92,84.29 81.92,84.1 82.06,83.96 82.39,83.96 82.52,83.83 82.52,83.64 82.39,83.5 82.06,83.5 81.92,83.37 81.92,82.86 82.2,82.59 82.55,82.59 82.69,82.72 82.69,83.16 82.82,83.3 83.01,83.3 83.15,83.16 83.15,82.72 83.28,82.59 83.62,82.59 83.83,82.38 83.83,77.32 84.06,77.09 84.39,77.09 84.87,76.61 85.25,76.61 85.67,76.19 v1(86.63,76.19)
