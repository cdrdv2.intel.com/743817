# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_DQ31: length 57.3
  L12_SIG4 w0.089: v1(122.48,44.45) 122.94,44.45 123.71,43.69 123.71,41.1 124.09,40.72 124.47,40.72 124.8,40.39 124.8,39.32 124.92,39.19 125.14,39.19 125.27,39.32 125.27,40.34 125.39,40.46 125.61,40.46 125.74,40.34 125.74,32.82 122.97,30.05 114.43,30.05 114.08,30.41 97.83,30.41 95.5,28.08 91.28,28.08 90.78,27.58 90.78,24.56 v1(91.18,24.16)
DDR4_COMP_DQ32: length 44.2
  L14_SIG5 w0.081: v1(117.7,50.89) 117.7,50.6 118.33,49.98 118.68,49.98 119.12,49.53 119.44,49.53 119.9,49.07 120.29,49.07 120.75,49.53 121.02,49.53 121.5,49.06 121.88,49.06 122.33,49.51 122.72,49.51 126.74,45.49 126.74,35.99 123.14,32.4 123.14,30.42 123.03,30.3 122.26,30.3 122.17,30.22 122.17,29.98 122.26,29.89 123.21,29.89 123.3,29.8 123.3,29.6 123.21,29.51 121.88,29.51 121.79,29.42 121.79,29.2 121.9,29.08 123.23,29.08 123.35,28.97 123.35,28.81 123.23,28.7 121.92,28.7 121.8,28.58 121.8,28.42 121.92,28.31 123.23,28.31 123.35,28.2 123.35,28.04 123.23,27.92 121.82,27.92 121.7,27.81 121.7,26.34 121.89,26.15 123.36,26.15 v1(123.76,25.76)
DDR4_COMP_DQ33: length 38.7
  L14_SIG5 w0.081: v1(127.76,26.56) 127.96,26.56 128.36,26.96 128.76,26.96 128.93,27.13 128.93,27.49 130.14,28.7 130.14,28.86 130.04,28.95 129.88,28.95 128.66,27.73 128.5,27.73 128.39,27.84 128.39,28 130.16,29.77 130.16,30.08 129.89,30.35 129.89,30.67 130.16,30.93 130.16,31.35 129.94,31.56 129.94,32.02 130.08,32.15 130.08,46.85 123.87,53.06 123.69,53.06 123.43,52.8 123.12,52.8 122.92,53 122.92,53.14 122.78,53.27 122.26,53.27 122.12,53.13 122.12,52.89 122.02,52.79 121.5,52.79 121.4,52.68 121.4,52.56 v1(121.69,52.27)
DDR4_COMP_DQ34: length 39.2
  L14_SIG5 w0.081: v1(124.56,24.96) 126.02,24.96 126.14,24.84 126.14,24.49 126.24,24.39 126.47,24.39 126.58,24.5 126.58,25.24 126.47,25.35 126.29,25.35 126.18,25.47 126.18,25.63 126.29,25.74 126.46,25.74 126.58,25.85 126.58,26.01 126.46,26.13 126.3,26.13 126.18,26.24 126.18,26.46 126.3,26.58 126.46,26.58 126.58,26.69 126.58,26.88 126.46,26.99 126.31,26.99 126.19,27.11 126.19,27.27 126.28,27.36 126.47,27.36 126.59,27.48 126.59,27.91 127.71,29.03 127.71,30.2 127.59,30.31 127.42,30.31 127.3,30.2 127.3,29.45 127.19,29.34 126.99,29.34 126.88,29.45 126.88,30.8 126.99,30.91 127.48,30.91 127.59,31.02 127.59,32.04 127.7,32.16 128.39,32.16 128.51,32.27 128.51,46.49 123.65,51.35 v1(121.69,51.35)
DDR4_COMP_DQ35: length 44.4
  L14_SIG5 w0.081: v1(116.91,51.35) 116.51,51.75 116.51,52.61 116.7,52.81 117.01,52.81 117.31,52.5 117.31,52.28 117.41,52.18 117.99,52.18 118.36,51.82 118.63,51.82 119.12,52.3 119.53,52.3 119.87,52.64 119.87,52.77 119.76,52.89 119.76,53.04 119.96,53.24 120.11,53.24 120.33,53.01 120.52,53.01 120.68,53.18 121.03,53.18 121.46,53.61 121.81,53.61 121.92,53.72 121.92,54.02 122.09,54.19 122.51,54.19 123,53.7 123.89,53.7 130.56,47.02 130.56,28.84 129.94,27.35 129.56,26.96 129.16,26.96 128.96,26.76 128.96,26.36 128.76,26.16 128.36,26.16 128.16,25.96 128.16,25.56 127.76,25.16 v1(127.76,24.96)
DDR4_COMP_DQ36: length 39.1
  L14_SIG5 w0.081: v1(122.48,50.89) 122.59,51 123.43,51 124.49,49.94 124.49,49.64 128.06,46.08 128.06,32.98 127.87,32.79 127.35,32.79 127.25,32.69 127.25,31.37 127.14,31.25 126.98,31.25 126.87,31.37 126.87,32.66 126.75,32.78 126.59,32.78 126.48,32.66 126.48,29.45 125.49,28.46 125.49,28.3 125.6,28.18 125.76,28.18 126.61,29.03 126.77,29.03 126.89,28.92 126.89,28.76 125.79,27.66 125.79,25.59 125.56,25.36 123.42,25.36 123.33,25.27 123.33,25.05 123.42,24.96 v1(123.76,24.96)
DDR4_COMP_DQ37: length 41.6
  L14_SIG5 w0.081: v1(128.56,24.96) 129.14,25.29 129.24,25.33 129.46,25.4 129.59,25.45 129.7,25.57 129.81,25.83 129.94,26.03 130.13,26.21 130.32,26.46 131.28,28.78 131.28,47.71 123.76,55.23 123.36,55.4 123.2,55.4 122.86,55.26 122.81,55.21 122.59,55.12 122.38,55.12 122.2,55.19 122.13,55.26 121.79,55.4 121.51,55.4 118.24,53.46 v1(117.7,52.73)
DDR4_COMP_DQ38: length 38.2
  L14_SIG5 w0.081: v1(122.48,52.73) 122.55,52.66 122.76,52.66 122.97,52.45 123.84,52.45 129.53,46.76 129.53,29.63 127.94,28.04 127.94,27.74 128.16,27.53 128.16,27.16 127.96,26.96 127.56,26.96 127.36,26.76 127.36,25.94 127.24,25.82 127.07,25.82 126.95,25.71 126.95,25.55 127.07,25.44 127.24,25.44 127.36,25.33 127.36,23.68 127.11,23.44 126.39,23.44 125.78,24.06 125.78,24.39 125.57,24.59 124.99,24.59 v1(124.56,24.16)
DDR4_COMP_DQ39: length 41.4
  L14_SIG5 w0.081: v1(118.5,52.27) 118.81,52.58 118.81,52.94 119.51,53.64 120.2,53.64 120.72,54.16 121.12,54.16 121.51,54.55 123.77,54.55 130.91,47.41 130.91,28.79 130.01,26.61 129.56,26.16 129.16,26.16 128.96,25.96 128.96,25.56 128.76,25.36 128.36,25.36 128.16,25.16 128.16,24.56 v1(127.76,24.16)
DDR4_COMP_DQS_N0: length 74.8
  L12_SIG4 w0.076: 114.96,41.54 114.96,41.56 114.97,41.57 114.97,41.64 arc(114.96,41.67) 114.95,41.71 114.81,41.91 arc(114.74,42.15) 114.81,42.38 114.85,42.44 arc(114.9,42.59) 114.87,42.74 114.83,42.82 arc(114.76,43.07) 114.83,43.33 114.83,43.33 arc(115.03,43.54) 115.31,43.62 115.41,43.62 arc(115.48,43.64) 115.54,43.68 115.71,43.91 arc(115.74,43.96) 115.72,44.02 115.67,44.11 115.57,44.14 v1(115.31,43.99)
  L12_SIG4 w0.089: v1(75.79,26.56) 76.09,26.25 76.27,26.25 76.5,26.48 77.21,26.48 78.1,27.37 78.1,27.76 77.91,27.96 77.44,27.96 77.13,28.26 77.13,28.73 77.41,29.01 77.41,36.06 77.63,36.27 78.28,36.27 78.49,36.06 78.49,30.08 78.59,29.97 80.82,29.97 81.03,29.76 81.03,29.37 80.82,29.16 78.59,29.16 78.49,29.06 78.49,28.72 78.62,28.59 80.99,28.59 82.89,30.48 82.89,31.37 83.89,32.38 83.89,33.18 84.23,33.52 84.83,33.52 85.74,34.43 86.95,34.43 87.19,34.68 87.19,35.08 87.6,35.49 90.71,35.49 90.98,35.21 90.98,34.98 91.15,34.81 91.61,34.81 91.83,35.03 91.83,35.46 92.47,36.1 92.7,36.1 92.92,36.32 94.38,36.32 94.63,36.58 94.63,37.78 95.01,38.15 96,38.15 96.28,38.43 100.35,38.43 101.03,39.12 110.93,39.12 111.48,39.67 112.2,39.67 112.31,39.77 112.56,39.77 112.66,39.67 112.91,39.67 113.02,39.77 113.27,39.77 113.37,39.67 113.63,39.67 113.96,40 113.96,40.15 114.14,40.33 114.28,40.33 114.46,40.51 114.46,40.65 114.64,40.83 114.78,40.83 114.96,41.01 114.96,41.54
DDR4_COMP_DQS_N1: length 35.6
  L14_SIG5 w0.076: v1(120.09,46.75) 120.35,46.6 120.38,46.5 120.34,46.44 arc(120.31,46.32) 120.33,46.2 120.41,46.04 arc(120.59,45.82) 120.86,45.74 120.92,45.74 arc(121.07,45.7) 121.18,45.6 121.26,45.48 arc(121.42,45.33) 121.64,45.28 121.73,45.28 arc(121.86,45.24) 121.97,45.15 122.06,45.02 arc(122.22,44.87) 122.44,44.82 122.65,44.82 122.91,44.55 122.91,44.55 122.92,44.54
  L14_SIG5 w0.081: v1(112.36,26.56) 112.36,26.35 112.47,26.25 112.65,26.25 112.88,26.48 112.88,26.64 112.78,26.73 112.78,26.89 112.9,27.01 113.06,27.01 113.15,26.91 113.31,26.91 113.58,27.18 113.58,27.6 113.13,28.05 113.13,28.42 113.42,28.71 113.71,28.71 114.58,29.59 116.18,29.59 117.56,30.96 117.56,31.14 117.32,31.38 117.14,31.38 116.04,30.27 115.71,30.27 115.36,30.62 115.36,30.95 117.06,32.64 117.86,32.64 120.96,35.74 120.96,36.03 121.52,36.59 121.52,37.98 122.8,39.26 122.8,39.53 123.08,39.82 123.36,39.82 123.46,39.92 123.46,40.34 123.34,40.47 122.9,40.47 122.66,40.7 122.66,41.21 122.9,41.45 123.34,41.45 123.46,41.57 123.46,44 122.92,44.54
DDR4_COMP_DQS_N2: length 46.6
  L14_SIG5 w0.081: v1(116.91,42.15) 117.14,42.01 117.18,41.88 117.04,41.65 117.04,41.02 114.88,38.85 104.26,38.85 104.02,38.62 104.02,37.86 104.43,37.45 104.43,36.98 104.23,36.78 104.23,34.03 103.13,32.93 98.81,32.93 98.5,32.62 98.5,29.86 98.3,29.65 97.99,29.65 97.79,29.86 97.79,32.62 97.48,32.93 96.83,32.93 96.52,32.62 96.52,29.17 97.08,28.61 99.79,28.61 100.23,28.17 101.36,28.17 101.6,27.93 101.6,27.35 101.04,26.79 100.9,26.79 100.82,26.87 100.68,26.87 100.58,26.77 100.58,26.64 100.66,26.55 100.66,26.41 100.45,26.2 100.27,26.2 100.17,26.3 v1(100.17,26.56)
DDR4_COMP_DQS_N3: length 59
  L12_SIG4 w0.076: v1(120.09,43.99) 120.35,44.14 120.45,44.11 120.46,44.1 120.49,44.04 arc(120.6,43.94) 120.74,43.9 120.94,43.9 arc(121.08,43.86) 121.18,43.77 121.24,43.68 arc(121.28,43.51) 121.22,43.35 121.22,43.35 arc(121.13,43.09) 121.2,42.81 121.24,42.74 arc(121.28,42.63) 121.26,42.52 121.16,42.32 arc(121.12,42.14) 121.17,41.97 121.33,41.64 arc(121.34,41.6) 121.35,41.57 121.35,41.47 121.34,41.47 121.34,41.45
  L12_SIG4 w0.089: 121.34,41.45 121.34,41.2 121.24,41.09 121.24,40.84 121.34,40.74 121.34,40.48 121.24,40.38 121.24,40.13 121.34,40.03 121.34,39.77 121.24,39.67 121.24,39.42 121.34,39.32 121.34,39.06 121.24,38.96 121.24,38.71 121.34,38.6 121.34,35.26 120.96,34.88 118.51,34.88 118.12,34.49 118.12,33.82 118.51,33.43 122.61,33.43 122.88,33.16 122.88,32.54 122.61,32.27 97.36,32.27 94.59,29.5 90.02,29.5 88.19,27.67 88.19,27.14 88.45,26.88 88.45,26.39 88.31,26.25 88.08,26.25 87.98,26.35 v1(87.98,26.56)
DDR4_COMP_DQS_N4: length 43.2
  L14_SIG5 w0.076: v1(118.5,51.35) 118.76,51.2 118.78,51.1 118.75,51.04 arc(118.72,50.92) 118.74,50.8 118.81,50.64 arc(119,50.42) 119.27,50.34 119.33,50.34 arc(119.48,50.3) 119.59,50.2 119.67,50.08 arc(119.83,49.93) 120.05,49.88 120.17,49.88 arc(120.38,49.93) 120.53,50.09 120.59,50.18 arc(120.7,50.3) 120.86,50.34 120.94,50.34 arc(121.08,50.3) 121.19,50.2 121.23,50.13 arc(121.42,49.94) 121.67,49.88 121.71,49.88 arc(121.97,49.95) 122.16,50.15 122.17,50.17 arc(122.29,50.29) 122.46,50.34 122.87,50.34 122.87,50.34
  L14_SIG5 w0.081: 122.87,50.34 123.06,50.34 123.53,49.87 123.53,49.58 127.28,45.82 127.28,33.6 127.19,33.51 126.77,33.51 126.68,33.6 126.68,34.15 126.49,34.35 125.88,34.35 125.69,34.15 125.69,29.68 125.57,29.56 125.16,29.56 125.04,29.68 125.04,32.21 124.84,32.4 124.22,32.4 124.02,32.21 124.02,28.75 124.79,27.98 124.79,27.85 124.71,27.77 124.56,27.77 124.47,27.69 124.47,27.46 124.56,27.38 124.71,27.38 124.79,27.3 124.79,27.01 125,26.8 125,26.37 124.88,26.25 124.66,26.25 124.56,26.35 v1(124.56,26.56)
DDR4_COMP_DQS_P0: length 74.8
  L12_SIG4 w0.076: v1(116.11,44.45) 115.85,44.3 115.83,44.2 115.88,44.11 arc(115.91,43.95) 115.86,43.8 115.68,43.58 arc(115.56,43.48) 115.41,43.44 115.31,43.44 arc(115.12,43.39) 114.99,43.25 114.98,43.24 arc(114.94,43.07) 114.98,42.9 115.02,42.82 arc(115.08,42.58) 115,42.34 114.96,42.29 arc(114.92,42.15) 114.96,42.01 115.1,41.81 arc(115.13,41.73) 115.15,41.64 115.15,41.57 115.15,41.56 115.15,41.54
  L12_SIG4 w0.089: v1(75.79,25.76) 76.09,26.06 76.35,26.06 76.58,26.29 77.29,26.29 78.29,27.29 78.29,27.84 77.99,28.15 77.52,28.15 77.32,28.34 77.32,28.66 77.6,28.93 77.6,35.98 77.71,36.08 78.2,36.08 78.3,35.98 78.3,30 78.51,29.78 80.74,29.78 80.84,29.68 80.84,29.45 80.74,29.35 78.51,29.35 78.3,29.14 78.3,28.64 78.54,28.4 81.07,28.4 83.08,30.41 83.08,31.29 84.08,32.3 84.08,33.1 84.31,33.33 84.91,33.33 85.82,34.24 87.03,34.24 87.38,34.6 87.38,35 87.68,35.3 90.63,35.3 90.79,35.13 90.79,34.9 91.08,34.62 91.69,34.62 92.02,34.95 92.02,35.38 92.55,35.91 92.78,35.91 93,36.13 94.46,36.13 94.83,36.5 94.83,37.7 95.09,37.96 96.08,37.96 96.36,38.24 100.43,38.24 101.11,38.93 111.01,38.93 111.56,39.48 113.71,39.48 115.15,40.93 115.15,41.54
DDR4_COMP_DQS_P1: length 35.4
  L14_SIG5 w0.076: 123.05,44.67 123.04,44.68 123.04,44.68 122.72,45 122.44,45 arc(122.31,45.03) 122.21,45.12 122.11,45.25 arc(121.95,45.4) 121.73,45.46 121.64,45.46 arc(121.51,45.49) 121.41,45.58 121.33,45.69 arc(121.15,45.86) 120.92,45.92 120.86,45.92 arc(120.69,45.97) 120.57,46.11 120.49,46.28 arc(120.49,46.31) 120.5,46.35 120.53,46.41 120.64,46.44 v1(120.89,46.29)
  L14_SIG5 w0.081: 123.05,44.67 123.65,44.07 123.65,41.5 123.41,41.26 122.97,41.26 122.85,41.14 122.85,40.78 122.97,40.65 123.41,40.65 123.65,40.42 123.65,39.85 123.43,39.63 123.16,39.63 122.98,39.46 122.98,39.18 121.71,37.91 121.71,36.52 121.14,35.95 121.14,35.66 117.94,32.46 117.13,32.46 115.54,30.87 115.54,30.69 115.78,30.46 115.96,30.46 117.07,31.56 117.4,31.56 117.74,31.21 117.74,30.88 116.26,29.4 114.66,29.4 113.78,28.53 113.49,28.53 113.31,28.34 113.31,28.13 113.76,27.68 113.76,27.1 112.73,26.07 112.47,26.07 112.36,25.96 v1(112.36,25.76)
DDR4_COMP_DQS_P2: length 46.4
  L14_SIG5 w0.081: v1(100.17,25.76) 100.17,25.91 100.27,26.02 100.52,26.02 101.79,27.28 101.79,28.01 101.44,28.36 100.31,28.36 99.87,28.79 97.15,28.79 96.7,29.24 96.7,32.54 96.9,32.75 97.4,32.75 97.6,32.54 97.6,29.78 97.91,29.47 98.37,29.47 98.68,29.78 98.68,32.54 98.89,32.75 103.2,32.75 104.41,33.95 104.41,36.7 104.61,36.91 104.61,37.53 104.2,37.94 104.2,38.54 104.33,38.67 114.96,38.67 117.23,40.94 117.23,41.6 117.34,41.8 117.46,41.83 v1(117.7,41.69)
DDR4_COMP_DQS_P3: length 59.1
  L12_SIG4 w0.076: 121.53,41.45 121.53,41.47 121.53,41.47 121.53,41.57 arc(121.52,41.64) 121.49,41.72 121.33,42.05 arc(121.3,42.14) 121.32,42.24 121.42,42.44 arc(121.45,42.64) 121.4,42.83 121.35,42.91 arc(121.31,43.08) 121.36,43.25 121.37,43.25 arc(121.46,43.51) 121.39,43.77 121.33,43.86 arc(121.16,44.02) 120.94,44.08 120.74,44.08 arc(120.68,44.09) 120.65,44.13 120.61,44.2 120.64,44.3 v1(120.89,44.45)
  L12_SIG4 w0.089: v1(87.98,25.76) 87.98,25.96 88.08,26.06 88.39,26.06 88.64,26.31 88.64,26.96 88.38,27.22 88.38,27.59 90.1,29.31 94.67,29.31 97.44,32.08 122.69,32.08 123.07,32.46 123.07,33.24 122.69,33.62 118.59,33.62 118.31,33.9 118.31,34.41 118.59,34.69 121.04,34.69 121.53,35.18 121.53,41.45
DDR4_COMP_DQS_P4: length 43
  L14_SIG5 w0.076: 122.89,50.52 122.87,50.52 122.87,50.52 122.46,50.52 arc(122.2,50.45) 122.01,50.25 122,50.23 arc(121.88,50.1) 121.71,50.06 121.67,50.06 arc(121.51,50.1) 121.38,50.22 121.34,50.29 arc(121.17,50.46) 120.94,50.52 120.86,50.52 arc(120.61,50.45) 120.43,50.27 120.38,50.18 arc(120.29,50.09) 120.17,50.06 120.05,50.06 arc(119.91,50.09) 119.81,50.18 119.74,50.29 arc(119.56,50.46) 119.33,50.52 119.27,50.52 arc(119.09,50.57) 118.98,50.71 118.9,50.88 arc(118.89,50.91) 118.9,50.95 118.94,51.01 119.04,51.04 v1(119.3,50.89)
  L14_SIG5 w0.081: v1(124.56,25.76) 124.56,25.96 124.66,26.07 124.96,26.07 125.18,26.29 125.18,26.87 124.98,27.08 124.98,28.06 124.2,28.83 124.2,32.13 124.29,32.22 124.77,32.22 124.86,32.13 124.86,29.6 125.08,29.38 125.64,29.38 125.87,29.6 125.87,34.08 125.96,34.17 126.41,34.17 126.5,34.08 126.5,33.52 126.69,33.32 127.27,33.32 127.47,33.52 127.47,45.9 123.71,49.65 123.71,49.95 123.14,50.52 122.89,50.52
DDR4_COMP_ODT: length 101.7
  TOP w0.149: U19.F3 76.4,23.36 v1(76.42,23.38) ; U17.F3 v1(100.68,23.56) ; U16.F3 v1(112.87,23.56) ; U15.F3 v1(125.06,23.56) ; U18.F3 v1(88.49,23.56)
  L03_SIG1 w0.081: v1(112.87,23.56) 112.91,23.52 113.36,23.22 113.55,23.14 114.44,22.96 122.08,22.96 v1(125.06,23.56)
  L07_SIG3 w0.089: v1(125.06,23.56) 124.96,23.67 124.96,28.3 124.78,28.48 123.4,28.48 123.22,28.65 123.22,31.55 123.4,31.73 123.91,31.73 124.09,31.55 124.09,29.34 124.26,29.16 124.78,29.16 124.96,29.34 124.96,34.36 124.78,34.54 124.16,34.54 123.98,34.36 123.98,32.66 123.76,32.44 123.27,32.44 123.02,32.69 123.02,36.25 122.33,36.93 120.3,36.93 120.13,37.11 120.13,38.59 119.95,38.76 119.71,38.76 119.53,38.59 119.53,37.03 119.36,36.86 119.11,36.86 118.93,37.03 118.93,38.56 118.83,38.66 118.44,38.66 118.34,38.56 118.34,37.11 118.16,36.93 117.81,36.93 117.63,37.11 117.63,38.31 115.72,40.22 115.72,45.9 v1(116.11,46.29) ; v1(112.87,23.56) 109.95,22.98 102.22,22.98 101.33,23.15 101.1,23.25 100.76,23.48 v1(100.68,23.56) 97.76,22.98 90.03,22.98 89.14,23.15 88.91,23.25 88.57,23.48 v1(88.49,23.56) 85.56,22.98 77.23,22.98 76.43,23.35 v1(76.42,23.38)
  BOTTOM w0.149: v1(76.42,23.38) 75.78,23.38 R191.2
DDR4_COMP_PAR: length 96.1
  TOP w0.149: U15.N3 v1(125.06,17.76) ; U19.N3 v1(76.42,17.76) ; U17.N3 v1(100.68,17.76) ; U18.N3 v1(88.49,17.76) ; U16.N3 v1(112.87,17.76)
  L03_SIG1 w0.081: v1(112.87,17.76) 112.93,17.7 113.33,17.44 113.47,17.38 114.43,17.38 115.33,17.47 116.02,17.6 116.3,17.63 116.43,17.63 116.55,17.61 117.04,17.4 117.27,17.36 122.87,17.36 123.13,17.41 123.58,17.6 123.75,17.63 v1(125.06,17.76)
  L07_SIG3 w0.089: v1(76.42,17.76) 76.51,17.67 76.83,17.45 76.98,17.39 77.07,17.38 77.8,17.38 78.66,17.46 79.49,17.63 79.83,17.63 79.93,17.61 80.4,17.41 80.55,17.38 86.42,17.38 86.54,17.4 86.97,17.58 87.22,17.64 87.87,17.73 v1(88.49,17.76) 88.58,17.67 88.9,17.45 89.04,17.39 89.14,17.38 89.99,17.38 90.85,17.46 91.68,17.63 92.02,17.63 92.12,17.61 92.59,17.41 92.74,17.38 98.61,17.38 98.73,17.4 99.16,17.58 99.41,17.64 100.06,17.73 v1(100.68,17.76) 100.77,17.67 101.09,17.45 101.24,17.39 101.33,17.38 102.19,17.38 103.04,17.46 103.88,17.63 104.21,17.63 104.31,17.61 104.79,17.41 104.93,17.38 110.8,17.38 110.92,17.4 111.35,17.58 111.6,17.64 112.25,17.73 v1(112.87,17.76) ; v1(125.06,17.76) 125.46,18.15 125.95,18.15 126.16,18.36 126.16,23.76 125.96,23.95 125.96,35.56 125.81,35.72 124.16,35.72 124.01,35.87 124.01,38.81 123.78,39.04 123.12,39.04 122.89,38.81 122.89,37.92 122.72,37.75 122.41,37.75 122.23,37.92 122.23,38.83 122.06,39 121.72,39 121.55,38.83 121.55,37.67 121.37,37.49 120.98,37.49 120.81,37.67 120.81,39.11 120.68,39.24 118.09,39.24 116.51,40.82 116.51,47.27 v1(116.91,47.67)
DDR4_COMP_REFCLK_N: length 69.6
  L14_SIG5 w0.079: v1(67.44,41.42) 67.75,41.42 67.84,41.33 67.84,40.84 68.09,40.59 69.48,40.59 70.59,39.47 76.82,39.47 77.48,38.82 84.17,38.82 84.55,38.44 84.55,36.95 85.34,36.16 85.34,34 86.22,33.13 88.78,33.13 91.4,35.74 92.52,35.74 93.48,36.71 93.48,37.54 93.83,37.9 94.67,37.9 94.93,38.16 94.93,38.48 95,38.56 v1(95.26,38.56) 94.93,38.89 94.93,39.3 95.18,39.55 95.79,39.55 97.49,41.25 97.73,41.25 97.83,41.15 97.83,41.01 97.93,40.91 98.11,40.91 98.21,41.01 98.21,41.15 98.31,41.25 109.33,41.25 110.57,42.5 110.57,43.45 111.31,44.18 111.31,45.55 112.09,46.33 112.09,47.99 113.07,48.96 113.57,48.96 113.58,48.98
  L14_SIG5 w0.081: v1(118.5,48.59) 118.74,48.72 118.77,48.85 118.72,48.93 118.68,48.97 118.28,48.97 117.84,49.41 117.57,49.41 117.13,48.98 116.68,48.98 116.25,49.41 115.97,49.41 115.53,48.98 115.09,48.98 114.66,49.41 114.37,49.41 113.94,48.98 113.58,48.98
DDR4_COMP_REFCLK_P: length 69.8
  L14_SIG5 w0.079: 113.58,49.17 113.57,49.19 112.97,49.19 111.87,48.08 111.87,46.43 111.08,45.64 111.08,44.28 110.34,43.54 110.34,42.59 109.23,41.48 97.4,41.48 95.7,39.78 95.09,39.78 94.7,39.39 94.7,38.89 v1(94.37,38.56) 94.62,38.56 94.7,38.48 94.7,38.25 94.57,38.13 93.74,38.13 93.25,37.64 93.25,36.8 92.42,35.97 91.3,35.97 88.69,33.36 86.31,33.36 85.57,34.1 85.57,36.26 84.78,37.04 84.78,38.53 84.27,39.05 77.57,39.05 76.91,39.7 71.58,39.7 71.48,39.8 71.48,39.92 71.38,40.02 71.2,40.02 71.1,39.92 71.1,39.8 70.99,39.7 70.69,39.7 70.29,40.1 70.29,40.24 70.36,40.31 70.36,40.45 70.23,40.58 70.08,40.58 70.02,40.51 69.88,40.51 69.57,40.82 68.18,40.82 68.07,40.93 68.07,41.33 68.16,41.42 v1(68.46,41.42)
  L14_SIG5 w0.081: v1(119.3,49.05) 119.06,48.91 118.94,48.94 118.88,49.05 118.76,49.17 118.36,49.17 117.92,49.61 117.48,49.61 117.05,49.17 116.76,49.17 116.33,49.61 115.89,49.61 115.45,49.17 115.18,49.17 114.74,49.61 114.29,49.61 113.86,49.17 113.58,49.17
DDR4_COMP_RESET_N: length 98.3
  L05_SIG2 w0.081: v1(122.96,19.36) 122.74,19.14 122.27,19.14 119.86,21.55 119.86,26.68 117.1,29.44 117.1,30.3 116.85,30.56 115.63,30.56 115.5,30.69 115.5,31.07 115.63,31.19 117.11,31.19 117.28,31.36 117.28,31.66 117.11,31.83 115.6,31.83 115.48,31.96 115.48,32.21 115.6,32.34 117.11,32.34 117.28,32.5 117.28,32.68 117.11,32.84 115.6,32.84 115.48,32.97 115.48,33.56 115.7,33.78 116.72,33.78 117.15,33.35 118.81,33.35 118.91,33.45 118.91,33.71 118.81,33.81 117.56,33.81 116.47,34.9 115.7,34.9 115.53,35.08 115.53,35.41 114.11,36.83 114.11,38.07 113.29,38.89 113.29,43.11 112.78,43.61 112.78,46.49 113.04,46.75 v1(113.72,46.75) ; v1(110.76,19.36) 108.75,19.76 99.36,19.76 99.02,19.65 v1(98.57,19.36) 96.56,19.76 87.17,19.76 86.82,19.65 v1(86.38,19.36) 84.37,19.76 74.97,19.76 74.63,19.65 v1(74.19,19.36)
  L16_SIG6 w0.081: v1(122.96,19.36) 121.99,19.76 111.51,19.76 111.13,19.6 v1(110.76,19.36)
  BOTTOM w0.149: R196.2 73.19,18.3 R195.2 73.35,18.48 74.19,19.32 v1(74.19,19.36)
DDR4_COMP_RZQ:
  vias: v1(119.3,49.97)
DDR4_COMP_TEN: length 51.6
  TOP w0.149: U19.G9 v1(81.22,22.56)
  L12_SIG4 w0.089: v1(81.22,22.56) 81.62,22.16 90.94,22.16 91.9,22.56 v1(92.78,22.56) 93.23,22.37 94.3,22.16 103.13,22.16 104.1,22.56 v1(104.97,22.56) 105.43,22.37 106.49,22.16 115.32,22.16 116.29,22.56 v1(117.16,22.56) 117.62,22.37 118.68,22.16 127.51,22.16 128.48,22.56 v1(129.36,22.56)
  BOTTOM w0.149: v1(81.22,22.56) 81.27,22.61 R197.2 82.31,22.95 R199.1
DDR4_DIMM1_A0: length 78.8
  L05_SIG2 w0.081: v1(121.49,93.98) 122.69,93.98 122.79,93.88 122.79,93.62 122.68,93.51 121.99,93.51 121.88,93.39 121.88,93.23 121.99,93.12 122.68,93.12 122.79,93.01 122.79,92.79 122.66,92.66 121.29,92.66 121.15,92.8 120.92,92.8 120.78,92.66 120.5,92.66 120.12,93.04 117.05,93.04 116.89,93.2 116.89,93.49 116.78,93.6 116.62,93.6 116.5,93.49 116.5,93.11 116.39,92.99 116.23,92.99 116.12,93.11 116.12,93.56 116,93.68 115.84,93.68 115.73,93.56 115.73,93.11 115.62,92.99 115.47,92.99 115.35,93.11 115.35,93.71 115.24,93.82 115.08,93.82 114.97,93.71 114.97,93.11 114.85,92.99 114.69,92.99 114.58,93.11 114.58,93.62 114.47,93.73 114.31,93.73 114.2,93.62 114.2,93.11 114.08,92.99 113.93,92.99 113.82,93.09 113.82,94.16 114.14,94.48 114.8,94.48 114.89,94.57 114.89,94.78 114.8,94.87 114.31,94.87 114.18,95 114.18,95.25 113.98,95.46 113.66,95.46 113.53,95.32 113.53,94.91 113.41,94.8 113.25,94.8 113.14,94.91 113.14,95.6 113.03,95.71 112.87,95.71 112.75,95.6 112.75,94.91 112.64,94.8 112.48,94.8 112.37,94.91 112.37,95.75 112.25,95.86 112.1,95.86 111.98,95.75 111.98,94.91 111.87,94.8 111.71,94.8 111.6,94.91 111.6,95.51 111.05,96.06 110.87,96.06 110.75,95.94 110.75,95.76 111.18,95.33 111.18,95.13 110.9,94.85 110.9,93.75 110.65,93.5 110.27,93.5 110.1,93.33 109.95,93.33 109.81,93.47 109.81,93.63 110.02,93.84 110.02,94.39 109.87,94.54 109.21,94.54 109.13,94.63 109.13,94.83 109.21,94.92 109.98,94.92 110.07,95.01 110.07,95.21 109.98,95.3 109.17,95.3 108.89,95.58 108.69,95.58 108.24,95.13 106.76,95.13 106.23,95.66 106,95.66 105.87,95.53 105.87,95.3 105.65,95.07 104.25,95.07 104.05,94.87 104.05,94.67 103.74,94.36 101.73,94.36 101.63,94.26 101.2,94.26 101.1,94.16 101.1,93.94 101.19,93.86 101.35,93.86 101.48,93.73 101.48,93.11 101.37,92.99 101.21,92.99 101.09,93.11 101.09,93.39 100.98,93.5 100.82,93.5 100.71,93.39 100.71,92.87 100.8,92.77 100.8,92.06 100.7,91.95 100.55,91.95 100.44,92.06 100.44,92.58 100.34,92.69 100.19,92.69 100.08,92.58 100.08,88.41 99.97,88.29 99.81,88.29 99.7,88.41 99.7,89.93 99.58,90.05 99.42,90.05 99.31,89.93 99.31,88.74 99.13,88.56 99.13,88.08 99.24,87.97 99.41,87.97 99.52,87.86 99.52,87.7 99.41,87.58 99.24,87.58 99.13,87.47 99.13,87.11 99.01,87 98.85,87 98.74,87.11 98.74,88.56 98.63,88.67 98.47,88.67 98.36,88.56 98.36,87.32 98.27,87.23 98.04,87.23 97.95,87.32 97.95,87.44 97.86,87.53 97.53,87.53 97.44,87.44 97.44,82.85 97.2,82.6 96.83,82.6 96.58,82.35 96.58,77.49 v1(96.19,77.11)
DDR4_DIMM1_A1: length 79
  L05_SIG2 w0.081: v1(110.44,93.98) 110.44,94.92 110.65,95.13 110.65,95.38 110.4,95.63 110.4,96.18 110.31,96.27 110.1,96.27 110.01,96.18 110.01,95.74 109.94,95.66 109.44,95.66 109.18,95.91 109.18,96.26 109.1,96.35 108.62,96.55 108.24,96.55 107.94,96.26 107.23,96.26 107.12,96.14 107.12,95.98 107.23,95.87 108.1,95.87 108.21,95.76 108.21,95.6 108.1,95.48 106.91,95.48 106.66,95.74 106.66,96.24 106.57,96.34 106.18,96.5 105.7,96.5 105.54,96.34 105.54,95.61 105.42,95.48 105.27,95.48 105.16,95.59 105.16,96.05 105.04,96.17 104.88,96.17 104.77,96.05 104.77,95.54 104.66,95.43 104.5,95.43 104.39,95.54 104.39,95.85 104.27,95.96 104.11,95.96 104,95.85 104,95.44 103.89,95.33 103.56,95.33 103.36,95.53 101.9,95.53 101.78,95.42 101.78,95.26 101.9,95.15 103.12,95.15 103.23,95.03 103.23,94.87 103.12,94.76 101.35,94.76 101.25,94.66 100.93,94.66 100.72,94.44 100.72,93.88 100.34,93.5 99.91,93.5 99.5,93.09 99.5,92.51 99.62,92.39 99.62,90.57 99.5,90.45 99.34,90.45 99.23,90.57 99.23,92.07 99.12,92.18 98.96,92.18 98.84,92.07 98.84,89.14 98.73,89.03 98.57,89.03 98.46,89.14 98.46,92.02 98.34,92.13 98.18,92.13 98.07,92.02 98.07,89.27 97.96,89.16 97.8,89.16 97.69,89.27 97.69,91.96 97.57,92.08 97.41,92.08 97.3,91.96 97.3,88.94 97.52,88.72 97.52,87.99 97.34,87.81 97.05,87.81 96.91,87.95 96.91,91.2 96.8,91.32 96.64,91.32 96.53,91.2 96.53,87.38 96.63,87.28 96.93,87.28 97.09,87.12 97.09,83.1 96.94,82.96 96.78,82.96 96.67,83.07 96.67,86.12 96.56,86.24 96.4,86.24 96.28,86.12 96.28,82.87 96.17,82.76 96.01,82.76 95.9,82.87 95.9,85.18 95.78,85.3 95.62,85.3 95.51,85.18 95.51,82.63 95.81,82.33 95.81,77.99 v1(95.39,77.57)
DDR4_DIMM1_A2: length 76.4
  L12_SIG4 w0.089: v1(110.44,99.98) 111.29,99.98 111.88,99.39 111.88,99.09 112.73,98.24 116.98,98.24 117.1,98.12 117.1,97.79 116.97,97.67 115.71,97.67 115.58,97.54 115.58,97.32 115.71,97.2 116.98,97.2 117.11,97.07 117.11,96.85 116.98,96.73 115.71,96.73 115.58,96.6 115.58,96.38 115.71,96.26 116.85,96.26 116.97,96.13 116.97,95.93 116.8,95.76 113.24,95.76 113.11,95.89 113.11,96.1 113.24,96.23 114.85,96.23 114.98,96.36 114.98,96.57 114.85,96.7 113.22,96.7 113.1,96.83 113.1,97.04 113.22,97.17 114.85,97.17 114.98,97.29 114.98,97.51 114.85,97.64 112.59,97.64 112.46,97.51 112.46,95.89 112.13,95.56 108.6,95.56 108.3,95.25 108.3,92.66 109.06,91.89 111.54,91.89 113.27,90.17 113.27,86.8 112.75,86.29 112.35,86.29 109.33,83.27 109.33,76.91 109.11,76.7 108.73,76.7 108.21,76.18 107.93,76.18 107.5,75.75 107.12,75.75 106.66,75.29 106.38,75.29 105.98,74.88 105.67,74.88 105.14,74.35 104.76,74.35 104.37,73.96 104.1,73.96 103.92,74.04 103.58,74.38 103.21,74.38 102.72,73.89 102.39,73.89 101.94,74.35 101.56,74.35 101.07,73.87 100.85,73.87 100.36,74.35 99.98,74.35 99.54,74.79 99.24,74.79 98.8,75.23 98.36,75.23 97.91,74.79 97.6,74.79 97.19,74.37 96.78,74.37 96.4,74.75 96.02,74.75 95.77,75.01 95.77,75.47 96.19,75.89 v1(96.19,76.19)
DDR4_DIMM1_A3: length 76.6
  L12_SIG4 w0.089: v1(95.39,75.73) 95.01,75.34 95.01,74.61 95.29,74.32 95.62,74.32 96,73.93 96.29,73.93 96.8,73.42 97.16,73.42 97.6,73.86 97.95,73.86 98.44,74.35 98.77,74.35 99.19,73.94 99.5,73.94 99.97,73.47 101.98,73.47 102.42,73.03 102.74,73.03 103.27,72.49 103.55,72.49 103.99,72.05 104.26,72.05 104.72,72.5 105.1,72.5 105.55,72.96 105.88,72.96 106.34,73.42 106.68,73.42 107.15,73.89 107.47,73.89 107.91,74.32 108.28,74.32 108.76,74.8 109.04,74.8 109.52,75.28 109.93,75.28 110.4,75.75 110.72,75.75 110.95,75.98 110.95,82.47 114.82,86.34 114.82,89.43 114.95,89.56 115.14,89.56 115.27,89.43 115.27,88.39 115.39,88.26 115.59,88.26 115.71,88.39 115.71,89.43 115.84,89.56 116.03,89.56 116.16,89.43 116.16,88.43 116.28,88.3 116.47,88.3 116.6,88.43 116.6,89.43 116.73,89.56 116.92,89.56 117.05,89.43 117.05,87.84 117.17,87.71 117.36,87.71 117.49,87.84 117.49,89.43 117.62,89.56 117.81,89.56 117.93,89.43 117.93,88.78 118.17,88.55 118.8,88.55 119.07,88.82 119.07,89.3 119.51,89.74 119.51,90.64 119.64,90.77 119.83,90.77 119.96,90.64 119.96,89.59 120.09,89.46 120.28,89.46 120.4,89.59 120.4,90.65 120.53,90.78 120.72,90.78 120.85,90.65 120.85,89.67 120.97,89.55 121.17,89.55 121.29,89.67 121.29,92.58 121.17,92.7 120.97,92.7 120.85,92.58 120.85,91.51 120.72,91.38 120.53,91.38 120.4,91.51 120.4,92.66 120.28,92.79 120.09,92.79 119.96,92.66 119.96,91.52 119.83,91.39 119.64,91.39 119.51,91.52 119.51,93.31 119.29,93.54 110.03,93.54 v1(109.59,93.98)
DDR4_DIMM1_A4: length 78.1
  L12_SIG4 w0.089: v1(108.74,99.98) 108.36,99.6 107.71,99.6 107.52,99.8 107.52,101.07 107.67,101.22 108.05,101.22 109.64,102.81 110.66,102.81 111.42,103.57 111.42,104.26 111.52,104.36 111.68,104.36 111.78,104.26 111.78,103.7 111.88,103.6 112.13,103.6 112.23,103.7 112.23,104.26 112.33,104.36 112.49,104.36 112.59,104.26 112.59,103.74 112.69,103.63 112.86,103.63 112.96,103.74 112.96,104.55 112.78,104.74 103.32,104.74 103.22,104.64 103.22,103.34 103.12,103.24 102.98,103.24 102.88,103.34 102.88,104.54 102.78,104.64 102.63,104.64 102.53,104.54 102.53,103.41 102.43,103.31 102.29,103.31 102.19,103.41 102.19,104.54 102.09,104.64 101.95,104.64 101.85,104.54 101.85,102.1 101.95,102 102.09,102 102.19,102.1 102.19,102.79 102.29,102.89 102.43,102.89 102.53,102.79 102.53,102.1 102.63,102 102.78,102 102.88,102.1 102.88,102.79 102.98,102.89 103.12,102.89 103.22,102.79 103.22,100.55 103.08,100.41 102.61,100.41 102.41,100.61 102.41,101.05 102.26,101.2 102.02,101.2 101.87,101.05 101.87,100.26 101.97,100.16 102.29,100.16 102.39,100.06 102.39,99.92 102.29,99.82 101.97,99.82 101.87,99.72 101.87,99.58 101.97,99.48 102.29,99.48 102.39,99.38 102.39,98.8 102.76,98.44 102.76,94.64 103.21,94.19 103.21,92.91 101.07,90.78 101.07,88.84 100.97,88.74 100.83,88.74 100.73,88.84 100.73,90.59 100.63,90.69 100.49,90.69 100.39,90.59 100.39,88.58 100.76,88.21 100.76,86.48 100.39,86.12 100.39,84.72 100.49,84.62 100.63,84.62 100.73,84.72 100.73,85.92 100.83,86.02 100.98,86.02 101.08,85.92 101.08,84.75 101.2,84.62 101.58,84.62 102.37,83.82 102.37,83.26 102.61,83.03 102.61,82.51 102.98,82.14 102.98,80.62 102.67,80.32 102.37,80.32 101.94,79.89 101.58,79.89 101.1,79.4 100.72,79.4 100.26,78.95 99.98,78.95 99.5,78.46 99.19,78.46 98.76,78.03 98.41,78.03 97.79,77.41 v1(97.79,77.11)
DDR4_DIMM1_A5: length 78.2
  L12_SIG4 w0.089: v1(107.89,99.98) 108.31,100.4 108.31,100.98 109.79,102.46 110.86,102.46 111.33,102.92 113,102.92 113.25,103.18 114.3,103.18 114.48,103.36 115.12,103.36 115.22,103.26 115.22,102.24 115.4,102.06 115.96,102.06 116.1,102.2 116.1,103.22 116.18,103.3 116.52,103.3 116.62,103.2 116.62,102.05 116.72,101.95 116.95,101.95 117.05,102.05 117.05,104.95 116.95,105.06 116.68,105.06 116.58,104.96 116.58,103.89 116.48,103.79 116.3,103.79 116.2,103.89 116.2,104.85 116.1,104.95 115.96,104.95 115.86,104.85 115.86,103.89 115.76,103.79 115.61,103.79 115.51,103.89 115.51,104.85 115.41,104.95 115.27,104.95 115.17,104.85 115.17,103.89 115.07,103.79 114.93,103.79 114.83,103.89 114.83,104.85 114.73,104.95 114.59,104.95 114.49,104.85 114.49,103.89 114.38,103.79 114.24,103.79 114.14,103.89 114.14,104.85 114.04,104.95 113.9,104.95 113.8,104.85 113.8,103.89 113.7,103.79 113.56,103.79 113.46,103.89 113.46,104.9 113.24,105.12 101.63,105.12 101.5,104.98 101.5,98.65 101.66,98.48 102.15,98.48 102.37,98.27 102.37,92.6 100.9,91.13 100.31,91.13 100.03,90.85 100.03,88.43 100.4,88.06 100.4,86.64 100.03,86.28 100.03,84.41 100.2,84.25 101.45,84.25 102.01,83.69 102.01,83.09 102.17,82.94 102.17,81.05 101.91,80.8 101.61,80.8 101.14,80.33 100.91,80.33 100.42,79.85 100,79.85 99.52,79.38 99.17,79.38 98.74,78.95 98.38,78.95 97.92,78.49 97.62,78.49 96.99,77.86 v1(96.99,77.57)
DDR4_DIMM1_A6: length 78.3
  L05_SIG2 w0.081: v1(107.89,93.98) 108.16,93.98 108.47,93.68 108.47,92.59 108.69,92.36 108.69,92.1 108.85,91.95 111.39,91.95 112.35,90.99 119.41,90.99 119.79,90.6 121.94,90.6 122.05,90.49 122.05,90.33 121.94,90.21 120.24,90.21 120.12,90.1 120.12,89.94 120.24,89.82 121.94,89.82 122.05,89.71 122.05,89.55 121.94,89.44 120.05,89.44 119.82,89.66 118.19,89.66 117.89,89.36 114.74,89.36 114.23,88.85 113.82,88.85 113.32,89.36 111.78,89.36 110.87,88.45 109.87,88.45 109.76,88.33 109.76,88.2 109.87,88.09 110.49,88.09 110.6,87.98 110.6,87.85 110.49,87.73 109.52,87.73 109.4,87.85 109.4,88.31 109.29,88.42 108.74,88.42 108.54,88.22 108.54,87.67 108.8,87.42 108.8,87.25 108.54,87 108.54,86.43 108.45,86.34 108.29,86.34 108.21,86.43 108.21,86.95 107.96,87.2 107.96,87.45 108.21,87.7 108.21,88.48 108.12,88.57 107.36,88.57 107.27,88.48 107.27,86.81 107.16,86.69 107,86.69 106.89,86.81 106.89,87.72 106.77,87.84 106.61,87.84 106.5,87.72 106.5,86.53 106.69,86.34 107.77,86.34 107.86,86.25 107.86,86 107.74,85.88 106.43,85.88 106.18,85.63 104.44,85.63 104.32,85.74 104.32,85.9 104.44,86.01 105.96,86.01 106.08,86.13 106.08,86.29 105.96,86.4 104.54,86.4 104.45,86.49 104.45,86.68 104.54,86.77 104.74,86.77 104.83,86.86 104.83,87.06 104.74,87.15 104.35,87.15 104.25,87.25 104.25,87.43 104.47,87.65 104.47,88.08 104.29,88.27 103.84,88.27 103.59,88.01 103.59,86.26 103.69,86.16 103.88,86.16 103.97,86.07 103.97,85.78 102.75,84.56 101.99,84.56 99.76,82.33 99.76,75.96 99.58,75.77 99.14,75.77 98.73,76.19 v1(97.79,76.19)
DDR4_DIMM1_A7: length 76.6
  L12_SIG4 w0.089: v1(106.19,99.98) 106.19,99.64 106.09,99.54 105.54,99.54 105.44,99.44 105.44,99.29 105.54,99.19 106.09,99.19 106.19,99.09 106.19,98.95 106.09,98.85 105,98.85 104.9,98.75 104.9,98.61 105,98.51 106.26,98.51 106.36,98.41 106.36,98.26 106.26,98.16 105.02,98.16 104.92,98.06 104.92,97.92 105.02,97.82 106.25,97.82 106.35,97.72 106.35,97.58 106.25,97.48 104.69,97.48 104.59,97.38 104.59,97.24 104.69,97.14 105.87,97.14 105.97,97.04 105.97,96.89 105.87,96.79 104.62,96.79 104.52,96.69 104.52,96.55 104.62,96.45 105.14,96.45 105.24,96.35 105.24,96.24 105.08,96.09 104.17,96.09 104.05,95.97 104.05,95.71 104.15,95.61 104.82,95.61 104.92,95.51 104.92,95.37 104.82,95.27 104.15,95.27 104.05,95.17 104.05,95.02 104.15,94.92 104.82,94.92 104.92,94.82 104.92,94.68 104.82,94.58 104.15,94.58 104.05,94.48 104.05,92.65 103.46,92.06 103.46,90.27 103.56,90.17 103.71,90.17 103.81,90.27 103.81,91.83 103.91,91.93 104.05,91.93 104.15,91.83 104.15,90.27 104.25,90.17 104.39,90.17 104.49,90.27 104.49,92.33 104.59,92.43 104.73,92.43 104.84,92.33 104.84,90.27 104.94,90.17 105.08,90.17 105.18,90.27 105.18,91.52 105.28,91.62 105.42,91.62 105.52,91.52 105.52,88.4 105.42,88.3 105.28,88.3 105.18,88.4 105.18,89.7 105.08,89.8 104.94,89.8 104.84,89.7 104.84,88.4 104.73,88.3 104.59,88.3 104.49,88.4 104.49,89.65 104.39,89.75 104.25,89.75 104.15,89.65 104.15,88.4 104.05,88.3 103.91,88.3 103.81,88.4 103.81,89.65 103.71,89.75 103.56,89.75 103.46,89.65 103.46,87.44 103.56,87.34 104.37,87.34 104.47,87.24 104.47,86.49 104.37,86.39 103.56,86.39 103.46,86.29 103.46,86.05 103.57,85.95 104.37,85.95 104.58,85.74 104.58,84.68 104.68,84.58 104.82,84.58 104.92,84.68 104.92,85.63 105.02,85.73 105.16,85.73 105.26,85.63 105.26,82.69 105.16,82.59 105.02,82.59 104.92,82.69 104.92,84.05 104.82,84.15 104.68,84.15 104.58,84.05 104.58,79.71 104.27,79.4 103.97,79.4 103.51,78.95 103.13,78.95 102.72,78.54 102.42,78.54 101.91,78.03 101.58,78.03 101.15,77.6 100.77,77.6 100.29,77.12 100.01,77.12 99.52,76.63 99.22,76.63 98.79,76.2 98.36,76.2 97.89,75.73 v1(96.99,75.73)
DDR4_DIMM1_A8: length 80.7
  L05_SIG2 w0.081: v1(107.04,93.98) 107.47,93.55 107.47,92.94 107.27,92.74 107.27,92.51 107.45,92.33 107.69,92.33 107.78,92.42 107.78,92.6 107.87,92.69 108.03,92.69 108.12,92.6 108.12,92.37 108.29,92.2 108.29,92.09 108.17,91.98 107.82,91.98 107.7,91.87 107.7,91.71 107.82,91.6 111.26,91.6 111.64,91.21 111.64,90.96 111.77,90.83 112.02,90.83 112.37,90.48 112.37,90.18 112.48,90.07 112.64,90.07 112.76,90.18 112.76,90.52 112.87,90.63 113.03,90.63 113.14,90.52 113.14,90.18 113.26,90.07 113.42,90.07 113.53,90.18 113.53,90.52 113.64,90.63 113.8,90.63 113.91,90.52 113.91,89.88 114.03,89.77 114.19,89.77 114.3,89.88 114.3,90.52 114.41,90.63 114.57,90.63 114.69,90.52 114.69,90.18 114.8,90.07 114.96,90.07 115.07,90.18 115.07,90.52 115.19,90.63 115.35,90.63 115.46,90.52 115.46,90.18 115.57,90.07 115.73,90.07 115.85,90.18 115.85,90.52 115.96,90.63 116.12,90.63 116.23,90.52 116.23,90.18 116.34,90.07 116.5,90.07 116.62,90.18 116.62,90.52 116.73,90.63 116.9,90.63 117,90.53 117,90.16 117.09,90.07 117.29,90.07 117.38,90.16 117.38,90.54 117.47,90.63 117.79,90.63 118.02,90.4 118.24,90.4 118.47,90.63 118.63,90.63 118.8,90.45 118.93,90.45 119.11,90.63 119.29,90.63 119.56,90.35 119.56,90.12 119.46,90.02 118.07,90.02 117.76,89.72 114.61,89.72 114.18,89.28 113.88,89.28 113.44,89.72 111.36,89.72 111.26,89.61 111.26,89.33 110.73,88.8 110.14,88.8 110,88.94 109.74,88.94 109.62,88.83 109.28,88.83 109.16,88.94 108.96,88.94 108.85,88.83 108.49,88.83 108.36,88.95 108.36,89.22 108.48,89.33 110.71,89.33 110.83,89.44 110.83,89.6 110.71,89.72 105.94,89.72 105.82,89.6 105.82,89.44 105.94,89.33 107.87,89.33 107.98,89.22 107.98,89.06 107.87,88.94 106.97,88.94 106.85,88.83 106.85,88.3 106.74,88.19 106.58,88.19 106.47,88.3 106.47,88.87 106.35,88.98 105.94,88.98 105.82,88.86 105.82,88.43 105.89,88.37 106.02,88.37 106.13,88.25 106.13,88.09 106.02,87.98 105.83,87.98 105.72,87.87 105.72,87.75 105.83,87.63 106.04,87.63 106.15,87.52 106.15,86.83 106.06,86.74 105.86,86.74 105.77,86.83 105.77,87.12 105.57,87.33 105.09,87.33 104.83,87.58 104.83,88.24 104.45,88.62 103.72,88.62 103.23,88.14 103.23,85.54 103.11,85.42 102.95,85.42 102.84,85.54 102.84,87.6 102.73,87.71 102.57,87.71 102.46,87.6 102.46,85.03 102.34,84.91 102.18,84.91 102.07,85.03 102.07,87.14 101.96,87.25 101.8,87.25 101.68,87.14 101.68,84.74 98.98,82.03 98.98,77.51 v1(99.38,77.11)
DDR4_DIMM1_A9: length 80.5
  L05_SIG2 w0.081: v1(98.58,77.57) 98.29,77.57 98.17,77.68 98.17,82.39 98.33,82.55 98.91,82.55 99.04,82.68 99.04,82.83 99.14,82.93 99.4,82.93 99.73,83.26 99.73,83.57 99.88,83.72 100.18,83.72 100.74,84.28 100.74,84.51 100.56,84.69 100.56,86 100.68,86.11 100.84,86.11 100.95,86 100.95,84.88 101.06,84.76 101.22,84.76 101.34,84.88 101.34,86.28 101.22,86.39 101.05,86.39 100.95,86.49 100.49,86.49 100.39,86.59 100.39,87.05 100.51,87.18 100.85,87.18 100.92,87.25 101.25,87.25 101.61,87.61 101.99,87.61 102.12,87.73 102.12,87.86 102.32,88.06 102.78,88.06 102.88,88.17 102.88,88.32 103.13,88.57 103.13,88.75 102.98,88.9 102.98,89.58 103.09,89.69 103.25,89.69 103.36,89.58 103.36,89.09 103.48,88.98 103.82,88.98 103.93,89.09 103.93,89.25 104.04,89.36 104.2,89.36 104.31,89.25 104.31,89.09 104.43,88.98 104.59,88.98 104.7,89.09 104.7,89.25 104.81,89.36 104.97,89.36 105.09,89.25 105.09,88.48 105.2,88.37 105.35,88.37 105.47,88.48 105.47,89.6 105.35,89.72 103.84,89.72 103.69,89.87 103.69,90.73 103.84,90.88 108.22,90.88 108.34,90.77 108.34,90.59 108.22,90.48 104.16,90.48 104.05,90.36 104.05,90.18 104.16,90.07 111.89,90.07 112,90.17 112,90.36 111.88,90.48 108.81,90.48 108.69,90.59 108.69,90.77 108.81,90.88 111.12,90.88 111.23,91 111.23,91.13 111.12,91.24 103.8,91.24 103.69,91.35 103.69,91.51 103.8,91.63 107.23,91.63 107.35,91.74 107.35,91.95 107.22,92.08 106.79,92.08 106.69,91.98 106.4,91.98 106.3,92.08 106,92.08 105.89,91.97 103.79,91.97 103.69,92.07 103.69,92.24 103.8,92.36 104.27,92.36 104.39,92.47 104.39,92.63 104.27,92.74 103.8,92.74 103.69,92.84 103.69,93.07 103.87,93.24 103.87,93.58 103.95,93.66 104.19,93.66 104.35,93.5 104.82,93.5 104.93,93.39 104.93,92.97 104.78,92.81 104.78,92.44 104.87,92.36 105.11,92.36 105.19,92.43 105.19,92.57 105.3,92.69 105.47,92.69 105.7,92.46 106.74,92.46 106.84,92.56 106.84,92.73 106.73,92.84 105.86,92.84 105.75,92.95 105.75,93.16 105.86,93.27 106.65,93.27 106.76,93.38 106.76,93.54 106.65,93.66 105.44,93.66 105.34,93.76 v1(105.34,93.98)
DDR4_DIMM1_A10: length 76.2
  L14_SIG5 w0.081: v1(123.19,99.98) 122.77,99.55 122.2,99.55 121.98,99.77 121.16,99.77 120.98,99.6 120.43,99.6 119.97,100.05 117.82,100.05 115.63,97.87 110.61,97.87 110.12,97.37 104.1,97.37 102.66,98.81 102.66,99.26 102.09,99.82 101.8,99.82 100.43,101.19 100.01,101.19 98.85,102.34 98.49,102.34 98.1,102.73 96.13,102.73 95.69,103.17 93.8,103.17 93.67,103.04 93.07,103.04 92.77,103.34 91.37,103.34 90.69,102.66 89.5,102.66 89.41,102.57 88.28,102.57 87.95,102.24 87.95,101.49 87.64,101.17 87.31,101.17 86.21,100.08 86.21,98.73 86.07,98.59 86.07,94.41 86.21,94.27 86.21,93.57 87.87,91.91 88.43,91.91 89.6,90.74 90.38,90.74 93.03,88.09 93.03,87.55 93.32,87.27 94.08,87.27 94.25,87.1 94.25,86.69 94.57,86.38 95.76,86.38 98.45,83.68 99.24,83.68 100.57,82.36 100.57,78.32 100.3,78.05 100.07,78.05 99.77,77.75 99.77,76.58 v1(99.38,76.19)
DDR4_DIMM1_A11: length 75.8
  L12_SIG4 w0.089: v1(98.58,75.73) 99.53,75.73 99.96,76.15 100.29,76.15 100.79,76.66 101.12,76.66 101.56,77.09 101.91,77.09 102.34,77.52 102.72,77.52 103.23,78.03 103.51,78.03 103.99,78.51 104.27,78.51 104.71,78.95 105.04,78.95 105.34,79.25 105.34,82 105.65,82.31 105.65,84.39 105.75,84.49 105.89,84.49 105.99,84.39 105.99,83.28 106.09,83.18 106.24,83.18 106.34,83.28 106.34,84.41 106.44,84.51 106.58,84.51 106.68,84.41 106.68,84.01 106.78,83.91 106.92,83.91 107.02,84.01 107.02,84.56 107.12,84.66 107.7,84.66 107.8,84.76 107.8,84.9 107.7,85 107.12,85 107.02,85.1 107.02,85.24 107.12,85.34 108.38,85.34 108.48,85.44 108.48,85.58 108.38,85.68 107.12,85.68 107.02,85.79 107.02,85.93 107.12,86.03 108.5,86.03 108.6,86.13 108.6,86.27 108.5,86.37 106.78,86.37 106.68,86.27 106.68,85.09 106.58,84.99 106.44,84.99 106.34,85.09 106.34,86.27 106.24,86.37 106.09,86.37 105.99,86.27 105.99,85.09 105.89,84.99 105.75,84.99 105.65,85.09 105.65,86.13 105.47,86.31 104.99,86.31 104.85,86.44 104.85,87.12 105.01,87.28 105.78,87.28 105.9,87.4 105.9,87.76 106,87.86 106.14,87.86 106.25,87.76 106.25,86.96 106.35,86.86 106.49,86.86 106.59,86.96 106.59,87.75 106.69,87.85 106.83,87.85 106.93,87.75 106.93,86.96 107.03,86.86 107.17,86.86 107.27,86.96 107.27,87.25 107.37,87.35 108.4,87.35 108.52,87.47 108.52,88.04 108.71,88.23 108.71,89.42 108.61,89.52 108.4,89.52 108.3,89.42 108.3,88.49 108.2,88.38 108.06,88.38 107.96,88.49 107.96,89.67 107.86,89.77 107.72,89.77 107.62,89.67 107.62,88.37 107.52,88.27 107.37,88.27 107.27,88.37 107.27,90.35 107.17,90.45 107.03,90.45 106.93,90.35 106.93,88.41 106.83,88.31 106.69,88.31 106.59,88.41 106.59,90.83 106.49,90.93 106.35,90.93 106.25,90.83 106.25,88.42 106.14,88.32 106,88.32 105.9,88.42 105.9,91.67 105.25,92.32 105.25,92.6 104.91,92.94 104.91,94.15 105.27,94.51 105.27,95.72 106.02,96.47 106.23,96.47 106.38,96.62 106.38,96.95 106.53,97.1 106.86,97.1 107.47,97.71 107.47,98.1 107.14,98.44 106.83,98.44 106.57,98.71 106.57,100.23 106.35,100.45 105.49,100.45 105.34,100.3 v1(105.34,99.98)
DDR4_DIMM1_A12: length 84.5
  L05_SIG2 w0.081: v1(100.18,75.73) 100.18,76.12 100.56,76.5 100.56,82.65 102.12,84.2 102.88,84.2 103.92,85.25 106.33,85.25 106.62,85.54 107.87,85.54 108.31,85.98 109.25,85.98 109.4,86.13 109.4,87.25 109.53,87.38 110.83,87.38 110.95,87.51 110.95,88.01 111.21,88.27 111.31,88.27 112.05,89 113.19,89 113.82,88.37 113.82,87.62 113.91,87.53 114.09,87.53 114.18,87.62 114.18,88.32 114.87,89 117.51,89 117.63,88.88 117.63,88.7 117.76,88.57 117.91,88.57 118.14,88.8 118.33,88.8 118.44,88.69 118.44,88.58 118.56,88.47 118.72,88.47 118.83,88.58 118.83,89.2 118.94,89.31 119.1,89.31 119.22,89.2 119.22,88.61 119.33,88.5 119.51,88.5 119.62,88.6 119.62,88.7 119.72,88.8 119.9,88.8 120,88.7 120,88.36 120.09,88.27 120.23,88.27 120.35,88.39 120.35,88.95 120.48,89.08 120.73,89.08 120.83,88.98 121.04,88.98 121.14,89.08 121.72,89.08 121.8,89 123.22,89 123.37,88.85 123.63,88.85 123.93,89.16 125.81,89.16 125.97,89 126.88,89 127.08,89.21 127.08,89.89 127.32,90.12 127.32,90.27 127.18,90.4 126.83,90.4 126.69,90.26 126.69,89.47 126.58,89.36 126.42,89.36 126.31,89.47 126.31,90.29 126.19,90.4 126.03,90.4 125.92,90.29 125.92,89.63 125.81,89.51 125.65,89.51 125.53,89.63 125.53,90.3 125.43,90.4 125.22,90.4 125.1,90.29 125.1,89.63 124.99,89.51 124.83,89.51 124.72,89.63 124.72,90.31 124.6,90.43 124.44,90.43 124.33,90.31 124.33,89.63 124.22,89.51 124.06,89.51 123.94,89.63 123.94,90.9 123.83,91.01 123.67,91.01 123.56,90.9 123.56,89.45 123.44,89.33 123.28,89.33 123.17,89.45 123.17,90.91 123.07,91.01 122.9,91.01 122.79,90.9 122.79,89.47 122.67,89.36 122.51,89.36 122.4,89.47 122.4,90.9 122.29,91.01 119.87,91.01 119.54,91.34 112.48,91.34 111.59,92.23 111.59,93.07 111.49,93.17 111.33,93.17 111.21,93.06 111.21,92.43 111.08,92.31 109.23,92.31 108.82,92.71 108.82,93.88 108.28,94.41 106.72,94.41 106.61,94.3 106.61,94.11 106.51,94.01 105.83,94.01 105.72,94.11 105.72,94.21 105.57,94.36 105.06,94.36 104.96,94.26 104.96,94.08 104.86,93.98 v1(104.49,93.98)
DDR4_DIMM1_A13: length 83.9
  L14_SIG5 w0.081: v1(129.14,99.98) 128.58,99.42 126.37,99.42 125.43,98.48 120.4,98.48 119.72,99.16 117.99,99.16 115.33,96.51 112.34,96.51 110.3,94.47 107.46,94.47 107.31,94.61 107.31,94.99 107.43,95.1 107.94,95.1 108.05,95.22 108.05,95.78 107.94,95.89 107.43,95.89 107.31,96 107.31,96.34 107.15,96.51 103.57,96.51 102.73,97.35 101.9,97.35 101.47,97.78 101.47,98.23 100.98,98.72 100.98,99.35 100.62,99.71 100.2,99.71 99.55,100.36 99.22,100.36 98.14,101.44 98.14,101.7 97.86,101.98 95.83,101.98 95.31,102.5 94.08,102.5 93.95,102.37 92.52,102.37 92.26,102.62 91.6,102.62 91.37,102.39 91.37,102.26 91.09,101.97 90.73,101.97 90.49,101.74 90.49,101.51 90.2,101.22 89.44,101.22 88.82,100.6 88.44,100.6 87.92,100.08 87.92,99.5 87.47,99.06 87.47,94.48 87.11,94.13 87.11,93.84 88.26,92.68 89.31,92.68 90.16,91.84 90.43,91.84 93.54,88.74 94.47,88.74 95.96,87.24 96.83,87.24 97.14,86.93 97.14,86.53 98.88,84.79 99.74,84.79 102.17,82.36 102.17,77.51 v1(102.57,77.11)
DDR4_DIMM1_A14: length 84.3
  L14_SIG5 w0.081: v1(101.77,77.57) 101.35,77.98 101.35,82.39 99.45,84.29 98.44,84.29 95.37,87.36 94.59,87.36 93.65,88.3 93.45,88.3 90.43,91.32 89.88,91.32 88.85,92.35 88.06,92.35 86.73,93.68 86.73,94.23 87.08,94.58 87.08,100.23 87.59,100.74 88.09,100.74 88.76,101.4 88.76,101.98 88.86,102.08 89.39,102.08 89.64,102.32 90.83,102.32 91.48,102.97 92.43,102.97 92.7,102.71 93.81,102.71 93.94,102.83 95.51,102.83 95.95,102.4 97.96,102.4 98.35,102.01 98.71,102.01 99.8,100.92 99.8,100.59 100.23,100.16 100.83,100.16 101.42,99.57 101.42,98.82 101.79,98.46 102.28,98.46 103.79,96.95 109.94,96.95 110.07,96.82 110.07,95.28 110.21,95.15 110.4,95.15 110.54,95.28 110.54,96.82 110.67,96.95 110.86,96.95 111,96.82 111,96.26 111.12,96.13 111.33,96.13 111.46,96.26 111.46,97.38 111.59,97.51 111.77,97.51 111.89,97.38 111.89,97.09 112.02,96.96 112.2,96.96 112.33,97.09 112.33,97.38 112.45,97.51 112.63,97.51 112.76,97.38 112.76,97.09 112.89,96.96 113.07,96.96 113.19,97.09 113.19,97.38 113.32,97.51 113.5,97.51 113.63,97.38 113.63,97.09 113.76,96.95 114,96.95 114.14,97.09 114.14,97.36 114.27,97.5 114.47,97.5 114.6,97.36 114.6,97.09 114.74,96.95 115.24,96.95 117.86,99.57 119.87,99.57 120.35,99.09 121.04,99.09 121.37,99.42 121.7,99.42 122.08,99.04 122.89,99.04 123.32,99.47 125.23,99.47 v1(125.74,99.98)
DDR4_DIMM1_A15: length 86.3
  L05_SIG2 w0.081: v1(127.44,93.98) 127.19,93.73 127.19,93.56 127.07,93.45 126.91,93.45 126.8,93.56 126.8,93.87 126.69,93.98 126.47,93.98 126.08,93.59 125.57,93.59 125.36,93.8 125.36,94.57 125.23,94.69 125.05,94.69 124.92,94.56 124.92,94.45 124.78,94.31 124.59,94.31 124.45,94.45 124.45,94.69 124.32,94.82 123.83,94.82 123.63,94.62 123.63,93.76 123.83,93.55 124.5,93.55 124.89,93.16 124.89,92.88 125.36,92.41 128.73,92.41 130.08,91.06 130.08,84.81 129.67,84.41 129.67,80.83 129.58,80.73 126.1,80.73 125.99,80.62 125.99,80.46 126.1,80.34 129.56,80.34 129.67,80.23 129.67,80.07 129.56,79.96 126.26,79.96 126.14,79.84 126.14,79.68 126.26,79.57 129.56,79.57 129.67,79.46 129.67,79.3 129.56,79.18 126.87,79.18 126.75,79.07 126.75,78.91 126.87,78.8 129.31,78.8 129.42,78.69 129.42,78.53 129.31,78.41 126.6,78.41 125.36,79.66 125.36,84.05 123.88,85.52 113.01,85.52 112.81,85.32 112.81,84.89 112.66,84.74 111.67,84.74 111.46,84.53 110.67,84.53 110.12,83.98 109.04,83.98 108.65,83.58 107.42,83.58 107.12,83.28 104.87,83.28 103.78,82.19 103.78,77.37 103.49,77.08 103.16,77.08 102.57,76.49 v1(102.57,76.19)
DDR4_DIMM1_A16: length 85.8
  L05_SIG2 w0.081: v1(101.77,75.73) 102.23,75.26 103.55,75.26 103.79,75.5 103.79,76.37 104.09,76.68 104.33,76.68 104.56,76.9 104.56,82.44 104.73,82.6 105.93,82.6 106.27,82.94 107.26,82.94 107.56,83.25 108.79,83.25 109.16,83.62 110.27,83.62 110.8,84.15 111.56,84.15 111.79,84.38 115.03,84.38 115.17,84.52 115.17,84.68 115.06,84.79 113.3,84.79 113.19,84.91 113.19,85.07 113.3,85.18 117.45,85.18 117.56,85.07 117.56,84.91 117.45,84.79 115.69,84.79 115.58,84.68 115.58,84.52 115.69,84.41 120.37,84.41 120.48,84.52 120.48,84.68 120.37,84.79 118.1,84.79 117.99,84.91 117.99,85.07 118.1,85.18 123.62,85.18 123.73,85.07 123.73,84.91 123.62,84.79 121.02,84.79 120.91,84.68 120.91,84.52 121.02,84.41 124.21,84.41 125,83.62 125,83.46 124.88,83.35 124.72,83.35 124.06,84.02 123.9,84.02 123.78,83.9 123.78,83.74 124.98,82.55 124.98,79.38 126.35,78.01 129.67,78.01 130.03,78.36 130.03,84 130.44,84.41 130.44,91.19 128.86,92.76 126.87,92.76 126.75,92.88 126.75,93.13 126.64,93.25 126.48,93.25 126.37,93.13 126.37,92.88 126.25,92.76 125.51,92.76 125.23,93.04 125.23,93.3 124.55,93.98 v1(124.04,93.98)
DDR4_DIMM1_A17: length 83.9
  L12_SIG4 w0.089: v1(104.16,77.11) 105.1,77.11 105.56,77.56 105.89,77.56 106.36,78.03 106.71,78.03 106.94,78.26 106.94,82.51 110.61,86.17 110.61,89.89 110.73,90.02 110.91,90.02 111.03,89.89 111.03,88.53 111.15,88.41 111.32,88.41 111.45,88.53 111.45,90.03 110.71,90.77 108.23,90.77 106.25,92.75 106.25,94.4 107.09,95.25 107.09,95.95 108.59,97.44 109.96,97.44 110.23,97.72 110.23,98.07 109.91,98.39 109.43,98.39 109.15,98.67 109.15,100.97 109.4,101.22 109.76,101.22 110.02,101.49 110.02,101.82 110.26,102.06 110.71,102.06 110.9,101.87 111.4,101.87 112.01,102.49 113.35,102.49 113.59,102.73 114.08,102.73 114.23,102.59 114.23,101.59 114.63,101.19 119.07,101.19 119.2,101.32 119.2,101.53 119.07,101.66 118.04,101.66 117.91,101.79 117.91,102 118.04,102.13 119.8,102.13 121.82,104.15 124.28,104.15 124.41,104.02 124.41,103.81 124.28,103.68 122.94,103.68 122.81,103.55 122.81,103.34 122.94,103.21 125.38,103.21 126.32,104.15 128.62,104.15 128.74,104.02 128.74,103.81 128.62,103.68 127.15,103.68 127.02,103.55 127.02,103.34 127.15,103.21 129.24,103.21 130.18,104.15 132.09,104.15 132.21,104.02 132.21,103.81 132.09,103.68 131.44,103.68 131.31,103.55 131.31,103.37 131.44,103.25 133.08,103.25 133.29,103.03 133.29,102.25 131.43,100.39 131.25,100.39 v1(130.84,99.98)
DDR4_DIMM1_ACT_N: length 76.3
  L05_SIG2 w0.081: v1(95.39,73.89) 94.98,74.31 94.98,74.96 95.31,75.29 95.61,75.29 96.04,75.72 96.4,75.72 96.81,76.13 97.19,76.13 97.4,76.34 97.4,82.03 97.84,82.47 97.84,86.28 97.95,86.39 98.11,86.39 98.23,86.28 98.23,83.01 98.34,82.9 98.5,82.9 98.61,83.01 98.61,86.53 98.73,86.64 98.89,86.64 99,86.53 99,83.4 99.11,83.29 99.27,83.29 99.39,83.4 99.39,85.92 99.5,86.03 99.66,86.03 99.77,85.92 99.77,84.19 99.88,84.08 100.04,84.08 100.16,84.19 100.16,86.28 100.04,86.4 99.54,86.4 99.37,86.57 99.37,86.82 99.5,86.95 99.5,87.15 99.75,87.4 100.18,87.4 100.3,87.52 100.71,87.52 100.79,87.61 100.79,87.82 100.71,87.91 100.57,87.91 100.45,88.02 100.45,91.46 100.56,91.57 100.71,91.57 100.81,91.46 100.81,88.37 100.92,88.27 101.07,88.27 101.18,88.37 101.18,92.53 101.28,92.64 101.43,92.64 101.54,92.53 101.54,88.14 101.64,88.04 101.79,88.04 101.9,88.14 101.9,92.58 102,92.69 102.15,92.69 102.26,92.58 102.26,88.55 102.36,88.45 102.51,88.45 102.62,88.55 102.62,92.56 102.72,92.66 102.87,92.66 102.98,92.56 102.98,90.15 103.08,90.05 103.23,90.05 103.34,90.15 103.34,92.86 103.21,93 103.21,93.18 103.41,93.38 103.41,93.52 103.3,93.63 103.03,93.63 102.9,93.5 102.62,93.5 102.47,93.35 102.29,93.35 102.17,93.47 102.06,93.47 101.94,93.6 v1(101.94,93.98)
