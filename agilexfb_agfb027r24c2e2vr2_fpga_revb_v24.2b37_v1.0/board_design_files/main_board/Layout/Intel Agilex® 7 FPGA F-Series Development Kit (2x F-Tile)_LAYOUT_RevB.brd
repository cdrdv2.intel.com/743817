# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM1_ALERT_N: length 81.7
  L12_SIG4 w0.089: v1(104.16,75.27) 104.16,75.55 103.77,75.94 103.77,77.35 104.02,77.6 104.35,77.6 104.78,78.03 105.06,78.03 105.54,78.51 105.87,78.51 106.15,78.79 106.15,82.41 109.09,85.34 109.09,86.25 109.45,86.61 109.45,87.82 109.55,87.92 109.7,87.92 109.8,87.82 109.8,86.4 109.9,86.3 110.04,86.3 110.14,86.4 110.14,90.06 110.04,90.16 109.9,90.16 109.8,90.06 109.8,88.39 109.7,88.29 109.55,88.29 109.45,88.39 109.45,89.97 109.18,90.24 108.07,90.24 105.76,92.55 105.76,95.28 106.04,95.56 106.32,95.56 106.6,95.83 106.6,96.12 107.95,97.47 107.95,97.89 108.05,97.99 108.76,97.99 108.86,98.09 108.86,98.23 108.76,98.33 107.94,98.33 107.84,98.43 107.84,98.64 107.94,98.75 108.55,98.75 108.65,98.85 108.65,98.99 108.55,99.09 107.47,99.09 107.05,99.51 107.05,100.95 106.75,101.24 106.01,101.24 105.84,101.41 105.84,101.67 106.2,102.03 107.88,102.03 107.98,102.13 107.98,102.27 107.88,102.37 106.72,102.37 106.62,102.47 106.62,102.62 106.72,102.72 108,102.72 108.1,102.82 108.1,102.96 108,103.06 106.49,103.06 106.39,103.16 106.39,103.3 106.49,103.4 108.19,103.4 108.31,103.28 110.46,103.28 110.71,103.52 110.71,104.07 110.58,104.19 110.44,104.19 110.34,104.09 110.34,103.76 110.24,103.66 110.1,103.66 110,103.76 110,104.16 109.9,104.26 109.46,104.26 109.36,104.16 109.36,104.02 109.26,103.92 109.12,103.92 109.02,104.02 109.02,104.16 108.92,104.26 108.35,104.26 108.25,104.16 108.25,103.9 108.15,103.8 108,103.8 107.9,103.9 107.9,104.16 107.8,104.26 107.66,104.26 107.56,104.16 107.56,103.9 107.46,103.8 107.32,103.8 107.22,103.9 107.22,104.16 107.12,104.26 106.97,104.26 106.87,104.16 106.87,103.9 106.77,103.8 106.63,103.8 106.53,103.9 106.53,104.16 106.43,104.26 104.32,104.26 104.22,104.16 104.22,103.95 104.32,103.85 105.59,103.85 105.69,103.75 105.69,103.6 105.59,103.5 104.15,103.5 104.05,103.4 104.05,103.23 104.15,103.13 105.59,103.13 105.69,103.03 105.69,102.89 105.59,102.79 104.21,102.79 104.11,102.69 104.11,102.54 104.21,102.44 105.59,102.44 105.69,102.34 105.69,102.2 105.59,102.1 103.83,102.1 103.71,101.98 103.71,101.42 103.81,101.31 103.94,101.31 104.08,101.18 104.08,100.42 v1(103.64,99.98)
DDR4_DIMM1_BA0: length 86.9
  L05_SIG2 w0.081: v1(103.36,77.57) 102.97,77.96 102.97,82.34 103.18,82.55 103.66,82.55 104.73,83.61 106.98,83.61 107.28,83.92 108.51,83.92 108.92,84.33 109.96,84.33 110.52,84.89 111.34,84.89 111.54,85.09 112.1,85.09 112.88,85.88 116.26,85.88 116.47,86.08 116.85,86.08 117.05,85.88 119.97,85.88 120.2,86.11 120.78,86.11 121.01,85.88 121.34,85.88 121.45,85.99 121.45,86.25 121.57,86.36 121.77,86.36 122.26,85.88 125.1,85.88 126.19,84.79 126.19,84.63 126.08,84.52 125.92,84.52 125.09,85.35 124.93,85.35 124.81,85.24 124.81,85.08 125.74,84.15 125.74,81.41 126.04,81.1 129.15,81.1 129.27,81.22 129.27,81.38 129.15,81.49 126.38,81.49 126.27,81.6 126.27,81.76 126.38,81.88 129.18,81.88 129.29,81.99 129.29,82.15 129.18,82.26 126.38,82.26 126.27,82.38 126.27,82.54 126.38,82.65 129.15,82.65 129.27,82.76 129.27,82.92 129.15,83.04 126.38,83.04 126.27,83.15 126.27,83.31 126.38,83.42 129.18,83.42 129.29,83.53 129.29,83.69 129.18,83.81 126.38,83.81 126.27,83.92 126.27,84.08 126.38,84.19 129.21,84.19 129.32,84.31 129.32,84.47 129.21,84.58 126.89,84.58 126.78,84.69 126.78,84.85 126.89,84.97 129.39,84.97 129.72,85.3 129.72,90.93 128.61,92.05 125.2,92.05 124.57,92.69 123.81,92.69 123.62,92.88 123.62,93.26 123.19,93.68 v1(123.19,93.98)
DDR4_DIMM1_BA1: length 82.6
  L12_SIG4 w0.089: v1(122.34,99.98) 121.91,100.41 121.91,101.34 122.17,101.6 122.63,101.6 122.77,101.45 122.77,100.68 123.01,100.44 123.9,100.44 124.02,100.32 124.02,100 124.15,99.87 124.32,99.87 124.44,100 124.44,101.36 124.56,101.48 124.74,101.48 124.86,101.36 124.86,100 124.98,99.87 125.16,99.87 125.28,100 125.28,100.32 125.4,100.44 126,100.44 126.12,100.56 126.12,101.02 126.24,101.15 126.41,101.15 126.54,101.02 126.54,99.76 126.66,99.64 126.83,99.64 126.96,99.76 126.96,100.32 127.08,100.44 127.71,100.44 127.84,100.56 127.84,101.08 127.96,101.2 128.13,101.2 128.26,101.08 128.26,99.77 128.36,99.67 128.64,99.67 128.73,99.76 128.73,100.25 128.92,100.44 129.54,100.44 129.67,100.56 129.67,101.09 129.79,101.21 129.95,101.21 130.07,101.09 130.07,100.56 130.2,100.44 130.41,100.44 130.51,100.54 130.51,102.05 130.39,102.17 128.8,102.17 128.3,102.67 127.56,102.67 127.06,102.17 126.38,102.17 125.94,102.62 125.53,102.62 125.09,102.17 124.57,102.17 124.11,102.63 123.19,102.63 122.73,102.17 120.56,102.17 120.13,101.74 120.13,101.49 119.4,100.76 114.47,100.76 113.21,102.02 112.03,102.02 111.23,101.22 110.26,101.22 110.04,101 110.04,100.71 109.61,100.28 109.61,99.61 110.26,98.96 110.26,98.58 110.72,98.12 110.72,97.55 110.14,96.97 108.6,96.97 107.47,95.85 107.47,95 106.64,94.17 106.64,92.85 108.34,91.15 110.97,91.15 111.85,90.27 111.85,87.49 111.64,87.28 111.18,87.28 110.96,87.05 110.96,85.99 107.75,82.79 107.75,77.85 107.47,77.57 107.2,77.57 106.73,77.11 106.41,77.11 105.96,76.66 105.54,76.66 105.07,76.19 v1(104.16,76.19)
DDR4_DIMM1_BG0: length 84.7
  L05_SIG2 w0.081: v1(102.79,93.98) 103.83,93.98 104.57,94.72 105.71,94.72 105.94,94.49 106.3,94.49 106.58,94.77 108.4,94.77 109.18,94 109.18,92.87 109.38,92.66 110.7,92.66 110.85,92.81 110.85,93.22 111.36,93.73 111.36,94.16 111.64,94.44 113.18,94.44 113.46,94.16 113.46,92.84 113.67,92.64 120.05,92.64 120.38,92.31 124.44,92.31 125.05,91.7 128.48,91.7 129.37,90.81 129.37,86.36 129.13,86.12 126.51,86.12 126.4,86.01 126.4,85.85 126.51,85.73 129.18,85.73 129.29,85.62 129.29,85.46 129.18,85.35 126.22,85.35 125.33,86.24 122.56,86.24 122.08,86.72 122.08,86.92 122.31,87.15 122.31,87.33 122.08,87.56 121.88,87.56 121.6,87.28 121.27,87.28 120.99,87 120.99,86.67 120.81,86.49 119.95,86.49 119.84,86.39 119.44,86.39 119.21,86.62 118.96,86.62 118.73,86.39 117.94,86.39 117.74,86.59 117.58,86.59 117.38,86.39 117.23,86.39 117.02,86.59 117.02,87 116.72,87.3 116.44,87.3 116.26,87.48 115.72,87.48 115.63,87.39 115.63,87.16 115.72,87.07 116.05,87.07 116.16,86.96 116.16,86.41 115.98,86.24 112.73,86.24 111.94,85.45 111.4,85.45 111.2,85.25 110.4,85.25 109.84,84.69 108.8,84.69 108.37,84.25 107.14,84.25 106.84,83.95 104.55,83.95 103.51,82.91 102.9,82.91 102.18,82.19 102.18,76.02 102.48,75.73 v1(103.36,75.73)
DDR4_DIMM1_BG1: length 76.6
  L12_SIG4 w0.089: v1(102.79,99.98) 103.21,99.56 103.9,99.56 104.1,99.76 104.43,99.76 104.57,99.9 104.57,100.91 104.71,101.04 104.85,101.04 104.95,100.94 104.95,99.73 105.06,99.62 105.06,99.48 104.92,99.34 104.22,99.34 104.09,99.22 103.21,99.22 103.11,99.12 103.11,98.97 103.21,98.87 103.97,98.87 104.07,98.77 104.07,98.63 103.97,98.53 103.24,98.53 103.14,98.43 103.14,98.29 103.24,98.19 103.96,98.19 104.06,98.09 104.06,97.95 103.96,97.84 103.25,97.84 103.15,97.74 103.15,97.6 103.25,97.5 104.03,97.5 104.13,97.4 104.13,97.26 104.03,97.16 103.25,97.16 103.15,97.06 103.15,96.92 103.25,96.82 104.03,96.82 104.13,96.72 104.13,96.57 104.03,96.47 103.25,96.47 103.15,96.37 103.15,94.73 103.6,94.29 103.6,92.78 103.05,92.23 103.05,89.23 102.95,89.13 102.81,89.13 102.71,89.23 102.71,91.43 102.61,91.53 102.46,91.53 102.36,91.43 102.36,89.23 102.26,89.13 102.12,89.13 102.02,89.23 102.02,90.77 101.92,90.87 101.78,90.87 101.68,90.77 101.68,86.99 101.78,86.89 101.92,86.89 102.02,86.99 102.02,88.49 102.12,88.59 102.26,88.59 102.36,88.49 102.36,86.99 102.46,86.89 102.61,86.89 102.71,86.99 102.71,88.57 102.81,88.67 102.95,88.67 103.05,88.57 103.05,86.55 102.95,86.45 101.78,86.45 101.68,86.35 101.68,85.09 101.78,84.99 101.92,84.99 102.02,85.09 102.02,85.89 102.12,85.99 102.26,85.99 102.36,85.89 102.36,84.46 102.46,84.36 102.61,84.36 102.71,84.46 102.71,85.89 102.81,85.99 102.95,85.99 103.05,85.89 103.05,85.7 103.15,85.6 104.09,85.6 104.19,85.5 104.19,85.36 104.09,85.26 103.15,85.26 103.05,85.16 103.05,85.02 103.15,84.92 104.09,84.92 104.19,84.82 104.19,84.68 104.09,84.58 103.15,84.58 103.05,84.48 103.05,84.33 103.15,84.23 104.09,84.23 104.19,84.13 104.19,83.99 104.09,83.89 103.15,83.89 103.05,83.79 103.05,83.61 103.15,83.51 104.11,83.51 104.21,83.41 104.21,83.27 104.11,83.17 103.38,83.17 103.28,83.07 103.28,82.92 103.38,82.82 104.11,82.82 104.21,82.72 104.21,82.58 104.11,82.48 103.91,82.48 103.77,82.34 103.77,80.17 103.46,79.86 103.18,79.86 102.71,79.39 102.41,79.39 101.96,78.95 101.63,78.95 101.18,78.49 100.77,78.49 100.34,78.06 100.03,78.06 99.55,77.57 99.22,77.57 98.77,77.13 98.52,77.13 98.05,76.66 97.59,76.66 97.14,76.2 96.83,76.2 96.55,75.92 96.55,75.63 v1(96.19,75.27)
DDR4_DIMM1_C0: length 85.2
  L05_SIG2 w0.081: v1(133.39,93.98) 133.19,94.19 132.93,94.19 132.75,94.01 132.4,94.01 131.95,94.47 131.6,94.47 131.38,94.24 131.2,94.24 131.05,94.39 130.82,94.39 130.66,94.24 130.49,94.24 130.26,94.47 129.85,94.47 129.55,94.17 129.55,93.96 129.39,93.8 128.84,93.8 128.71,93.93 128.71,94.39 128.58,94.52 128.02,94.52 127.89,94.38 127.89,93.28 128.05,93.12 129.01,93.12 129.75,92.38 130.54,92.38 130.78,92.14 130.78,84.04 130.89,83.92 131.05,83.92 131.17,84.04 131.17,86.1 131.28,86.21 131.44,86.21 131.55,86.1 131.55,83.72 131.33,83.49 131.33,78.09 131.19,77.96 131,77.96 130.86,78.09 130.86,83.38 130.73,83.52 130.54,83.52 130.4,83.38 130.4,77.84 130.11,77.55 126.32,77.55 124.59,79.28 124.59,82.4 124.34,82.65 123.98,82.65 123.79,82.84 123.79,83.2 123.6,83.39 123.25,83.39 123.03,83.61 123.03,83.81 122.82,84.03 111.92,84.03 111.67,83.77 110.95,83.77 110.46,83.28 109.3,83.28 108.94,82.91 107.86,82.91 107.53,82.58 106.41,82.58 105.95,82.12 105.62,82.12 105.35,81.85 105.35,79.96 105.04,79.65 105.04,78.06 105.35,77.74 105.35,76.48 105.05,76.17 104.78,76.17 104.55,75.94 104.55,75.08 104.22,74.75 101.49,74.75 v1(100.97,75.27)
DDR4_DIMM1_C1: length 83.1
  L12_SIG4 w0.089: v1(100.18,74.81) 101.15,74.81 101.61,75.26 101.94,75.26 102.4,74.81 102.72,74.81 103.16,75.24 103.57,75.24 104,74.81 104.32,74.81 104.78,75.26 105.09,75.26 105.57,75.75 105.9,75.75 106.36,76.2 106.69,76.2 107.12,76.63 107.47,76.63 107.93,77.09 108.24,77.09 108.54,77.4 108.54,83.06 112.19,86.71 112.19,88.04 112.58,88.43 112.58,90.26 111.34,91.5 108.77,91.5 107.46,92.81 107.46,94.12 107.9,94.56 107.9,95.79 108.71,96.6 110.41,96.6 110.58,96.42 110.58,96.07 110.66,95.98 110.98,95.98 111.12,96.13 111.12,96.74 111.25,96.87 111.44,96.87 111.57,96.74 111.57,96.13 111.7,96 111.89,96 112.01,96.13 112.01,98.2 111.89,98.33 111.7,98.33 111.57,98.2 111.57,97.42 111.44,97.29 111.25,97.29 111.12,97.42 111.12,98.33 110.73,98.72 110.73,99.08 110.04,99.77 110.04,100.21 110.27,100.44 111.53,100.44 111.7,100.6 111.7,101.14 111.77,101.22 113.27,101.22 114.15,100.33 119.51,100.33 120.38,101.2 120.89,101.2 121.07,101.03 121.07,100.51 122.37,99.21 122.37,98.13 122.49,98.01 122.66,98.01 122.78,98.13 122.78,99.43 122.91,99.55 123.08,99.55 123.2,99.43 123.2,98.57 123.33,98.44 124.42,98.44 124.54,98.57 124.54,99.37 124.67,99.5 125.82,99.5 125.94,99.37 125.94,99.12 125.82,98.99 125.09,98.99 124.96,98.87 124.96,98.57 125.09,98.44 127,98.44 127.13,98.57 127.13,99.36 127.25,99.48 127.64,99.48 127.76,99.36 127.76,98.57 127.88,98.44 128.64,98.44 129.59,99.39 131.89,99.39 132.48,99.98 v1(133.39,99.98)
DDR4_DIMM1_CK_N0: length 77.2
  L05_SIG2 w0.076: 101.35,82.31 101.35,82.29 101.35,82.29 101.35,82.19 101.53,81.82 arc(101.56,81.64) 101.49,81.48 101.43,81.39 arc(101.38,81.25) 101.41,81.11 101.48,81 arc(101.54,80.79) 101.49,80.58 101.41,80.44 arc(101.37,80.31) 101.42,80.19 101.48,80.1 arc(101.54,79.9) 101.5,79.7 101.41,79.52 arc(101.38,79.39) 101.42,79.26 101.46,79.19 arc(101.47,79.19) 101.47,79.18 arc(101.53,78.96) 101.48,78.74 101.43,78.63 arc(101.39,78.49) 101.42,78.35 101.49,78.22 arc(101.54,78.01) 101.48,77.8 101.42,77.7 arc(101.38,77.58) 101.41,77.46 101.49,77.29 arc(101.53,77.07) 101.47,76.86 101.43,76.8 arc(101.38,76.65) 101.43,76.49 101.49,76.39 arc(101.55,76.18) 101.48,75.97 101.43,75.9 arc(101.23,75.71) 100.97,75.64 100.87,75.64 arc(100.77,75.61) 100.7,75.54 100.64,75.44 arc(100.45,75.25) 100.18,75.18 100.09,75.18 arc(99.97,75.15) 99.89,75.06 99.8,74.92 arc(99.65,74.76) 99.43,74.7 99.23,74.7 arc(99.09,74.74) 98.99,74.84 98.96,74.89 arc(98.89,74.95) 98.8,74.94 v1(98.58,74.81)
  L05_SIG2 w0.081: 101.35,82.31 101.35,82.4 102.42,83.47 103.18,83.47 104.22,84.51 106.64,84.51 106.94,84.81 108.17,84.81 108.6,85.25 109.63,85.25 110.14,85.75 110.14,86.5 110.28,86.64 110.67,86.64 110.78,86.54 110.78,86.21 110.98,86.01 111.74,86.01 112.12,86.39 112.12,88.04 112.35,88.27 112.9,88.27 113.08,88.09 113.08,87.04 113.33,86.79 114.64,86.79 114.9,87.05 114.9,88.02 115.15,88.27 115.5,88.27 115.73,88.04 116.19,88.04 116.42,88.27 116.97,88.27 117.17,88.07 117.17,87.63 117.56,87.25 118.21,87.25 118.52,87.55 119.51,87.55 119.94,87.12 120.35,87.12 120.99,87.76 120.99,88.01 121.24,88.27 121.72,88.27 121.88,88.12 122.31,88.12 122.46,88.27 122.94,88.27 123.12,88.09 123.12,87.03 123.35,86.79 124.75,86.79 125,87.05 125,87.54 124.75,87.79 124.26,87.79 124.09,87.96 124.09,88.26 124.26,88.42 125.43,88.42 125.79,88.06 126.25,88.06 126.45,88.27 127.15,88.27 127.36,88.06 127.36,87.75 127.06,87.45 127.06,86.92 127.31,86.67 128.56,86.67 128.79,86.9 128.79,87.38 128.43,87.73 128.43,88.04 128.79,88.4 128.79,88.84 128.57,89.06 127.93,89.06 127.82,89.17 127.82,89.6 127.93,89.71 128.53,89.71 128.79,89.97 128.79,90.58 128.23,91.14 124.85,91.14 124.24,91.75 120.17,91.75 119.84,92.08 112.81,92.08 112.65,92.24 112.65,93.64 v1(112.99,93.98)
DDR4_DIMM1_CK_N1: length 83
  L12_SIG4 w0.076: v1(103.36,73.89) 103.62,73.68 103.63,73.61 103.6,73.56 arc(103.57,73.43) 103.6,73.3 103.75,73.03 arc(103.88,72.91) 104.06,72.86 104.23,72.86 arc(104.4,72.9) 104.53,73.01 104.69,73.24 arc(104.78,73.31) 104.9,73.34 105.06,73.34 arc(105.26,73.39) 105.39,73.54 105.46,73.67 arc(105.55,73.77) 105.69,73.81 105.82,73.81 arc(105.99,73.85) 106.13,73.97 106.29,74.17 arc(106.37,74.23) 106.47,74.26 106.54,74.26 arc(106.78,74.31) 106.97,74.44 107.13,74.61 arc(107.2,74.67) 107.3,74.69 107.43,74.69 arc(107.63,74.74) 107.77,74.89 107.83,75.01 arc(107.94,75.13) 108.1,75.18 108.18,75.18 arc(108.4,75.24) 108.58,75.39 108.65,75.5 arc(108.76,75.6) 108.91,75.64 109.02,75.64 arc(109.21,75.69) 109.36,75.83 109.46,75.99 arc(109.56,76.08) 109.68,76.11 109.78,76.11 arc(109.97,76.16) 110.12,76.28 110.19,76.38 arc(110.27,76.63) 110.2,76.89 110.18,76.93 arc(110.13,77.06) 110.17,77.2 110.24,77.34 arc(110.3,77.58) 110.22,77.83 110.17,77.91 arc(110.13,78.04) 110.18,78.16 110.27,78.3 arc(110.34,78.52) 110.27,78.74 110.21,78.81 arc(110.17,78.94) 110.21,79.08 110.24,79.13 arc(110.31,79.34) 110.27,79.56 110.2,79.71 arc(110.16,79.87) 110.2,80.02 110.25,80.14 arc(110.29,80.35) 110.24,80.55 110.2,80.62 arc(110.16,80.8) 110.21,80.98 110.24,81.03 arc(110.29,81.25) 110.23,81.46 110.17,81.55 arc(110.13,81.7) 110.18,81.85 110.24,81.93 arc(110.34,82.14) 110.38,82.38 110.38,82.64 110.38,82.64 110.38,82.66
  L12_SIG4 w0.089: 110.38,82.66 110.38,82.8 114.22,86.64 114.22,89.98 114.35,90.11 118.58,90.11 118.82,90.35 118.82,90.85 118.58,91.09 114.08,91.09 113.95,91.22 113.95,91.56 114.08,91.69 118.64,91.69 118.88,91.93 118.88,92.43 118.64,92.66 109.34,92.66 109.12,92.88 109.12,94.33 109.36,94.57 110.49,94.57 110.96,94.09 111.66,94.09 111.97,94.4 113.22,94.4 113.51,94.11 114.2,94.11 114.53,94.45 123.45,94.45 123.76,94.76 123.76,96.42 123.42,96.76 121.7,96.76 120.96,97.5 120.96,98.49 119.93,99.53 113.58,99.53 113.33,99.28 112.9,99.28 112.77,99.42 112.77,99.75 v1(112.99,99.98)
DDR4_DIMM1_CK_P0: length 77.2
  L05_SIG2 w0.076: v1(99.38,75.27) 99.15,75.14 arc(99.1,75.07) 99.11,74.99 99.14,74.93 arc(99.18,74.89) 99.23,74.88 99.43,74.88 arc(99.56,74.91) 99.65,75 99.74,75.15 arc(99.88,75.3) 100.09,75.36 100.18,75.36 arc(100.36,75.4) 100.49,75.53 100.55,75.63 arc(100.68,75.77) 100.87,75.82 100.97,75.82 arc(101.15,75.86) 101.28,75.99 101.33,76.07 arc(101.37,76.19) 101.34,76.3 101.28,76.4 arc(101.21,76.65) 101.28,76.9 101.32,76.96 arc(101.36,77.08) 101.33,77.21 101.25,77.38 arc(101.21,77.59) 101.27,77.79 101.32,77.89 arc(101.36,78.01) 101.33,78.14 101.26,78.27 arc(101.21,78.49) 101.27,78.71 101.32,78.82 arc(101.36,78.95) 101.32,79.09 arc(101.32,79.09) 101.31,79.1 arc(101.31,79.1) 101.31,79.1 101.27,79.17 arc(101.2,79.38) 101.25,79.61 101.34,79.78 arc(101.37,79.89) 101.33,80 101.27,80.09 arc(101.2,80.31) 101.25,80.53 101.33,80.67 arc(101.36,80.79) 101.33,80.91 101.26,81.02 arc(101.2,81.26) 101.29,81.5 101.35,81.58 arc(101.38,81.66) 101.37,81.74 101.17,82.15 101.17,82.29 101.17,82.29 101.17,82.31
  L05_SIG2 w0.081: 101.17,82.31 101.17,82.47 102.34,83.65 103.11,83.65 104.15,84.69 106.56,84.69 106.87,85 108.09,85 108.52,85.43 109.56,85.43 109.96,85.83 109.96,86.58 110.21,86.83 110.75,86.83 110.96,86.61 110.96,86.29 111.06,86.19 111.67,86.19 111.94,86.46 111.94,88.11 112.28,88.45 112.98,88.45 113.27,88.17 113.27,87.12 113.41,86.98 114.57,86.98 114.72,87.13 114.72,88.1 115.07,88.45 115.58,88.45 115.81,88.22 116.11,88.22 116.34,88.45 117.05,88.45 117.36,88.14 117.36,87.71 117.63,87.43 118.14,87.43 118.44,87.73 119.59,87.73 120.02,87.31 120.28,87.31 120.8,87.84 120.8,88.09 121.17,88.45 121.8,88.45 121.95,88.3 122.23,88.3 122.38,88.45 123.01,88.45 123.3,88.17 123.3,87.1 123.43,86.98 124.67,86.98 124.82,87.12 124.82,87.46 124.67,87.61 124.18,87.61 123.91,87.88 123.91,88.33 124.18,88.6 125.51,88.6 125.86,88.25 126.17,88.25 126.37,88.45 127.23,88.45 127.54,88.14 127.54,87.68 127.24,87.38 127.24,87 127.39,86.85 128.48,86.85 128.61,86.98 128.61,87.3 128.25,87.66 128.25,88.12 128.61,88.47 128.61,88.76 128.49,88.88 127.86,88.88 127.64,89.1 127.64,89.67 127.86,89.89 128.45,89.89 128.6,90.05 128.6,90.51 128.16,90.96 124.77,90.96 124.16,91.56 120.1,91.56 119.77,91.89 112.74,91.89 112.47,92.16 112.47,92.27 112.37,92.36 112.23,92.36 112.13,92.46 112.13,92.59 112.24,92.7 112.38,92.7 112.47,92.79 112.47,93.66 v1(112.14,93.98)
DDR4_DIMM1_CK_P1: length 83
  L12_SIG4 w0.076: v1(104.16,73.43) 103.85,73.55 103.79,73.54 103.75,73.47 arc(103.74,73.43) 103.75,73.39 103.91,73.12 arc(103.97,73.06) 104.06,73.04 104.23,73.04 arc(104.32,73.06) 104.39,73.12 104.55,73.34 arc(104.7,73.47) 104.9,73.52 105.06,73.52 arc(105.16,73.54) 105.23,73.62 105.3,73.75 arc(105.46,73.92) 105.69,73.99 105.82,73.99 arc(105.92,74.01) 105.99,74.07 106.15,74.28 arc(106.29,74.39) 106.47,74.43 106.54,74.43 arc(106.7,74.47) 106.84,74.57 107,74.73 arc(107.13,74.83) 107.3,74.87 107.43,74.87 arc(107.54,74.9) 107.61,74.97 107.67,75.1 arc(107.85,75.29) 108.1,75.36 108.18,75.36 arc(108.32,75.39) 108.43,75.49 108.5,75.6 arc(108.68,75.76) 108.91,75.82 109.02,75.82 arc(109.13,75.84) 109.21,75.92 109.31,76.09 arc(109.47,76.24) 109.68,76.29 109.78,76.29 arc(109.89,76.32) 109.97,76.39 110.04,76.48 arc(110.09,76.64) 110.05,76.79 110.03,76.83 arc(109.95,77.06) 110.01,77.29 110.08,77.42 arc(110.12,77.58) 110.07,77.73 110.02,77.81 arc(109.96,78.04) 110.03,78.26 110.13,78.4 arc(110.16,78.52) 110.12,78.63 110.07,78.7 arc(109.99,78.94) 110.06,79.18 110.09,79.23 arc(110.14,79.35) 110.11,79.48 110.04,79.63 arc(109.99,79.87) 110.04,80.1 110.09,80.21 arc(110.12,80.34) 110.08,80.47 110.05,80.54 arc(109.98,80.81) 110.06,81.07 110.08,81.12 arc(110.11,81.24) 110.08,81.36 110.02,81.46 arc(109.95,81.71) 110.03,81.95 110.09,82.03 arc(110.17,82.2) 110.2,82.38 110.2,82.64 110.19,82.64 110.19,82.66
  L12_SIG4 w0.089: 110.19,82.66 110.19,82.88 110.61,83.3 110.61,83.44 110.54,83.51 110.54,83.65 110.64,83.75 110.78,83.75 110.85,83.68 111,83.68 114.03,86.72 114.03,90.06 114.27,90.3 118.5,90.3 118.63,90.43 118.63,90.77 118.5,90.9 114,90.9 113.76,91.14 113.76,91.64 114,91.88 118.56,91.88 118.69,92 118.69,92.35 118.56,92.47 109.26,92.47 108.93,92.8 108.93,94.41 109.28,94.76 110.57,94.76 111.04,94.28 111.58,94.28 111.89,94.59 113.3,94.59 113.59,94.3 114.12,94.3 114.45,94.64 123.37,94.64 123.57,94.84 123.57,96.34 123.34,96.57 121.62,96.57 120.77,97.42 120.77,98.41 119.85,99.33 113.66,99.33 113.41,99.09 112.83,99.09 112.58,99.34 112.58,99.88 112.48,99.98 v1(112.14,99.98)
DDR4_DIMM1_CKE0: length 71.3
  L12_SIG4 w0.089: v1(100.24,93.98) 99.96,93.7 99.96,93.41 99.86,93.31 99.72,93.31 99.62,93.41 99.62,94 99.52,94.1 99.37,94.1 99.27,94 99.27,93.26 99.17,93.15 99.03,93.15 98.93,93.26 98.93,93.48 98.83,93.58 98.24,93.58 98.14,93.47 98.14,93.14 98.04,93.04 97.9,93.04 97.8,93.14 97.8,93.45 97.7,93.55 97.56,93.55 97.45,93.44 97.45,91.87 97.35,91.77 97.21,91.77 97.11,91.87 97.11,93.45 97.01,93.55 96.86,93.55 96.76,93.45 96.76,91.87 96.66,91.77 96.52,91.77 96.42,91.87 96.42,93.4 96.32,93.5 96.18,93.5 96.08,93.4 96.08,89.69 96.18,89.59 96.32,89.59 96.42,89.69 96.42,91.26 96.52,91.36 96.66,91.36 96.76,91.26 96.76,89.69 96.86,89.59 97.01,89.59 97.11,89.69 97.11,91.26 97.21,91.36 97.35,91.36 97.45,91.26 97.45,87.38 97.35,87.28 97.21,87.28 97.11,87.38 97.11,89.08 97.01,89.18 96.86,89.18 96.76,89.08 96.76,87.38 96.66,87.28 96.52,87.28 96.42,87.38 96.42,89.09 96.32,89.19 96.18,89.19 96.08,89.09 96.08,86.7 96.42,86.35 96.42,86.08 96.08,85.73 96.08,85.39 96.54,84.93 96.82,84.93 96.92,85.03 96.92,86.47 97.02,86.57 97.16,86.57 97.26,86.47 97.26,85.01 97.36,84.9 97.5,84.9 97.6,85.01 97.6,86.23 97.7,86.33 97.85,86.33 97.95,86.23 97.95,82.71 97.85,82.61 97.7,82.61 97.6,82.71 97.6,84.33 97.5,84.43 97.36,84.43 97.26,84.33 97.26,82.95 97.16,82.85 97.02,82.85 96.92,82.95 96.92,84.33 96.82,84.43 96.68,84.43 96.58,84.33 96.58,76.84 96.33,76.59 95.99,76.59 95.59,76.18 95.25,76.18 94.82,75.76 94.49,75.76 94.19,75.46 94.19,74.19 94.5,73.88 94.8,73.88 95.3,73.37 95.53,73.37 95.87,73.03 96.24,73.03 96.7,72.57 97.2,72.57 97.55,72.92 97.55,73.19 v1(97.79,73.43)
DDR4_DIMM1_CKE1: length 73.2
  L14_SIG5 w0.081: v1(99.39,99.98) 99.64,99.73 99.64,99.27 100.23,98.67 100.49,98.67 101,98.16 101,97.7 101.92,96.78 102.35,96.78 103.58,95.54 106.3,95.54 106.66,95.18 106.66,94.72 106.41,94.47 103.42,94.47 103.09,94.8 103.09,95.02 98.94,99.16 98.94,100.15 97.9,101.19 95.79,101.19 95.54,101.44 95.54,101.75 95.3,101.99 94.79,101.99 94.53,101.73 94.08,101.73 93.77,102.03 92.31,102.03 92.1,101.83 91.73,101.83 90.73,100.83 89.53,100.83 88.78,100.08 88.78,99.54 87.93,98.69 87.93,93.82 88.73,93.02 89.73,93.02 93.14,89.61 94.23,89.61 96.16,87.68 96.94,87.68 97.48,87.14 97.48,86.67 98.93,85.22 100.07,85.22 102.98,82.31 102.98,76.91 102.75,76.69 102.45,76.69 101.96,76.2 101.53,76.2 101.12,76.61 100.74,76.61 100.29,76.15 99.98,76.15 99.47,75.64 99.09,75.64 98.71,75.26 98.38,75.26 97.92,74.81 97.59,74.81 96.99,74.2 v1(96.99,73.89)
DDR4_DIMM1_CS_N0: length 77.2
  L05_SIG2 w0.081: v1(125.74,93.98) 126.21,94.45 126.64,94.45 127.06,94.87 128.76,94.87 129.01,94.62 129.42,94.62 129.62,94.82 132.32,94.82 132.57,94.57 133.37,94.57 133.87,94.07 133.87,83.39 132.87,82.4 132.87,77.63 131.35,76.1 125.79,76.1 123.07,78.82 123.07,81.36 121.88,82.55 112.43,82.55 111.58,81.71 111.15,81.71 110.69,81.25 110.34,81.25 109.88,80.79 109.55,80.79 109.08,80.33 108.83,80.33 108.52,80.01 108.52,74.62 108.26,74.36 107.94,74.36 107.65,74.07 107.65,73.48 106.65,72.48 106.3,72.48 105.79,71.97 105.55,71.97 105.23,71.66 104.76,71.66 104.31,71.21 103.88,71.21 103.51,71.58 103.26,71.58 102.75,72.09 102.5,72.09 101.99,71.58 101.61,71.58 101.23,71.96 100.7,71.96 100.34,71.6 100.04,71.6 99.58,72.06 99.25,72.06 98.78,72.52 98.43,72.52 98,72.95 97.66,72.95 97.19,73.43 v1(96.19,73.43)
DDR4_DIMM1_CS_N1: length 74.7
  L05_SIG2 w0.081: v1(129.99,93.98) 130.26,93.98 130.44,93.81 130.44,93.28 130.55,93.17 130.75,93.17 130.87,93.28 130.87,93.77 130.98,93.88 131.19,93.88 131.3,93.77 131.3,93.07 131.58,92.79 131.96,92.79 132.33,92.42 132.33,90.44 132.44,90.33 132.6,90.33 132.72,90.44 132.72,92.17 132.83,92.28 132.99,92.28 133.1,92.17 133.1,87.39 132.99,87.28 132.83,87.28 132.72,87.39 132.72,89.7 132.6,89.82 132.44,89.82 132.33,89.7 132.33,83.28 132.11,83.06 132.11,77.88 131.05,76.81 126.07,76.81 123.83,79.05 123.83,81.66 122.18,83.31 112.2,83.31 111.89,83.01 111.16,83.01 110.69,82.54 109.57,82.54 109.15,82.12 108.72,82.12 108.28,81.68 107.95,81.68 107.52,81.25 107.21,81.25 106.94,80.98 106.94,75.51 106.66,75.22 106.37,75.22 106.15,75.01 106.15,74.22 105.84,73.9 105.58,73.9 105.15,73.48 104.86,73.48 104.36,72.98 104.02,72.98 103.57,73.43 v1(99.38,73.43)
DDR4_DIMM1_DBI_N0: length 83.5
  L07_SIG3 w0.076: 99.75,82.29 99.75,82.27 99.75,82.26 99.75,82.23 arc(99.76,82.14) 99.81,82.05 arc(99.84,82.01) 99.87,81.96 99.9,81.89 arc(99.93,81.82) 99.94,81.76 arc(99.94,81.61) 99.88,81.47 99.79,81.33 arc(99.78,81.31) 99.78,81.28 arc(99.78,81.21) 99.81,81.15 99.87,81.03 arc(99.93,80.8) 99.88,80.56 99.84,80.48 arc(99.8,80.32) 99.85,80.16 99.89,80.08 99.92,79.98 arc(99.94,79.85) 99.92,79.73 99.91,79.7 99.84,79.56 arc(99.82,79.53) 99.81,79.49 99.81,79.49 arc(99.79,79.43) 99.79,79.38 arc(99.8,79.31) 99.81,79.24 arc(99.84,79.2) 99.87,79.16 99.91,79.12 arc(99.99,79.06) 100.1,79.04 100.19,79.04 arc(100.38,79) 100.54,78.89 100.71,78.72 arc(100.81,78.52) 100.76,78.3 100.73,78.26 100.76,78.15 v1(100.97,78.03)
  L07_SIG3 w0.089: v1(55.19,93.98) 55.53,94.31 55.53,94.5 55.41,94.61 55.27,94.61 54.65,94 54.65,93.56 54.8,93.41 54.97,93.41 55.05,93.5 55.22,93.5 55.33,93.38 55.33,93.22 55.24,93.13 55.24,92.97 55.4,92.81 55.4,92.43 55.58,92.26 56.23,92.26 56.84,91.64 56.84,84.23 57.02,84.05 58.69,84.05 59.24,83.5 59.24,82.19 60.04,81.39 60.04,81.09 59.84,80.89 59.84,80.65 60.09,80.4 60.31,80.4 60.74,80.83 61.59,80.83 61.76,81 62.16,81 62.59,80.57 62.59,80.19 61.53,79.14 61.53,78.9 61.8,78.64 62.05,78.64 63.2,79.8 63.67,79.8 64.2,79.27 64.2,78.86 63.03,77.7 63.03,77.46 63.28,77.22 63.67,77.22 64.74,78.29 65.11,78.29 65.42,77.98 65.42,77.62 65.24,77.44 65.24,77.22 65.37,77.1 65.58,77.1 65.85,77.37 66.19,77.37 66.55,77.01 66.55,76.7 66.87,76.38 67.99,76.38 68.27,76.09 68.27,75.63 68,75.36 67.24,75.36 67.13,75.26 67.13,74.87 67.27,74.74 68.24,74.74 68.45,74.95 69.08,74.95 70.76,76.63 71.1,76.63 71.47,77 73.67,77 75.87,79.2 75.87,80.11 79.89,84.13 95.06,84.13 96.4,82.79 99.44,82.79 99.75,82.48 99.75,82.29
DDR4_DIMM1_DBI_N1: length 78.3
  L07_SIG3 w0.076: v1(108.94,80.79) 108.68,80.64 108.58,80.67 108.55,80.72 arc(108.44,80.83) 108.29,80.87 108.13,80.88 arc(108.13,80.88) 108.13,80.88 108.12,80.88 arc(107.89,80.97) 107.79,81.21 107.79,81.33 arc(107.79,81.37) 107.81,81.42 107.86,81.5 arc(107.91,81.73) 107.85,81.94 107.82,81.99 arc(107.78,82.08) 107.77,82.17 107.77,82.32 107.77,82.33 107.77,82.34
  L07_SIG3 w0.089: v1(64.54,93.98) 64.86,94.3 64.86,94.55 65.09,94.78 65.47,94.78 66.01,94.24 66.01,93.52 64.66,92.17 64.66,91.81 64.87,91.61 65.11,91.61 66.34,90.38 66.34,88.79 66.46,88.67 66.77,88.67 66.89,88.79 66.89,89.85 67.15,90.11 67.92,90.11 68.88,91.07 71.96,91.07 72.49,90.54 73.29,90.54 74.01,89.82 74.63,89.82 74.84,89.61 74.84,89.34 74.45,88.94 74.45,88.83 74.62,88.65 74.77,88.65 75.97,89.85 76.34,89.85 76.62,89.57 76.62,89.18 75,87.55 75,87.26 75.21,87.05 75.87,87.05 77.23,88.41 77.23,89.51 77.55,89.84 86.33,89.84 86.99,90.5 96.45,90.5 96.71,90.23 96.71,89.23 96.87,89.08 97.13,89.08 97.28,89.23 97.28,90.23 97.55,90.5 97.93,90.5 98.19,90.23 98.19,88.4 98.35,88.25 98.59,88.25 98.75,88.4 98.75,90.23 99.01,90.5 99.42,90.5 99.69,90.23 99.69,89.1 99.84,88.95 100.03,88.95 100.19,89.1 100.19,90.23 100.45,90.5 100.75,90.5 101.18,90.06 101.18,89.48 101.29,89.38 101.86,89.38 102.75,88.49 102.75,86.47 103.84,85.38 105.14,85.38 107.77,82.75 107.77,82.34
DDR4_DIMM1_DBI_N2: length 85.2
  L07_SIG3 w0.076: v1(118.5,80.79) 118.25,80.64 118.14,80.67 118.1,80.75 arc(118.08,80.84) 118.12,80.93 118.29,81.1 arc(118.35,81.14) 118.42,81.16 118.54,81.16 arc(118.75,81.21) 118.91,81.34 119.04,81.5 arc(119.07,81.54) 119.11,81.57 119.11,81.57 arc(119.19,81.61) 119.28,81.62 119.3,81.62 arc(119.54,81.68) 119.74,81.82 arc(119.86,82.01) 119.9,82.23 119.9,82.32 119.91,82.33 119.91,82.35
  L07_SIG3 w0.089: 119.91,82.35 119.91,82.64 120.44,83.17 120.44,89.71 117.66,92.49 117.66,93.84 116.34,95.16 116.34,100.5 115.3,101.54 115.3,102.12 114.98,102.44 114.57,102.44 111.93,105.08 109.38,105.08 108.34,106.11 101.55,106.11 101.34,105.9 99.63,105.9 99.28,106.25 97.89,106.25 97.47,105.83 97.01,105.83 96.72,106.13 95.82,106.13 95.52,105.83 94.21,105.83 93.79,106.25 89.01,106.25 88.77,106.01 88.77,105.63 88.65,105.5 88.06,105.5 87.94,105.63 87.94,106.01 87.7,106.25 86.3,106.25 86.06,106.01 86.06,105.59 85.93,105.46 85.26,105.46 85.14,105.59 85.14,106.01 84.9,106.25 84.19,106.25 83.95,106.01 83.95,105.59 83.83,105.46 83.32,105.46 83.19,105.59 83.19,106.01 82.95,106.25 77.73,106.25 73.31,101.83 73.31,101.37 72.3,100.36 72.3,99.91 72.81,99.4 72.81,99.17 72.31,98.68 72.31,95.96 72.66,95.61 73.84,95.61 74.16,95.29 74.16,94.25 v1(73.89,93.98)
DDR4_DIMM1_DBI_N3: length 58
  L07_SIG3 w0.076: 112.56,82.26 112.56,82.25 112.55,82.24 112.55,82.16 arc(112.56,82.08) 112.6,81.99 112.63,81.94 arc(112.69,81.73) 112.64,81.5 112.59,81.42 arc(112.57,81.37) 112.57,81.33 112.57,81.21 arc(112.67,80.97) 112.9,80.88 112.91,80.88 arc(112.91,80.88) 112.92,80.88 113.07,80.87 arc(113.22,80.83) 113.33,80.72 113.36,80.67 113.46,80.64 v1(113.72,80.79)
  L07_SIG3 w0.089: 112.56,82.26 112.56,82.38 112.87,82.7 112.87,84.39 110.94,86.32 110.94,88.54 107.52,91.96 106.61,91.96 105.94,92.63 105.94,94.36 105.77,94.53 105.77,95 105.47,95.3 104.78,95.3 104.65,95.43 104.65,95.68 104.81,95.84 105.5,95.84 105.74,96.08 105.74,96.42 105.45,96.72 103.05,96.72 102.75,96.42 102.75,96.13 102.57,95.95 101.89,95.95 101.76,96.08 101.76,96.43 101.52,96.67 100.81,96.67 100.4,96.26 97.46,96.26 97.13,96.59 96.52,96.59 96.26,96.33 95.81,96.33 95.69,96.46 95.69,96.97 95.41,97.25 94.92,97.25 94.71,97.04 94.71,96.41 94.58,96.28 94.2,96.28 93.87,96.61 91.11,96.61 90.83,96.33 90.1,96.33 89.76,95.99 89.76,95.53 89.67,95.44 89.26,95.44 89.17,95.53 89.17,95.94 88.94,96.18 88.5,96.18 88.23,95.91 88.23,95.56 88.15,95.47 87.76,95.47 87.68,95.56 87.68,96.31 87.42,96.56 86.96,96.56 86.67,96.27 86.67,95.89 86.58,95.8 86.23,95.8 86.14,95.89 86.14,96.93 85.94,97.13 85.44,97.13 85.2,96.89 85.2,95.89 85.11,95.8 84.79,95.8 84.66,95.93 84.66,97.17 84.46,97.37 83.74,97.37 83.44,97.07 83.44,96.64 83.78,96.3 83.78,95.91 83.58,95.71 83.58,94.31 v1(83.25,93.98)
DDR4_DIMM1_DBI_N4: length 56.8
  L16_SIG6 w0.076: v1(104.16,80.79) 103.91,80.65 103.88,80.53 103.92,80.46 arc(103.95,80.43) 104,80.41 104.22,80.41 arc(104.33,80.44) 104.42,80.52 104.5,80.63 arc(104.55,80.81) 104.49,80.99 104.48,81.01 arc(104.4,81.24) 104.48,81.48 104.53,81.56 arc(104.57,81.68) 104.54,81.81 104.51,81.86 arc(104.43,82.01) 104.41,82.18 104.41,82.54 104.4,82.54
  L16_SIG6 w0.081: 104.4,82.54 104.4,82.74 108.19,86.52 108.19,88.15 108.53,88.49 109.47,88.49 109.74,88.22 109.74,87.64 109.91,87.47 110.14,87.47 110.31,87.64 110.31,88.22 110.58,88.49 113.45,88.49 113.72,88.22 113.72,87.6 113.89,87.43 114.13,87.43 114.29,87.6 114.29,88.22 114.57,88.49 116.84,88.49 117.22,88.12 117.47,88.12 118.08,88.73 118.58,88.73 118.83,88.98 119.2,88.98 119.46,88.73 120.04,88.73 120.27,88.5 120.27,87.82 120.39,87.7 120.6,87.7 120.81,87.91 120.81,88.92 121.08,89.19 121.62,89.19 121.9,88.92 121.9,88.66 122.06,88.49 122.3,88.49 122.47,88.66 122.47,88.92 122.74,89.19 123.13,89.19 123.4,88.92 123.4,87.67 123.64,87.43 124.26,87.43 124.39,87.56 124.39,87.86 123.97,88.28 123.97,88.92 124.24,89.19 124.63,89.19 124.9,88.92 124.9,88.61 125.07,88.44 125.31,88.44 125.47,88.61 125.47,88.92 125.75,89.19 126.13,89.19 126.41,88.92 126.41,88.66 126.57,88.49 126.87,88.49 127.23,88.14 127.48,88.14 127.61,88.26 127.61,88.44 127.42,88.63 127.42,88.96 127.66,89.19 127.99,89.19 128.17,89.01 128.37,89.01 129.31,89.94 132.43,89.94 134.07,91.58 137.98,93.2 138.03,93.33 137.98,93.45 138.04,93.58 138.17,93.63 138.29,93.58 138.34,93.46 138.47,93.41 138.86,93.57 138.92,93.66 138.92,93.85 138.8,93.98 v1(138.49,93.98)
DDR4_DIMM1_DBI_N5: length 74.7
  L16_SIG6 w0.076: 109.33,82.56 109.33,82.55 109.33,82.54 109.33,82.15 109.44,81.92 arc(109.5,81.68) 109.42,81.43 109.38,81.36 arc(109.35,81.25) 109.37,81.15 109.44,81.02 arc(109.5,80.8) 109.45,80.57 109.39,80.47 arc(109.36,80.31) 109.41,80.15 109.45,80.1 arc(109.51,79.88) 109.45,79.66 109.39,79.55 arc(109.34,79.39) 109.38,79.22 109.41,79.17 arc(109.5,79.07) 109.63,79.03 109.8,79.03 arc(109.93,79.01) 110.05,78.94 110.24,78.77 arc(110.33,78.62) 110.3,78.45 110.27,78.39 110.28,78.35 v1(110.53,78.03)
  L16_SIG6 w0.081: v1(147.84,93.98) 148.18,93.98 148.26,94.06 148.26,94.36 148.09,94.53 147.83,94.53 147.35,94.05 147.35,93.02 147.08,92.74 146.11,92.74 145.76,92.4 145.76,91.79 145.36,91.39 144.91,91.39 144.13,90.61 144.13,87.62 143.31,86.81 143.31,84.91 142.68,84.29 142.68,81.76 142.33,81.4 132.72,81.4 132.17,81.95 132.17,82.64 132.61,83.07 133.72,83.07 133.84,83.2 133.84,83.45 133.69,83.6 131.55,83.6 131.38,83.44 131.38,81.86 131.11,81.59 130.72,81.59 130.45,81.86 130.45,83.44 130.28,83.6 130.05,83.6 129.88,83.44 129.88,81.86 129.61,81.59 129.22,81.59 128.95,81.86 128.95,83.44 128.78,83.6 128.54,83.6 128.38,83.44 128.38,81.86 128.1,81.59 127.72,81.59 127.44,81.86 127.44,83.92 127.32,84.04 127,84.04 126.87,83.92 126.87,82.78 126.6,82.51 126.21,82.51 125.94,82.78 125.94,83.62 125.74,83.82 110.41,83.82 109.33,82.74 109.33,82.56
DDR4_DIMM1_DBI_N6: length 74.4
  L03_SIG1 w0.076: 112.12,82.66 112.12,82.64 112.12,82.64 112.12,82.36 111.86,81.99 arc(111.84,81.96) 111.82,81.93 arc(111.63,81.69) 111.34,81.61 arc(111.29,81.61) 111.25,81.6 arc(111.24,81.6) 111.23,81.6 arc(111.21,81.59) 111.19,81.58 arc(111.13,81.54) 111.08,81.5 111.01,81.4 arc(110.8,81.23) 110.55,81.16 110.49,81.15 arc(110.35,81.11) 110.23,81.01 110.19,80.97 arc(109.98,80.78) 109.71,80.7 arc(109.54,80.64) 109.42,80.51 arc(109.21,80.3) 108.93,80.24 arc(108.75,80.19) 108.62,80.05 arc(108.42,79.85) 108.15,79.78 arc(108.04,79.77) 107.95,79.73 arc(107.93,79.71) 107.91,79.7 arc(107.86,79.65) 107.83,79.6 arc(107.61,79.38) 107.32,79.3 arc(107.15,79.26) 107.03,79.13 arc(106.82,78.92) 106.52,78.86 arc(106.36,78.83) 106.24,78.71 arc(106.11,78.56) 105.93,78.45 arc(105.8,78.42) 105.66,78.42 arc(105.57,78.41) 105.51,78.35 105.47,78.28 arc(105.46,78.22) 105.5,78.18 v1(105.75,78.03)
  L03_SIG1 w0.081: v4(157.19,93.98) 157.52,94.31 157.52,94.82 157.39,94.96 157.25,94.96 157.19,94.9 157.05,94.9 156.95,95 156.95,95.14 157.01,95.19 157.01,95.33 156.76,95.59 154.42,95.59 153.84,95.01 153.84,94.6 152.47,93.22 152.13,93.22 151.44,92.53 151.44,91.27 150.55,90.38 149.34,90.38 148.85,89.89 141.55,89.89 139.67,90.67 137.85,90.67 136.61,90.15 134.58,88.12 134.58,84.18 133.31,82.9 131.73,82.9 131.6,82.78 131.6,81.59 131.37,81.36 127.52,81.36 127.29,81.59 127.29,82.08 127.52,82.31 130.18,82.31 130.31,82.44 130.31,82.78 130.18,82.9 126.68,82.9 125.75,83.83 113.05,83.83 112.12,82.9 112.12,82.66
DDR4_DIMM1_DBI_N7: length 68.6
  L12_SIG4 w0.076: 116.9,82.23 116.89,82.22 116.88,82.22 116.63,81.97 116.53,81.8 arc(116.39,81.66) 116.19,81.61 116.1,81.61 arc(115.94,81.57) 115.82,81.44 115.8,81.4 arc(115.77,81.22) 115.82,81.05 115.84,81.02 arc(115.9,80.79) 115.82,80.56 115.8,80.53 arc(115.74,80.36) 115.76,80.19 arc(115.77,80.17) 115.78,80.16 115.81,80.1 arc(115.88,79.88) 115.83,79.66 115.75,79.52 arc(115.72,79.39) 115.76,79.26 115.81,79.18 arc(115.87,78.94) 115.8,78.7 115.71,78.58 arc(115.54,78.44) 115.32,78.41 115.22,78.42 arc(115.13,78.41) 115.07,78.35 115.02,78.26 arc(115.01,78.22) 115.03,78.19 v1(115.31,78.03)
  L12_SIG4 w0.089: v1(166.54,93.98) 166.87,94.31 166.87,95.46 166.69,95.64 166.34,95.64 165.88,95.18 165.37,95.18 165.01,95.54 165.01,96.05 165.37,96.41 165.37,96.76 165.03,97.1 164.58,97.1 164.03,96.56 163.3,96.56 162.81,97.04 161.44,97.04 160.78,97.7 138.16,97.7 134.87,94.41 132.98,94.41 132.65,94.09 132.65,93.15 127.49,87.99 127.49,86.63 124.18,83.32 118.76,83.32 118.67,83.23 118.67,83.04 118.59,82.95 118.41,82.95 118.32,83.04 118.32,83.23 118.23,83.32 117.99,83.32 116.9,82.23
DDR4_DIMM1_DBI_N8: length 55.3
  L14_SIG5 w0.076: v1(107.35,76.19) 107.05,76.09 106.96,76.11 106.94,76.15 arc(106.92,76.22) 106.94,76.28 107.01,76.42 arc(107.12,76.52) 107.26,76.56 107.4,76.56 arc(107.64,76.62) 107.82,76.78 107.87,76.86 arc(107.94,77.07) 107.88,77.29 107.79,77.44 arc(107.72,77.62) 107.72,77.8 107.75,77.95 arc(107.76,78.02) 107.75,78.08 107.72,78.37 arc(107.73,78.49) 107.77,78.6 107.85,78.74 arc(107.9,78.86) 107.91,79 arc(107.88,79.09) 107.83,79.17 107.78,79.23 arc(107.72,79.34) 107.74,79.47 107.88,79.72 arc(107.91,79.8) 107.92,79.89 arc(107.91,79.96) 107.88,80.02 107.8,80.18 arc(107.77,80.34) 107.81,80.49 107.87,80.6 arc(107.92,80.82) 107.85,81.04 107.8,81.12 arc(107.76,81.22) 107.79,81.33 107.85,81.45 arc(107.91,81.69) 107.85,81.93 107.78,82.06 arc(107.77,82.1) 107.76,82.15 107.76,82.49 107.77,82.49 107.77,82.51
  L14_SIG5 w0.081: v1(92.59,93.99) 92.9,94.29 92.9,94.48 93.18,94.76 93.62,94.76 97.15,91.23 99.9,91.23 100.17,90.96 100.17,90.46 100.34,90.29 100.72,90.29 100.88,90.44 100.88,90.93 101.14,91.19 101.57,91.19 101.83,90.93 101.83,89.99 101.98,89.84 102.27,89.84 102.42,89.99 102.42,90.93 102.68,91.19 103.12,91.19 103.38,90.93 103.38,89.99 103.53,89.84 104.51,89.84 105.21,89.14 106.2,89.14 106.35,89.29 106.35,90.94 106.61,91.2 107.08,91.2 107.34,90.94 107.34,89.27 107.47,89.14 107.82,89.14 107.97,89.29 107.97,90.97 108.23,91.23 108.9,91.23 109.16,90.97 109.16,88.71 109.37,88.51 109.68,88.51 109.86,88.68 109.86,90.96 110.12,91.22 110.66,91.22 110.92,90.96 110.92,87.74 110.66,87.49 109.81,87.49 109.66,87.33 109.66,87.12 109.81,86.97 110.35,86.97 110.61,86.71 110.61,86.34 110.35,86.08 109.59,86.08 109.38,85.88 109.38,84.26 107.77,82.64 107.77,82.51
DDR4_DIMM1_DQ0: length 83.6
  L07_SIG3 w0.089: v1(98.58,79.41) 98.18,79.81 98.18,80.08 97.93,80.33 97.61,80.33 97.14,80.8 96.83,80.8 96.4,81.24 96.01,81.24 95.54,81.71 95.18,81.71 94.53,82.36 92.87,83.05 80.24,83.05 77.05,79.86 77.05,78.53 74.39,75.87 72.7,75.87 71.65,74.81 71.3,74.81 70.03,73.55 65.22,73.55 64.07,74.7 64.07,74.97 64.57,75.46 64.57,75.78 64.78,75.99 64.78,76.18 64.55,76.42 64.37,76.42 64.04,76.09 62.69,76.09 59.02,79.76 56.4,80.84 56.19,81.06 55.33,83.13 55.33,85.44 55.14,85.62 55.14,86.22 55.03,86.33 54.7,86.33 54.58,86.45 54.58,86.6 54.7,86.71 55.51,86.71 55.61,86.82 55.61,86.96 55.51,87.06 54.33,87.06 54.22,86.95 54.22,86.65 54.1,86.53 53.94,86.53 53.82,86.65 53.82,86.95 53.71,87.06 53.42,87.06 53.33,87.15 53.33,87.37 53.42,87.46 55.48,87.46 55.6,87.58 55.6,87.89 55.48,88.02 54.87,88.02 54.73,88.16 54.73,88.46 54.62,88.57 54.01,88.57 53.92,88.66 53.92,88.98 54.01,89.07 55.52,89.07 55.64,89.19 55.64,89.35 55.52,89.47 54.85,89.47 54.73,89.58 54.73,89.75 54.85,89.86 55.52,89.86 55.64,89.98 55.64,90.14 55.52,90.25 54.94,90.25 54.82,90.37 54.82,90.55 54.94,90.67 55.22,90.67 55.3,90.76 55.3,91 55.22,91.09 54.56,91.09 53.91,91.75 53.91,92.17 53.76,92.32 52.44,92.32 52.33,92.43 52.33,92.64 52.44,92.75 53.29,92.75 53.42,92.87 53.42,93.04 53.29,93.16 52.63,93.16 52.53,93.26 52.53,93.5 52.63,93.6 53.11,93.6 v1(53.49,93.98)
DDR4_DIMM1_DQ1: length 83.2
  L07_SIG3 w0.089: v1(99.38,79.87) 98.99,80.26 98.99,80.52 98.74,80.77 98.41,80.77 97.97,81.22 97.58,81.22 97.1,81.7 96.81,81.7 96.38,82.13 96.04,82.13 94.71,83.46 80.17,83.46 76.65,79.95 76.65,78.72 74.24,76.31 72.57,76.31 71.93,75.67 71.26,75.67 71.1,75.83 70.92,75.83 70.7,75.6 70.7,75.44 70.97,75.17 70.97,75 70.85,74.89 70.69,74.89 70.42,75.16 70.25,75.16 70.14,75.05 70.14,74.88 70.41,74.61 70.41,74.45 70.3,74.33 70.13,74.33 69.86,74.61 69.7,74.61 69.58,74.49 69.58,74.33 69.73,74.18 69.73,74.04 69.59,73.9 69.45,73.9 69.3,74.05 69.14,74.05 69.03,73.94 65.41,73.94 65.21,74.14 65.21,74.7 65.32,74.82 66.16,74.82 66.27,74.93 66.27,75.1 66.16,75.21 65.87,75.21 65.76,75.33 65.76,76.07 65.58,76.24 65.24,76.24 64.56,76.93 64.38,76.93 63.93,76.48 62.85,76.48 62.09,77.23 62.09,77.4 62.22,77.52 62.22,77.69 62.1,77.8 61.94,77.8 61.81,77.68 61.65,77.68 58.55,80.77 58.55,80.96 58.91,81.32 58.91,81.51 58.77,81.65 58.58,81.65 58.22,81.3 58.03,81.3 57.62,81.71 57.62,81.91 57.82,82.11 57.82,82.48 58.09,82.75 58.09,82.93 57.89,83.13 57.71,83.13 57.31,82.73 56.96,82.73 55.95,83.74 55.95,85.3 55.49,85.77 55.49,86.19 55.99,86.69 55.99,90.8 54.35,92.44 54.13,92.44 53.91,92.67 53.91,94.66 53.3,95.27 53.3,96.52 54.34,97.57 54.34,97.93 54.23,98.05 53.8,98.05 53.69,98.16 53.69,98.33 53.8,98.44 54.09,98.44 54.21,98.56 54.21,98.72 54.09,98.84 53.92,98.84 53.8,98.95 53.8,99.11 53.92,99.23 54.23,99.23 54.34,99.34 v1(54.34,99.98)
DDR4_DIMM1_DQ2: length 81.6
  L07_SIG3 w0.089: v1(99.38,78.03) 100.18,78.03 100.34,77.96 100.53,77.78 101,77.58 101.17,77.58 101.59,78 101.87,78 102.36,78.5 102.71,78.5 103.16,78.95 103.46,78.95 103.77,79.25 103.77,82.3 103.51,82.55 102.94,82.55 100.5,84.99 97.31,84.99 95.98,86.32 93.35,86.32 92.99,86.68 92.99,86.93 92.71,87.21 91.61,87.21 91.35,86.94 91.35,86.66 91.02,86.32 89.42,86.32 89.12,86.62 89.12,87.01 88.82,87.3 88.4,87.3 88.09,87 88.09,86.62 87.79,86.32 85.94,86.32 85.2,87.06 84.33,87.06 83.59,86.32 81.99,86.32 81.48,86.83 79.49,86.83 73.28,80.62 72.56,80.62 72.25,80.49 71.62,80.49 71.31,80.18 70.53,80.18 69.95,79.6 69.16,79.6 67.4,81.36 66.77,81.36 66.08,82.05 66.08,82.64 65.91,82.81 65.67,82.81 65.49,82.63 64.64,82.63 64.17,83.09 64.17,83.63 64.35,83.81 64.35,84.54 63.91,84.99 63.91,86.14 63.13,86.92 63.13,88.72 60.34,91.51 60.34,92.11 59.78,92.68 59.78,93.38 59.56,93.6 59.21,93.6 59.03,93.77 59.03,98.94 59.15,99.05 59.33,99.05 59.44,98.94 59.44,96.11 59.72,95.83 59.72,94.85 59.44,94.58 v1(59.44,93.98)
DDR4_DIMM1_DQ3: length 82.2
  L07_SIG3 w0.089: v1(60.29,99.98) 57.98,100.78 54.18,100.78 53.42,100.46 53.11,100.15 53.11,99.72 51.39,94.24 51.39,93.74 50.7,92.08 50.7,88.54 51.01,88.22 52.02,88.22 52.26,87.98 52.26,87.68 53.83,86.12 54.29,86.12 54.74,85.67 54.74,83.39 55.72,81.01 56.19,80.55 58.56,79.57 62.93,75.2 63.05,75.2 65.05,73.2 70.18,73.2 71.01,74.02 71.58,74.02 72.98,75.43 74.63,75.43 77.47,78.26 77.47,79.77 80.33,82.63 92.32,82.63 93,82.35 93.68,81.66 93.94,81.66 94.37,81.23 94.85,81.23 95.29,80.79 95.54,80.79 96.05,80.29 96.34,80.29 96.78,79.85 97.25,79.85 97.74,79.36 97.92,79.36 98.24,79.04 98.24,78.83 v1(98.58,78.49)
DDR4_DIMM1_DQ4: length 83.1
  L07_SIG3 w0.089: v1(51.79,93.98) 51.79,94.36 52.02,94.59 52.4,94.59 52.6,94.79 52.6,96.73 53.11,97.24 53.11,97.48 52.95,97.64 52.95,97.79 53.31,98.14 53.31,99.16 53.92,99.77 53.92,100.09 54.23,100.41 54.62,100.41 54.93,100.11 55.19,100.11 55.5,100.41 57.04,100.41 57.28,100.17 57.28,99.02 57.36,98.95 57.36,93.04 58.07,92.32 58.07,89.39 58.27,89.2 61.2,89.2 62.1,88.3 62.1,86.38 62.8,85.68 62.8,85.38 61.97,84.55 61.97,83.27 62.97,82.26 63.38,82.26 64.26,81.38 64.26,81.11 64.49,80.87 64.97,80.87 65.26,80.59 65.26,80.1 67.01,78.35 67.98,78.35 68.44,77.89 70.23,77.89 70.55,78.21 72.73,78.21 73.12,78.6 73.12,79 79.4,85.29 95.54,85.29 96.88,83.95 99.91,83.95 101.35,82.51 101.35,79.2 101.77,78.78 v1(101.77,78.49)
DDR4_DIMM1_DQ5: length 83.1
  L07_SIG3 w0.089: v1(52.64,99.98) 52.64,101.34 53.55,102.25 58.6,102.25 59.05,101.79 59.05,101.41 59.53,100.93 60.07,100.93 60.75,100.25 60.75,99.8 59.81,98.86 59.81,96.32 60.16,95.97 60.16,94.54 59.88,94.27 59.88,93.81 60.15,93.54 60.15,92.81 60.71,92.25 60.71,91.62 63.47,88.87 63.47,87.07 64.25,86.29 64.25,85.26 65.18,84.33 65.18,84.08 66.47,82.78 66.47,82.14 66.86,81.76 67.52,81.76 69.32,79.96 69.81,79.96 70.42,80.57 71.15,80.57 71.43,80.86 72.19,80.86 72.73,81.08 73.26,81.08 79.44,87.27 83.61,87.27 83.92,87.58 85.59,87.58 85.91,87.27 87.68,87.27 88.13,87.72 89,87.72 89.46,87.27 90.92,87.27 91.38,87.73 92.87,87.73 93.34,87.27 94.98,87.27 95.51,86.74 96.07,86.74 97.45,85.35 100.66,85.35 103.06,82.95 103.62,82.95 104.55,82.02 104.55,78.72 104.3,78.46 103.94,78.46 103.51,78.03 v1(102.57,78.03)
DDR4_DIMM1_DQ6: length 83.4
  L07_SIG3 w0.089: v1(101.77,79.41) 102.17,79.81 102.17,82.32 100.19,84.29 97.02,84.29 95.68,85.63 92.76,85.63 92.66,85.73 92.66,85.99 92.56,86.09 92.42,86.09 92.32,85.99 92.32,85.73 92.22,85.63 92.07,85.63 91.97,85.73 91.97,85.97 91.87,86.07 91.73,86.07 91.63,85.97 91.63,85.73 91.53,85.63 88.89,85.63 88.78,85.74 88.78,85.98 88.68,86.08 88.53,86.08 88.43,85.98 88.43,85.74 88.32,85.63 85.39,85.63 85.29,85.73 85.29,85.99 85.19,86.09 85.05,86.09 84.95,85.99 84.95,85.73 84.85,85.63 84.7,85.63 84.6,85.73 84.6,85.99 84.5,86.09 84.36,86.09 84.26,85.99 84.26,85.73 84.16,85.63 81.15,85.63 81.05,85.73 81.05,86.01 80.95,86.11 80.81,86.11 80.71,86.01 80.71,85.73 80.61,85.63 80.47,85.63 80.37,85.73 80.37,86.01 80.27,86.11 80.12,86.11 80.02,86.01 80.02,85.73 79.92,85.63 79.78,85.63 79.68,85.73 79.37,85.73 73.04,79.41 72.21,79.41 71.97,79.16 71.97,78.71 71.86,78.61 71.63,78.61 71.5,78.74 71.5,79.28 71.39,79.38 71.21,79.38 71.1,79.28 71.1,78.68 71,78.58 70.82,78.58 70.72,78.68 70.72,78.91 70.62,79.01 70.34,79.01 70.14,78.81 69.84,78.81 69.73,78.7 69.73,78.37 69.61,78.25 69.45,78.25 69.33,78.37 69.33,78.7 69.22,78.81 68.43,78.81 68.31,78.69 67.35,78.69 67.23,78.81 67.23,79.15 67.52,79.44 67.52,79.73 67.46,79.79 66.11,79.79 66.02,79.88 66.02,80.12 66.11,80.21 67.03,80.21 67.12,80.29 67.12,80.49 67.03,80.58 66.36,80.58 65.95,80.99 65.53,80.99 65.29,81.22 65.29,81.64 64.99,81.94 64.32,81.94 63.5,82.77 63.12,82.77 62.48,83.41 62.48,84.39 63.22,85.14 63.22,85.86 62.44,86.64 62.44,88.44 61.34,89.55 60.17,89.55 60.05,89.66 60.05,90.71 59.94,90.83 59.78,90.83 59.66,90.71 59.66,89.66 59.54,89.55 59.3,89.55 59.19,89.66 59.19,92.15 59.07,92.27 58.91,92.27 58.8,92.15 58.8,89.66 58.68,89.55 58.55,89.55 58.45,89.65 58.45,92.43 58.32,92.56 58.32,92.73 58.55,92.96 58.55,93.13 58.44,93.24 58.28,93.24 58.04,93.01 57.88,93.01 57.74,93.14 v1(57.74,93.98)
DDR4_DIMM1_DQ7: length 83.3
  L07_SIG3 w0.089: v1(102.57,79.87) 102.98,80.28 102.98,81.99 100.33,84.64 97.16,84.64 95.82,85.98 93.21,85.98 92.72,86.47 91.65,86.47 91.16,85.98 89.28,85.98 88.79,86.47 88.42,86.47 87.93,85.98 85.8,85.98 85.31,86.47 84.24,86.47 83.75,85.98 81.82,85.98 81.33,86.47 79.62,86.47 72.93,79.78 72.09,79.78 71.98,79.67 71.61,79.67 71.5,79.78 70.62,79.78 70.09,79.26 68.48,79.26 68.31,79.42 68.31,79.8 68.09,80.02 67.71,80.02 67.54,80.2 67.54,80.73 67.34,80.93 66.49,80.93 66.33,81.09 66.33,81.31 65.36,82.29 64.49,82.29 63.83,82.95 63.83,83.25 63.41,83.67 63.03,83.67 62.82,83.88 62.82,84.25 63.56,84.99 63.56,86 62.78,86.78 62.78,88.58 61.08,90.28 60.92,90.28 60.7,90.06 60.54,90.06 60.43,90.18 60.43,90.34 60.64,90.56 60.64,90.72 60.16,91.21 59.76,91.21 59.59,91.38 59.59,92.3 59.41,92.48 59.41,92.86 58.68,93.59 58.28,93.59 58.16,93.71 58.16,94.38 58.26,94.48 58.59,94.48 58.69,94.58 58.69,94.72 58.56,94.85 57.8,94.85 57.7,94.95 57.7,95.09 57.8,95.19 58.61,95.19 58.69,95.27 58.69,95.41 58.56,95.53 57.8,95.53 57.7,95.63 57.7,95.78 57.8,95.88 58.59,95.88 58.67,95.96 58.67,96.1 58.55,96.22 57.8,96.22 57.7,96.32 57.7,96.46 57.8,96.56 58.58,96.56 58.66,96.64 58.66,96.78 58.54,96.91 57.8,96.91 57.7,97.01 57.7,97.15 57.8,97.25 58.56,97.25 58.64,97.33 58.64,97.47 58.52,97.59 57.8,97.59 57.7,97.69 57.7,97.83 57.8,97.93 58.57,97.93 58.65,98.01 58.65,98.16 58.53,98.28 57.8,98.28 57.7,98.38 57.7,98.52 57.8,98.62 58.59,98.62 58.67,98.7 58.67,98.89 58.57,98.99 57.86,98.99 57.76,99.09 57.76,99.27 57.86,99.37 58.4,99.37 58.59,99.56 v1(58.59,99.98)
DDR4_DIMM1_DQ8: length 78
  L07_SIG3 w0.089: v1(107.35,80.79) 107.07,80.79 106.96,80.9 106.96,81.44 106.73,81.68 106.45,81.68 106.15,81.97 106.15,82.1 104.33,83.92 103.39,83.92 101.01,86.3 97.82,86.3 97.48,86.64 97.48,87.08 96.93,87.63 96.08,87.63 95.31,88.41 95.31,88.99 95.2,89.09 94.99,89.09 94.88,88.97 94.88,88.81 94.76,88.7 94.6,88.7 94.49,88.81 94.49,88.97 94.37,89.09 94.21,89.09 94.09,88.97 94.09,88.81 93.98,88.7 93.81,88.7 93.7,88.81 93.7,88.97 93.58,89.09 93.42,89.09 93.3,88.97 93.3,88.81 93.19,88.7 93.03,88.7 92.91,88.81 92.91,88.97 92.8,89.09 92.63,89.09 92.52,88.97 92.52,88.81 92.4,88.7 92.24,88.7 92.12,88.81 92.12,88.97 92.01,89.09 91.84,89.09 91.73,88.97 91.73,88.81 91.61,88.7 91.45,88.7 91.34,88.81 91.34,88.97 91.22,89.09 91.06,89.09 90.94,88.97 90.94,88.81 90.83,88.7 90.66,88.7 90.55,88.81 90.55,88.97 90.43,89.09 90.27,89.09 90.15,88.97 90.15,88.81 90.04,88.7 89.88,88.7 89.76,88.81 89.76,88.97 89.65,89.09 89.48,89.09 89.37,88.97 89.37,88.81 89.25,88.7 89.09,88.7 88.97,88.81 88.97,88.97 88.86,89.09 88.7,89.09 88.58,88.97 88.58,88.81 88.46,88.7 88.3,88.7 88.19,88.81 88.19,88.97 88.07,89.09 87.91,89.09 87.79,88.97 87.79,88.81 87.68,88.7 87.11,88.7 86.9,88.48 81.81,88.48 81.51,88.18 81.33,88.18 81.17,88.35 80.99,88.35 80.83,88.18 80.65,88.18 80.48,88.35 80.31,88.35 80.14,88.18 79.96,88.18 79.8,88.35 79.62,88.35 79.45,88.18 79.1,88.18 73.34,82.42 71.83,81.79 70.38,81.79 69.74,81.15 69.43,81.15 66.15,84.43 66.15,84.73 65.14,85.74 65.14,86.47 65.24,86.57 65.32,86.57 65.46,86.71 65.46,87.2 65.32,87.34 64.54,87.34 64.36,87.52 64.36,89.23 64.14,89.45 64.14,89.64 64.41,89.91 64.41,90.09 64.28,90.22 64.1,90.22 63.83,89.95 63.64,89.95 63.51,90.08 63.51,90.27 63.78,90.53 63.78,90.72 63.65,90.85 63.47,90.85 63.2,90.58 63.01,90.58 62.88,90.71 62.88,90.89 63.23,91.24 63.23,91.43 63.1,91.56 62.92,91.56 62.57,91.21 62.38,91.21 62.25,91.34 62.25,91.52 63.24,92.5 63.24,93.39 63.15,93.48 62.88,93.48 62.8,93.39 62.8,92.69 61.94,91.84 61.76,91.84 61.63,91.97 61.63,92.15 61.8,92.32 61.8,92.49 61.09,93.19 61.09,93.35 61.21,93.47 61.37,93.47 62.08,92.76 62.24,92.76 62.36,92.88 62.36,93.06 62.06,93.36 62.06,93.51 62.26,93.71 62.57,93.71 v1(62.84,93.98)
DDR4_DIMM1_DQ9: length 78.4
  L07_SIG3 w0.089: v1(106.55,82.17) 106.55,82.47 106.26,82.76 106,82.76 105.88,82.87 105.88,83.13 105.77,83.25 105.56,83.25 105.4,83.41 105.4,83.62 105.29,83.73 105.08,83.73 104.91,83.89 104.91,84.1 104.7,84.32 103.48,84.32 101.67,86.13 101.67,87.05 101.48,87.25 100.93,87.25 100.79,87.11 100.79,86.83 100.66,86.7 100.52,86.7 100.39,86.83 100.39,87.11 100.26,87.25 99.22,87.25 99.08,87.11 99.08,86.85 98.94,86.72 98.75,86.72 98.61,86.85 98.61,87.11 98.47,87.25 97.8,87.25 97.08,87.97 96.27,87.97 95.66,88.58 95.66,89.16 95.38,89.44 87.36,89.44 86.76,88.83 79.27,88.83 73.18,82.75 71.73,82.15 68.92,82.15 66.5,84.57 66.5,84.86 65.86,85.51 65.86,87.32 65.44,87.74 64.87,87.74 64.74,87.88 64.74,88.07 64.87,88.21 65.14,88.21 65.27,88.35 65.27,88.54 65.14,88.68 64.87,88.68 64.74,88.82 64.74,89.01 64.87,89.15 65.14,89.15 65.27,89.29 65.27,89.89 64.97,90.2 64.79,90.2 63.61,91.39 63.61,94 63.25,94.36 61.68,94.36 61.55,94.49 61.55,94.63 61.64,94.72 63.03,94.72 63.14,94.84 63.14,94.98 63.05,95.07 61.59,95.07 61.49,95.17 61.49,95.31 61.61,95.43 62.5,95.43 62.62,95.54 62.62,95.71 62.5,95.82 61.66,95.82 61.54,95.94 61.54,96.1 61.66,96.22 62.5,96.22 62.62,96.33 62.62,96.49 62.5,96.61 62.15,96.61 62.03,96.73 62.03,96.89 62.15,97 62.5,97 62.62,97.12 62.62,97.28 62.5,97.4 62.15,97.4 62.03,97.51 62.03,97.99 62.16,98.11 62.32,98.11 62.41,98.02 62.58,98.02 62.69,98.14 62.69,98.3 62.6,98.39 62.6,98.56 63.69,99.65 v1(63.69,99.98)
