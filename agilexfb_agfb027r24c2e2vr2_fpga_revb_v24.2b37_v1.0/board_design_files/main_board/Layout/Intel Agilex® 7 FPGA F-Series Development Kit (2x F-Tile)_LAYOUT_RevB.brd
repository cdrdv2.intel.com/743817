# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_1V2_LED3: length 284.2
  L03_SIG1 w0.081: v1(222.51,17.1) 222.51,17.99 222.99,18.47 222.99,21.46 224.26,22.73 224.26,25.69 222.24,27.71 222.24,30.14 218.55,33.84 218.55,35.77 218.82,36.04 218.82,37.04 218.57,37.29 218.57,37.75 218.82,38 218.82,39.79 218.55,40.06 218.55,40.42 218.82,40.69 218.82,41.22 219.56,41.96 219.56,65.19 221.75,67.37 221.75,74.3 220.99,75.06 220.99,78.06 220.02,79.02 220.02,83.59 218.85,84.77 218.85,101.14 218.4,101.59 218.4,102.31 217.63,103.08 v1(217.3,103.08)
  L07_SIG3 w0.089: v1(85.83,43.53) 85.83,43.25 85.42,42.83 85.42,41.86 84.56,41 83.22,41 82.73,40.52 81.77,40.52 78.84,37.58 78.84,37.08 76.72,34.96 76.72,28.68 76.18,28.15 76.18,26.32 76.01,26.15 75.63,26.15 75.39,25.91 75.39,25.6 75.15,25.36 74.84,25.36 74.59,25.1 74.59,24.81 74.33,24.56 73.95,24.56 73.47,24.08 73.47,21.84 72.83,21.2 72.83,16.98 75.24,14.56 84.81,14.56 85.66,13.72 112.35,13.72 112.66,13.41 127.52,13.41 127.64,13.54 134.23,13.54 135.87,15.17 156.33,15.17 156.73,15.57 161.55,15.57 161.86,15.27 180.58,15.27 180.88,15.57 184.82,15.57 185.22,15.17 217.24,15.17 219.92,17.86 220.23,17.86 220.86,18.49 221.5,18.49 222,17.99 222,17.6 v1(222.51,17.1)
  BOTTOM w0.149: U87.5 218.41,100.95 218.19,101.17 218.19,102.19 v1(217.3,103.08)
FPGA_1V2_SCL: length 134.5
  L03_SIG1 w0.081: v1(66.26,104.63) 65.75,104.12 63.41,104.12 61.75,102.47 53.73,102.47 52.48,101.22 47.45,101.22 v1(47,101.68)
  L12_SIG4 w0.089: v1(47,101.68) 47.35,101.32 47.35,95.91 48.98,94.29 48.98,93.17 48.57,92.76 45.98,92.76 44.67,91.46 44.67,88.15 43.47,86.95 41.41,86.95 40.9,86.44 40.9,85.91 40.65,85.65 40.39,85.65 39.9,85.16 39.9,81.57 39.35,81.03 39.35,76.3 37.32,74.27 37.32,72.57 36.91,72.16 36.91,69.55 36.35,68.99 36.35,65.89 36.71,65.53 36.71,62.64 38.64,60.71 38.64,59.9 39.2,59.34 40.82,59.34 44,56.16 44,53.19 45.63,51.56 46.01,51.56 46.42,51.16 46.42,50.74 47.23,49.94 48.27,49.94 48.5,49.71 48.5,48.47 48.8,48.16 50.98,48.16 51.92,47.22 57.31,47.22 57.84,46.69 67.44,46.69 67.75,46.99 71.38,46.99 72.4,45.98 74.68,45.98 74.99,45.67 77.53,45.67 77.78,45.42 80.4,45.42 80.8,45.01 81.39,45.01 81.8,45.42 83.57,45.42 83.95,45.8 85.48,45.8 86.37,46.69 87.71,46.69 88.22,46.18 v1(88.22,45.83)
  BOTTOM w0.149: U39.3 66.48,104.84 v1(66.26,104.63)
FPGA_1V2_SDA: length 133.9
  L03_SIG1 w0.081: v1(48.01,101.68) 50.3,101.68 51.77,103.15 61.42,103.15 63.91,105.64 v1(66.26,105.64)
  L12_SIG4 w0.089: v1(89.02,45.37) 89.02,46.19 87.66,47.55 87.23,47.55 86.75,47.07 86.24,47.07 85.86,46.69 83.95,46.69 83.57,46.31 83.19,46.31 82.81,45.93 80.78,45.93 80.4,46.31 80.02,46.31 79.76,46.05 75.45,46.05 73.95,47.55 66.48,47.55 66.22,47.81 59.32,47.81 58.68,47.17 57.84,47.17 57.46,47.55 52.23,47.55 49.31,50.47 47.63,50.47 46.96,51.15 46.96,51.83 44.43,54.36 44.43,56.37 41.16,59.64 39.5,59.64 39.25,59.9 39.25,60.67 37.14,62.78 37.14,66.45 37.35,66.65 37.35,69.01 37.83,69.5 37.83,72.19 38.28,72.65 38.28,74.73 39.63,76.08 39.63,80.67 40.27,81.31 40.27,84.86 40.67,85.27 41.05,85.27 41.33,85.55 43.49,85.55 45.08,87.14 45.08,91.28 46.13,92.33 48.95,92.33 49.82,93.2 49.82,93.91 49.59,94.14 49.59,95.63 49.84,95.89 49.84,97.45 49.11,98.18 49.11,98.66 48.01,99.75 v1(48.01,101.68)
  BOTTOM w0.149: v1(66.26,105.64) 66.57,105.34 U39.4
FPGA_1V8_ASX4_CLK: length 47.1
  L14_SIG5 w0.081: v1(35.95,54.43) 35.46,54.92 35.46,57.5 36.19,58.23 37.13,58.23 39.66,60.76 46.57,60.76 46.84,60.49 53.84,60.49 56.47,63.12 62.03,63.12 63.28,64.37 64.09,64.37 64.22,64.24 70.76,64.24 v1(71,64.48)
  BOTTOM w0.149: U9.B2 33.28,54.43 v1(35.95,54.43)
FPGA_1V8_ASX4_CS0N_MSEL0: length 85
  L14_SIG5 w0.081: v1(31.61,51.77) 31.22,52.16 31.22,56.31 32.9,57.99 v1(32.9,58.69) 32.44,59.15 32.44,59.82 32.77,60.15 33.38,60.15 33.64,60.41 33.64,60.55 33.24,60.96 33.24,61.1 33.47,61.33 33.6,61.33 34.01,60.92 34.15,60.92 34.38,61.15 34.38,61.29 33.97,61.69 33.97,61.83 34.2,62.06 34.34,62.06 34.75,61.65 34.89,61.65 35.13,61.9 35.13,62.04 34.72,62.44 34.72,62.58 34.93,62.79 35.06,62.79 35.4,62.45 53.87,62.45 56.42,65 59.8,65 60.84,66.04 67.32,66.04 67.47,66.2 69.55,66.2 69.7,66.35 69.7,66.63 69.55,66.78 68.94,66.78 68.74,66.99 68.74,67.84 68.97,68.07 69.32,68.07 69.45,67.94 69.45,67.55 69.99,67 70.35,67 70.45,67.1 70.45,67.44 70.55,67.54 70.74,67.54 70.84,67.44 70.84,67.1 70.94,67 71.12,67 71.22,67.1 71.22,67.44 71.33,67.54 71.51,67.54 71.61,67.44 71.61,67.1 71.71,67 71.89,67 72,67.1 72,67.44 72.1,67.54 72.28,67.54 72.38,67.44 72.38,67.1 72.48,67 74.91,67 75.62,67.72 76.46,67.72 77.32,66.86 78.3,66.86 78.52,66.65 78.93,66.65 79.39,67.1 79.65,67.1 79.91,67.36 80.5,67.36 80.78,67.08 81.32,67.08 81.58,67.34 83.76,67.34 84,67.1 86.17,67.1 86.42,67.36 86.88,67.36 87.15,67.08 87.53,67.08 87.99,67.54 88.41,67.54 88.81,67.94 89.16,67.94 89.44,68.22 89.44,68.81 89.61,69.24 89.61,69.38 89.43,69.71 89.19,69.84 88.86,69.84 88.71,69.99 88.6,69.99 88.47,70.12 87.91,70.12 87.82,70.21 v1(87.43,70.21)
FPGA_1V8_ASX4_D0: length 89.1
  L14_SIG5 w0.081: v1(87.43,72.05) 87.75,72.05 87.84,71.96 88.53,71.96 88.8,71.68 89.25,71.68 89.46,71.55 89.71,71.12 90.04,70.93 90.21,70.77 90.21,70.18 90.44,69.78 90.55,69.67 90.71,69.67 91,69.38 91,67.21 90.69,66.9 88.76,66.9 88.36,66.5 88.02,66.5 87.57,66.05 87.22,66.05 86.86,65.69 86.4,65.69 85.98,66.12 85.62,66.12 85.33,66.41 83.25,66.41 82.89,66.05 80.91,66.05 80.56,65.69 79.93,65.69 79.65,65.98 79.27,65.98 78.88,65.59 77.5,65.59 77.19,65.9 76.52,65.9 76.41,65.78 76.41,65.23 76.3,65.12 76.14,65.12 76.02,65.23 76.02,65.57 75.91,65.69 75.75,65.69 75.64,65.57 75.64,65.37 75.52,65.26 75.36,65.26 75.25,65.37 75.25,65.78 74.71,66.32 70.9,66.32 69.96,65.38 62.54,65.38 61.94,64.78 61.07,64.78 60.13,63.83 56.22,63.83 54.06,61.67 52.68,61.67 52.58,61.57 52.58,61.29 52.48,61.19 52.02,61.19 51.92,61.29 51.92,61.58 51.83,61.68 51.34,61.68 51.24,61.58 51.24,61.29 51.14,61.19 50.68,61.19 50.58,61.29 50.58,61.6 50.48,61.7 50.05,61.7 49.94,61.6 49.94,61.34 49.79,61.19 49.36,61.19 49.21,61.34 49.21,61.62 49.11,61.72 48.5,61.72 48.39,61.62 48.39,61.35 48.24,61.19 47.66,61.19 47.12,61.72 38,61.72 37.9,61.63 37.9,60.81 37.74,60.64 37.26,60.64 37.07,60.45 37.07,59.92 36.97,59.82 35.59,59.82 35.49,59.92 35.49,60.15 35.59,60.25 36.36,60.25 36.46,60.35 36.46,60.64 36.36,60.73 35.39,60.73 34.35,59.69 34.35,57.99 32.01,55.65 32.01,52.66 32.52,52.15 32.52,51.13 31.76,50.37 31.01,50.37 v1(30.61,50.77)
FPGA_1V8_ASX4_D1: length 84.4
  L14_SIG5 w0.081: v1(87.43,69.29) 87.43,68.96 86.75,68.28 86.25,68.28 86,68.03 85.52,68.03 85.31,68.24 83.22,68.24 82.98,68 80.92,68 80.58,68.34 80.19,68.34 79.85,68 79.16,68 78.88,68.28 77.17,68.28 77.02,68.43 74.88,68.43 74.61,68.7 71.85,68.7 71.3,69.24 69.04,69.24 67.95,68.15 66.05,68.15 64.62,66.73 60.28,66.73 59.27,65.71 56.17,65.71 53.63,63.17 42.15,63.17 41.49,63.83 33.54,63.83 30.59,60.89 30.59,57.36 29.09,55.86 29.09,54.53 28.99,54.43 28.55,54.43 28.46,54.53 28.46,55.68 28.36,55.78 27.92,55.78 27.82,55.68 27.82,51.49 27.92,51.39 28.36,51.39 28.46,51.49 28.46,53.4 28.55,53.5 28.99,53.5 29.09,53.4 29.09,51.51 29.34,51.26 30.74,51.26 31.23,50.77 v1(31.61,50.77)
FPGA_1V8_ASX4_D2: length 87.4
  L14_SIG5 w0.081: v1(29.61,51.77) 30.87,51.77 31.33,51.31 31.81,51.31 32.01,51.51 32.01,52.02 31.68,52.35 31.68,55.88 33.92,58.12 v1(33.92,58.69) 33.51,59.1 33.51,59.8 35.79,62.08 36.63,62.08 36.73,61.98 36.73,61.72 36.63,61.62 35.86,61.62 35.77,61.52 35.77,61.26 35.86,61.17 36.99,61.17 37.09,61.26 37.09,61.98 37.23,62.12 54.04,62.12 56.59,64.67 56.91,64.67 57.04,64.53 57.04,64.28 57.15,64.17 57.4,64.17 57.49,64.27 57.49,64.53 57.59,64.63 57.85,64.63 57.95,64.53 57.95,64.28 58.06,64.17 58.39,64.17 58.48,64.27 58.48,64.56 58.58,64.66 58.89,64.66 58.99,64.56 58.99,64.28 59.1,64.17 59.4,64.17 59.5,64.27 59.5,64.56 59.6,64.66 60.18,64.66 61.01,65.48 61.25,65.48 61.35,65.39 61.35,65.2 61.45,65.1 61.76,65.1 61.86,65.2 61.86,65.56 62.01,65.71 67.64,65.71 67.75,65.81 69.78,65.81 70.63,66.67 75.05,66.67 75.72,67.34 76.26,67.34 77.18,66.41 78.81,66.41 79.07,66.16 79.85,66.16 80.13,66.44 80.43,66.44 80.86,66.87 81.28,66.87 81.57,66.59 82.07,66.59 82.4,66.92 82.83,66.92 83.1,66.65 84.52,66.65 84.76,66.89 86.12,66.89 86.41,66.6 86.86,66.6 87.15,66.9 87.61,66.9 88.07,67.36 88.47,67.36 88.72,67.11 89.32,67.11 89.69,67.48 89.93,67.48 90.19,67.75 90.19,69.83 90.06,70.06 89.95,70.13 89.67,70.13 89.48,70.32 89.48,71.06 89.28,71.41 89.14,71.5 88.85,71.5 88.57,71.22 87.89,71.22 87.61,71.5 86.72,71.5 v1(86.63,71.59)
FPGA_1V8_ASX4_D3: length 88.6
  L14_SIG5 w0.081: v1(29.61,50.77) 30.42,49.97 31.96,49.97 32.9,50.9 32.9,53.93 33.41,54.43 33.41,56.34 34.93,57.86 v1(34.93,58.69) 35.61,59.36 35.85,59.36 35.95,59.26 35.95,58.72 36.05,58.63 36.94,58.63 37.04,58.72 37.04,58.91 36.94,59.01 36.38,59.01 36.29,59.11 36.29,59.29 36.38,59.39 37.41,59.39 39.24,61.22 46.74,61.22 47.13,60.83 53.69,60.83 56.34,63.48 61.91,63.48 63.13,64.7 70.44,64.7 71.2,65.46 71.66,65.46 73.29,63.83 76.03,63.83 76.37,64.17 78.13,64.17 78.56,64.6 79.02,64.6 79.34,64.92 80.49,64.92 80.63,65.06 81.24,65.06 81.68,65.49 82.47,65.49 83.27,64.7 83.58,64.7 84.06,64.21 84.51,64.21 84.89,64.59 85.28,64.59 85.58,64.28 85.94,64.28 86.42,63.8 86.87,63.8 87.28,64.2 87.54,64.2 88.02,64.69 88.39,64.69 88.83,65.13 89.22,65.13 89.65,65.56 89.95,65.56 90.9,66.5 91.56,66.5 91.79,66.73 91.79,69.05 91.5,69.35 91.29,69.35 91.02,69.62 91.02,70.43 90.73,70.71 90.56,70.71 89.96,71.31 89.59,71.96 89.13,72.41 88.77,72.41 88.51,72.14 87.94,72.14 87.66,72.42 87.13,72.42 87.04,72.51 v1(86.63,72.51)
FPGA_1V8_ASX4_RESETN: length 85.5
  L14_SIG5 w0.081: v1(29.61,53.77) 29.61,55.47 31.88,57.74 v1(31.88,58.69) 31.38,59.2 31.38,59.69 32.3,60.62 32.3,60.82 32.13,60.99 31.99,60.99 31.69,60.69 31.55,60.69 31.36,60.87 31.36,61.05 33.7,63.39 33.85,63.39 34.05,63.19 34.05,63.05 32.58,61.58 32.58,61.41 32.71,61.28 32.91,61.28 35.06,63.43 35.47,63.43 35.57,63.33 35.57,63.03 35.67,62.93 36.18,62.93 36.27,63.03 36.27,63.35 36.37,63.45 36.87,63.45 36.96,63.35 36.96,63.03 37.06,62.93 37.52,62.93 37.62,63.03 37.62,63.35 37.71,63.45 38.14,63.45 38.23,63.35 38.23,63.03 38.33,62.93 38.86,62.93 38.96,63.03 38.96,63.35 39.05,63.45 39.53,63.45 39.63,63.35 39.63,63.03 39.73,62.93 40.2,62.93 40.3,63.03 40.3,63.35 40.4,63.45 40.93,63.45 41.03,63.35 41.03,63.03 41.13,62.93 41.73,62.93 41.84,62.82 53.75,62.82 56.29,65.35 59.52,65.35 60.56,66.39 65.04,66.39 65.16,66.51 65.16,66.66 65.3,66.8 66.34,66.8 66.53,66.6 67.88,66.6 68.28,67 68.28,67.95 69.09,68.76 69.95,68.76 70.07,68.64 70.07,68.09 70.21,67.95 72.34,67.95 72.92,67.37 74.71,67.37 75.19,67.85 75.19,68.02 75.27,68.1 76.69,68.1 77.3,67.49 79.03,67.49 79.33,67.79 79.68,67.79 79.94,67.54 80.55,67.54 80.83,67.82 81.49,67.82 81.75,67.56 83.66,67.56 83.88,67.79 84.48,67.79 84.77,67.5 85.2,67.5 85.48,67.79 86.13,67.79 86.37,67.54 86.88,67.54 87.24,67.9 87.51,67.9 87.94,68.33 88.32,68.33 88.79,68.8 89.06,68.8 89.36,69.1 89.41,69.23 89.41,69.37 89.29,69.57 89.14,69.66 88.76,69.66 88.66,69.75 v1(88.22,69.75)
FPGA_1V8_CATTRIPN: length 72
  L14_SIG5 w0.081: v1(85.04,70.67) 84.78,70.67 84.69,70.76 84.11,70.76 83.98,70.83 83.76,71.22 83.28,71.71 82.52,71.71 82.06,72.16 81.72,72.16 81.28,72.6 80.81,72.6 80.55,72.86 80.03,72.86 79.77,72.6 79.28,72.6 79.06,72.82 77.32,72.82 77.02,72.52 75.78,72.52 74.66,73.64 74.33,73.64 72.88,75.09 72.47,75.09 71.7,75.86 71.16,75.86 69.86,77.16 68.99,77.16 v1(68.79,77.36) 68.39,76.95 67.97,76.95 67.37,76.36 66.87,76.36 66.57,76.66 59.7,76.66 57.11,79.25 43.39,79.25 42.91,78.77 42.91,76.2 40.46,73.75 39.62,73.75 39.38,73.51 39.38,72.74 38.95,72.31 35.64,72.31 34.99,72.95 34.99,73.62 34.51,74.1 25.17,74.1 24.62,74.65 v1(24.18,74.65)
FPGA_1V8_CONF_DONE: length 98.9
  L14_SIG5 w0.081: v1(88.22,72.51) 87.86,72.51 87.76,72.6 87.28,72.6 86.91,72.97 86.43,72.97 86.03,72.57 85.75,72.57 85.33,72.14 84.88,72.14 84.61,72.41 84.61,73.25 84.34,73.52 84.06,73.52 83.57,74.01 83.17,74.01 82.82,74.37 82.51,74.37 82.12,74.77 81.83,74.77 81.36,75.24 80.81,75.24 80.48,74.9 80.02,74.9 79.65,75.27 78.66,75.27 76,77.93 72.14,77.93 71.27,78.81 68.44,78.81 68.19,78.56 66.88,78.56 65.89,79.55 62.62,79.55 61.89,78.82 60.59,78.82 58.94,80.47 55.24,80.47 54.59,81.12 54.01,81.12 53.64,80.76 49.56,80.76 49.19,81.12 48.39,81.12 48.06,80.79 40.79,80.79 40.06,80.06 40.06,77.75 39.38,77.07 39.38,76.53 39.07,76.23 38.36,76.23 38.28,76.3 37.02,76.3 36.74,76.02 34.22,76.02 33.17,77.07 31.94,77.07 31.62,77.39 31.62,77.8 31.28,78.15 17.91,78.15 17.18,77.42 v1(17.18,76.65)
  BOTTOM w0.149: Q15.1 14.04,82.57 15.76,80.85 15.76,78.07 v1(17.18,76.65) 17.67,77.14 23.38,77.14 23.63,76.89 23.63,76.2 v1(24.18,75.65)
FPGA_1V8_CVP_CONF_DONE: length 78.8
  L14_SIG5 w0.081: v1(86.63,68.83) 86.23,68.83 86.14,68.74 85.45,68.74 85.2,68.49 83.16,68.49 82.95,68.7 82.43,68.7 82.21,68.48 81.47,68.48 81.12,68.83 80.9,68.83 80.52,69.21 79.87,69.21 79.58,68.93 79.17,68.93 78.94,69.16 77.32,69.16 76.92,68.76 75.11,68.76 74.84,69.04 72.13,69.04 71.29,69.88 71.29,70.33 71,70.61 69.5,70.61 67.42,68.53 63.65,68.53 62.18,67.06 60,67.06 59.05,66.11 54.11,66.11 53.74,65.74 41.79,65.74 40.77,64.72 37.8,64.72 36.86,65.66 32.6,65.66 31.02,67.24 24.07,67.24 23.28,68.02 21.55,68.02 v1(21.17,67.64)
  BOTTOM w0.149: v1(21.17,67.64) 21.62,68.1 21.62,72.93 21.93,73.23 22.76,73.23 v1(23.18,73.65)
FPGA_1V8_INIT_DONE: length 75.1
  L14_SIG5 w0.081: v1(89.02,69.29) 88.08,69.29 87.69,69.67 87.25,69.67 86.85,69.27 86.37,69.27 86.01,68.92 84.06,68.92 83.78,69.2 83.13,69.2 82.86,68.92 82.34,68.92 82.04,69.21 81.68,69.21 81.24,69.65 80.85,69.65 80.61,69.41 79.87,69.41 79.64,69.64 79.19,69.64 78.92,69.38 78.55,69.38 78.1,69.83 77.32,69.83 76.59,70.56 75.47,70.56 75.04,70.13 75.04,69.63 74.68,69.27 72.33,69.27 71.78,69.82 71.78,70.47 71.34,70.91 62.51,70.91 60.99,69.4 59.6,69.4 58.54,68.34 38.38,68.34 37.94,68.79 34.53,68.79 34.16,69.15 26.06,69.15 25.69,69.52 25.69,69.98 25.51,70.15 22.88,70.15 21.68,71.35 21.68,72.15 v1(21.18,72.65)
FPGA_1V8_JTAG_TCK: length 78.9
  L14_SIG5 w0.081: v1(88.22,71.59) 87.86,71.59 87.77,71.68 87.12,71.68 86.79,72.01 86.42,72.01 86.23,71.81 86.23,70.95 86.02,70.74 85.5,70.74 85.21,71.04 84.88,71.04 84.42,71.5 83.99,71.5 83.53,71.96 83.3,71.96 82.81,72.44 82.51,72.44 82.03,72.93 81.73,72.93 81.6,73.06 79.94,73.06 79.69,73.31 78.21,73.31 76.84,74.67 76.84,75.84 76.27,76.41 73.22,76.41 72.8,76.82 71.02,76.82 70.27,77.57 69.17,77.57 69.01,77.73 68.59,77.73 68.23,77.37 66.92,77.37 66.59,77.04 59.94,77.04 57.37,79.61 42.83,79.61 41.79,78.57 41.79,76.3 41.18,75.69 40.6,75.69 40.04,75.14 38.13,75.14 37.57,74.57 35.03,74.57 34.56,75.03 32.37,75.03 32.25,75.15 20.98,75.15 20.68,74.85 20.68,74.15 v1(21.18,73.65)
FPGA_1V8_JTAG_TDI: length 77.6
  L14_SIG5 w0.081: v1(20.18,72.65) 20.58,72.65 20.99,73.06 21.34,73.06 21.68,72.72 21.68,72.55 22.08,72.15 22.48,72.15 22.68,71.95 22.68,71.45 22.98,71.15 24.48,71.15 24.83,70.79 26.33,70.79 26.98,70.15 33.95,70.15 34.32,69.78 37.36,69.78 37.78,69.35 58.63,69.35 60.25,70.98 61.29,70.98 62.68,72.37 66.12,72.37 68.11,74.36 v1(68.79,74.36) 69.73,73.42 69.73,72.09 70.52,71.3 71.81,71.3 72.45,70.66 75.06,70.66 75.39,71 77.56,71 78.34,70.21 78.82,70.21 79.21,69.83 79.76,69.83 80.05,70.11 80.58,70.11 80.83,69.86 81.36,69.86 81.69,70.19 82.13,70.19 82.48,69.84 82.83,69.84 83.29,69.38 83.86,69.38 84.13,69.66 84.48,69.66 84.85,69.28 85.25,69.28 85.63,69.66 86.04,69.66 86.21,69.75 86.38,70.05 86.51,70.12 86.82,70.12 87.27,70.58 87.83,70.58 88.11,70.3 88.64,70.3 88.73,70.21 v1(89.02,70.21)
FPGA_1V8_JTAG_TDO: length 75.1
  L14_SIG5 w0.081: v1(84.24,70.21) 83.9,70.21 83.84,70.28 83.32,70.28 82.86,70.74 82.51,70.74 82.03,71.22 81.69,71.22 81.28,71.62 80.81,71.62 80.48,71.95 79.88,71.95 79.62,71.7 79.19,71.7 79,71.88 75.19,71.88 74.86,71.56 74.23,71.56 73.9,71.89 73.9,72.75 72.6,74.04 70.73,74.04 68.9,75.88 68.04,75.88 67.27,75.11 62.29,75.11 61.9,74.73 57.88,74.73 57.69,74.54 57.69,74.13 57.88,73.94 59.53,73.94 59.68,73.8 59.68,73.2 59.49,73.01 54.39,73.01 53.78,72.41 48.29,72.41 47.71,71.83 41.4,71.83 41.06,72.17 39.88,72.17 39.4,71.69 37.03,71.69 36.48,71.15 35.36,71.15 34.28,72.23 24.98,72.23 24.68,72.53 24.68,72.85 24.38,73.15 23.98,73.15 23.68,73.45 23.68,73.85 23.28,74.25 21.88,74.25 21.48,74.65 v1(21.18,74.65)
FPGA_1V8_JTAG_TMS: length 77.5
  L14_SIG5 w0.081: v1(20.18,73.65) 20.58,73.25 23.28,73.25 23.68,72.85 23.68,72.45 23.98,72.15 24.48,72.15 24.68,71.95 24.68,71.45 24.88,71.25 33.56,71.25 34.65,70.16 38.26,70.16 38.69,69.72 41.74,69.72 42.54,70.52 58.84,70.52 62.06,73.74 66.54,73.74 68.16,75.36 v1(68.79,75.36) 70.34,73.81 70.34,73.37 70.75,72.96 72.11,72.96 72.93,72.14 72.93,71.65 73.41,71.17 74.99,71.17 75.31,71.49 79.66,71.49 79.97,71.18 80.45,71.18 80.91,70.71 81.3,70.71 81.62,71.03 81.96,71.03 82.44,70.55 82.79,70.55 83.24,70.09 83.67,70.09 83.92,69.84 84.62,69.84 84.9,70.12 85.24,70.12 85.51,69.84 85.95,69.84 86.1,69.92 86.26,70.2 86.46,70.32 86.76,70.32 87.2,70.76 87.63,70.76 87.91,71.04 88.93,71.04 v1(89.02,71.13)
FPGA_1V8_MSEL1: length 397.3
  L12_SIG4 w0.089: v1(21.18,71.65) 20.81,71.65 20.32,71.16 19.92,71.16 19.79,71.03 19.79,66.65 25.48,60.96 25.48,58.65 28.63,55.51 28.63,51.19 33.23,46.59 34.17,46.59 39.05,41.71 39.05,41.02 42.76,37.32 49.16,37.32 50.15,38.31 54.36,38.31 55.35,37.32 58,37.32 61.9,33.41 62.3,33.41 63,32.71 63,27.31 63.66,26.65 64.27,26.65 64.62,26.29 64.62,25.99 65.79,24.82 65.79,23.46 67.52,21.73 68.38,21.73 69.17,20.94 69.17,19.28 74,14.46 76.64,14.46 76.89,14.2 83.55,14.2 84.18,13.57 88.91,13.57 89.14,13.79 117.96,13.79 119.16,14.99 130.31,14.99 132.36,17.05 132.36,17.63 133.84,19.1 133.84,22.87 135.39,24.43 142.1,24.43 143.87,22.66 145.23,22.66 146.47,21.41 149,21.41 150.45,19.97 150.45,17.53 153.92,14.06 212.45,14.06 212.8,14.42 215.41,14.42 219.04,18.05 220.49,18.05 221.09,18.65 221.56,18.65 221.8,18.41 223.02,18.41 223.26,18.65 225.33,18.65 231.53,24.85 241.25,24.85 243.94,22.15 247.62,22.15 248.55,23.08 248.55,24.65 249.36,25.45 249.36,27.08 248.7,27.74 248.7,37.59 248.25,38.04 248.25,46.9 v1(251.21,49.86)
  L14_SIG5 w0.081: v1(21.18,71.65) 20.76,71.24 18.94,71.24 17.43,72.75 17.43,75.39 16.75,76.08 16.75,78.16 18.02,79.43 18.6,79.43 18.88,79.15 31.26,79.15 31.65,78.76 31.65,78.39 31.88,78.15 32.29,78.15 32.95,77.49 33.34,77.49 33.68,77.15 34.27,77.15 35.16,76.27 36.51,76.27 37.08,76.84 38.24,76.84 38.45,77.05 38.65,77.05 39.55,77.95 39.55,80.19 40.49,81.13 48.07,81.13 48.29,81.35 49.45,81.35 49.71,81.09 53.46,81.09 53.73,81.35 54.75,81.35 55.39,80.71 59.94,80.71 60.36,81.13 62.54,81.13 63.28,81.87 63.74,81.87 64.7,80.9 65.03,80.9 65.26,80.67 65.26,80.16 65.5,79.92 66.86,79.92 67.34,79.44 67.34,79.1 67.61,78.84 68.08,78.84 68.28,79.04 71.39,79.04 72.21,78.22 76.07,78.22 78.56,75.73 v1(79.46,75.73)
FPGA_1V8_MSEL2: length 394.6
  L12_SIG4 w0.089: v1(19.18,72.65) 18.68,72.15 18.68,67.23 24.54,61.36 24.54,58.95 28.2,55.29 28.2,50.98 33.1,46.08 34.03,46.08 38.59,41.51 38.59,40.72 42.32,36.99 49.66,36.99 50.6,37.92 53.98,37.92 54.92,36.99 57.36,36.99 62.42,31.93 62.42,27.28 63.19,26.51 63.19,25.01 67.01,21.19 68.3,21.19 68.71,20.78 68.71,19.15 74.07,13.79 83.55,13.79 84.06,13.29 117.92,13.29 119.38,14.75 130.42,14.75 132.62,16.94 132.62,17.33 134.19,18.9 134.19,22.58 135.67,24.06 141.85,24.06 143.57,22.34 145.04,22.34 146.24,21.14 148.88,21.14 150.04,19.97 150.04,17.38 153.64,13.78 215.4,13.78 219.3,17.68 225.15,17.68 231.95,24.48 240.57,24.48 243.42,21.63 247.82,21.63 248.9,22.71 248.9,24.54 249.6,25.24 249.6,27.4 249.05,27.94 249.05,45.88 251.8,48.62 251.8,50.55 v1(251.21,51.13)
  L14_SIG5 w0.081: v1(85.04,71.59) 84.65,71.59 84.52,71.71 84.1,71.71 83.29,72.53 82.87,73.24 82.77,73.31 81.51,73.31 81.26,73.55 80.71,73.55 80.5,73.76 79.94,73.76 79.73,73.55 78.58,73.55 77.35,74.78 77.35,75.85 76.03,77.17 72.04,77.17 71,78.2 70.11,78.2 69.9,77.98 67.01,77.98 66.45,77.42 60.21,77.42 57.68,79.96 42.49,79.96 41.38,78.85 41.38,77.35 39.66,75.62 38.21,75.62 38.03,75.8 37.57,75.8 37.37,75.59 37.37,75.26 37.1,74.99 35.24,74.99 34.87,75.37 34.04,75.37 33.38,76.02 31.45,76.02 31.33,76.15 19.98,76.15 19.68,75.85 19.68,73.15 v1(19.18,72.65)
FPGA_1V8_NCONFIG: length 73.5
  L14_SIG5 w0.081: v1(85.83,70.21) 85.47,70.21 85.37,70.3 84.75,70.3 84.47,70.58 84.02,70.58 83.87,70.66 83.72,70.92 83.14,71.5 82.43,71.5 81.98,71.95 81.65,71.95 81.19,72.41 80.82,72.41 80.57,72.17 79.88,72.17 79.65,72.4 77.66,72.4 77.48,72.21 75.5,72.21 74.51,73.21 74.12,73.21 72.85,74.48 71.51,74.48 69.63,76.36 v1(68.79,76.36) 68,76.36 67.52,75.88 66.84,75.88 66.53,76.19 59.54,76.19 56.73,79 43.82,79 43.24,78.41 43.24,74.6 41.27,72.64 39.82,72.64 39.22,72.04 35.46,72.04 34.26,73.25 24.88,73.25 24.68,73.45 24.68,73.85 24.38,74.15 23.68,74.15 v1(23.18,74.65)
FPGA_1V8_NSTATUS: length 81.4
  L14_SIG5 w0.081: v1(85.83,71.13) 85.83,71.45 85.33,71.96 84.81,71.96 84.32,72.44 84.09,72.44 83.79,72.74 83.21,73.07 83.02,73.42 82.85,73.51 82.12,73.51 81.33,74.3 80.75,74.3 80.45,74 80,74 79.63,74.37 79.21,74.37 76.03,77.55 72.11,77.55 71.17,78.5 69.84,78.5 69.7,78.36 v1(68.79,78.36) 68.39,78.36 68.31,78.28 66.82,78.28 66.6,78.06 60.46,78.06 58.29,80.23 40.94,80.23 40.47,79.76 40.47,77.6 39.91,77.04 39.91,76.51 39.38,75.97 38.18,75.97 38.11,76.05 37.26,76.05 36.99,75.78 34.03,75.78 33.53,76.28 31.96,76.28 31.63,76.61 31.63,76.82 31.3,77.15 18.98,77.15 18.68,76.85 18.68,72.15 v1(19.18,71.65)
FPGA_1V8_SVID_SCL: length 177.9
  TOP w0.149: v1(193.68,65.61) 193.94,65.35 U36.3
  L03_SIG1 w0.081: v4(85.83,72.05) 85.83,72.4 86.4,72.97 86.8,72.97 87.01,73.17 87.01,74.1 87.24,74.33 87.52,74.33 88.01,74.82 88.35,74.82 88.78,75.25 89.13,75.25 89.6,75.71 90.04,75.71 90.47,75.29 90.77,75.29 91.16,75.68 91.56,75.68 91.98,75.26 92.36,75.26 92.78,75.68 93.22,75.68 93.65,75.25 93.96,75.25 94.39,75.69 94.78,75.69 95.17,75.3 95.56,75.3 95.97,75.7 96.36,75.7 96.77,75.3 97.16,75.3 97.59,75.73 97.95,75.73 98.37,75.3 98.77,75.3 99.2,75.74 99.57,75.74 100.05,75.26 100.35,75.26 100.79,74.82 101.69,74.82 102.12,75.25 103.54,75.25 103.97,74.82 104.32,74.82 105.13,74 106.07,74 106.97,73.1 107.73,72.78 107.96,72.56 108.32,72.56 108.65,72.88 109.15,72.88 110.09,73.82 110.09,76.58 112.02,78.51 112.38,78.51 112.83,78.97 113.19,78.97 113.65,79.43 113.93,79.43 114.38,79.89 114.79,79.89 115.22,80.32 115.48,80.32 115.88,80.72 116.24,80.72 116.72,81.21 117.1,81.21 117.56,81.66 117.91,81.66 118.32,82.07 118.75,82.07 119.01,81.82 119.49,81.82 119.72,82.04 120.35,82.04 120.58,81.82 121.11,81.82 121.39,82.1 122.31,82.1 122.54,81.87 124.34,81.87 129.93,76.28 132.98,76.28 134.25,77.55 134.25,78.18 134.75,78.69 153.55,78.69 153.8,78.44 154.69,78.44 155.18,78.92 155.18,79.56 155.68,80.06 159.19,80.06 159.57,80.44 159.57,85.26 161.36,87.05 161.36,88.91 162.16,89.72 163.94,89.72 164.73,90.5 164.73,90.76 165.23,91.26 170.82,91.26 171.77,92.22 187.9,92.22 189.36,93.68 197.87,93.68 203.97,87.58 203.97,83.14 v1(203.08,82.25)
  L16_SIG6 w0.081: v1(193.68,65.61) 194.32,64.98 196.65,64.98 199.91,68.23 199.91,73.36 200.54,73.99 200.54,74.63 202.7,76.79 202.7,81.87 v1(203.08,82.25)
  BOTTOM w0.149: R366.1 v1(193.68,65.61)
FPGA_1V8_SVID_SDA: length 178.1
  TOP w0.149: v1(192.92,65.61) 193,65.61 193.44,65.17 U36.4
  L03_SIG1 w0.081: v4(86.63,69.75) 86.63,70.13 87.04,70.54 87.04,72.33 87.24,72.53 87.61,72.53 88.08,73.01 88.41,73.01 88.65,73.24 88.65,74.12 88.87,74.34 89.14,74.34 89.6,74.8 89.96,74.8 90.43,74.33 90.8,74.33 91.21,74.73 91.56,74.73 91.97,74.33 92.35,74.33 92.74,74.72 93.25,74.72 93.65,74.33 94.04,74.33 94.4,74.69 94.87,74.69 95.23,74.33 95.64,74.33 96.01,74.71 96.44,74.71 96.82,74.33 97.18,74.33 97.59,74.73 98.01,74.73 98.41,74.33 98.73,74.33 99.14,74.74 99.57,74.74 100.41,73.9 101.49,73.9 102.32,74.73 103.19,74.73 103.97,73.95 104.52,73.95 104.99,73.48 105.42,73.48 106.4,72.51 106.76,72.51 107.19,72.08 107.42,72.08 107.91,71.6 108.29,71.6 108.76,72.07 109.22,72.07 109.65,72.49 109.83,72.49 111.11,73.76 111.11,75.75 113.09,77.73 113.09,78.06 113.49,78.46 113.85,78.46 114.31,78.92 114.69,78.92 115.22,79.45 115.53,79.45 115.98,79.91 116.21,79.91 116.62,80.32 117.05,80.32 117.61,80.88 117.99,80.88 118.29,81.18 118.57,81.18 118.98,81.59 119.51,81.59 119.77,81.33 120.43,81.33 120.68,81.59 121.04,81.59 121.29,81.33 122.03,81.33 122.28,81.59 124.24,81.59 129.88,75.95 133.28,75.95 134.37,77.04 154.72,77.04 155.46,77.78 155.46,79.23 156.01,79.78 159.42,79.78 160,80.37 160,84.05 161.88,85.93 161.88,88.8 162.44,89.36 164.22,89.36 165.11,90.25 170.95,90.25 171.77,91.07 199.33,91.07 203.59,86.82 203.59,83.64 202.57,82.63 202.57,81.49 v1(203.08,80.98)
  L16_SIG6 w0.081: v1(192.92,65.61) 194.14,64.39 197.16,64.39 201.05,68.28 201.05,74.37 203.08,76.41 v1(203.08,80.98)
  BOTTOM w0.149: R367.1 192.92,65.17 v1(192.92,65.61)
FPGA_3V3_LED0: length 19.8
  BOTTOM w0.149: Q7.1 237.01,100.41 234.45,100.41 233.56,99.52 221.81,99.52 221.69,99.65 R822.2 221.56,100.15 221.24,100.15 220.84,99.75 U87.10
FPGA_3V3_LED1: length 16.2
  BOTTOM w0.149: U87.9 220.73,100.15 221.24,100.66 221.24,100.92 221.37,101.04 R823.2 221.69,100.66 221.81,100.54 223.27,100.54 223.78,100.03 232.8,100.03 234.26,101.49 Q12.1
FPGA_3V3_LED2: length 13
  BOTTOM w0.149: U87.8 220.63,100.55 220.86,100.79 220.86,101.7 221.22,102.06 R824.2 221.69,101.74 221.88,101.55 223.15,101.55 224.16,100.54 229.5,100.54 230.45,101.49 Q13.1
FPGA_3V3_LED3: length 9.2
  BOTTOM w0.149: U87.7 220.35,100.95 220.48,101.08 220.48,102.44 221.11,103.08 R825.2 221.69,102.76 221.88,102.57 223.78,102.57 224.04,102.82 225.54,102.82 Q14.1
FPGA_3V3_SCL: length 136.1
  TOP w0.149: J7.11 v1(50.02,25.56)
  L03_SIG1 w0.081: v1(40.01,95.96) 41.21,94.77 48.34,94.77 49.6,96.03 62.55,96.03 63.38,96.85 v1(66.36,96.85)
  L07_SIG3 w0.089: v1(31.33,24.29) 30.49,25.14 30.49,26.4 v1(30.89,26.81) ; v1(50.02,25.56) 51.06,26.6 51.06,36.68 49.28,38.46 49.28,42.95 46.68,45.54 46.34,45.54 44.88,47 v1(44.88,47.35) 45.32,47.35 45.85,47.88 45.85,50.17 44.43,51.59 44.43,57.38 41.16,60.66 41.16,62.56 39.76,63.96 39.76,65.36 38.28,66.83 38.28,74.32 37.85,74.75 36.89,74.75 36.46,75.19 36.46,75.64 38.49,77.68 38.49,80.09 37.35,81.23 37.35,81.95 37.77,82.38 37.77,86.11 37.98,86.31 37.98,89.99 39.25,91.26 39.25,95.2 v1(40.01,95.96)
  L14_SIG5 w0.081: v1(50.02,25.56) 49.56,26.02 49.56,26.27 48.57,27.26 44.2,27.26 43.14,26.19 35.41,26.19 34.88,25.66 33.97,25.66 33.59,26.04 32.72,26.04 32.27,25.58 31.86,25.58 30.89,26.55 v1(30.89,26.81)
  BOTTOM w0.149: v1(66.36,96.85) 66.5,96.98 U38.6
FPGA_3V3_SDA: length 141.3
  L03_SIG1 w0.081: v1(39,95.96) 40.52,94.44 52.22,94.44 52.98,95.2 63.25,95.2 64,95.95 v1(66.32,95.95)
  L07_SIG3 w0.089: v1(49.8,24.78) 49.41,25.17 49.41,26.62 50.68,27.89 50.68,35.71 48.65,37.74 48.65,41.96 47.07,43.54 47.07,44.29 44.81,46.55 v1(43.73,46.55) 43.73,48.38 43.92,48.57 45.04,48.57 45.3,48.82 45.3,49.43 44.05,50.68 44.05,57.32 40.77,60.59 40.77,62.31 37.35,65.74 37.35,73.76 36.18,74.93 36.18,76.13 37.35,77.29 37.35,78.06 37.09,78.31 37.09,79.71 36.46,80.34 36.46,80.85 36.2,81.1 35.82,81.1 35.57,81.36 35.57,87.2 36.84,88.47 36.84,89.49 38.87,91.52 38.87,95.11 39,95.23 v1(39,95.96) ; v1(31.98,23.53) 31.88,23.63 31.88,24.84 31.5,25.23 31.5,26.15 v1(32.16,26.81)
  L14_SIG5 w0.081: v1(32.16,26.81) 31.71,27.26 30.72,27.26 30.49,27.03 30.49,26.49 32.04,24.95 33.66,24.95 33.94,25.22 43.03,25.22 43.97,26.16 46.41,26.16 47.02,25.55 49.03,25.55 v1(49.8,24.78)
  BOTTOM w0.149: U38.5 67.07,96.48 66.54,95.95 v1(66.32,95.95)
FPGA_3V3_SVID_SCL: length 83.5
  TOP w0.149: v1(193.68,60.53) 193.94,60.79 U36.6 ; R6907.2 v1(236.04,37.29)
  TOP w0.203: 182.11,49.88 U61.15
  TOP w0.267: 182.11,49.88 183.14,48.85 184.67,48.85 185.81,47.7 v1(186.38,47.7)
  L05_SIG2 w0.081: v1(186.38,47.7) 184.8,49.28 184.8,53.3 186.76,55.26 188.41,55.26 190.25,57.1 190.25,59.26 191.98,60.99 193.22,60.99 v1(193.68,60.53)
  L16_SIG6 w0.081: v1(236.04,37.29) 234.59,38.74 227.51,38.74 227.3,38.95 226.36,38.95 225.91,39.4 225.91,39.91 225.41,40.41 221.14,40.41 218.57,42.98 213.42,42.98 212.27,44.12 188.88,44.12 186.38,46.62 v1(186.38,47.7)
  BOTTOM w0.149: R369.1 v1(193.68,60.53)
FPGA_3V3_SVID_SDA: length 82.7
  TOP w0.149: v1(192.79,60.53) 193.44,61.18 U36.5 ; R6906.2 v1(238.2,37.29)
  TOP w0.203: U61.16 182.51,50.11
  TOP w0.267: v1(186.38,48.59) 185.81,48.59 184.92,49.48 183.14,49.48 182.51,50.11
  L05_SIG2 w0.081: v1(186.38,48.59) 185.18,49.79 185.18,52.92 186.63,54.37 188.41,54.37 191.4,57.36 191.4,59.64 192.29,60.53 v1(192.79,60.53)
  L16_SIG6 w0.081: v1(186.38,48.59) 186.8,48.17 186.8,46.79 189.05,44.54 212.45,44.54 213.59,43.4 218.96,43.4 221.64,40.71 225.71,40.71 226.24,40.17 226.24,39.58 226.53,39.29 227.62,39.29 227.79,39.12 235.03,39.12 236.86,37.29 v1(238.2,37.29)
  BOTTOM w0.149: v1(192.79,60.53) 192.79,61.1 R368.1
FPGA_CXL_PERSTN: length 91.1
  L07_SIG3 w0.089: v1(60.33,104.73) 58.71,104.73 57.77,103.8 52.56,103.8 50.55,101.79 50.55,94.69 49.77,93.91 49.77,92.35 49.9,92.03 49.9,87.8 50.24,87.47 50.24,80.35 51.03,79.56 56.22,79.56 62.3,73.48 62.3,71.1 61.99,70.79 61.99,68.6 62.5,68.09 62.5,66.46 61.22,65.18 v1(61.22,63.96)
  L14_SIG5 w0.081: v1(89.02,66.53) 88.77,66.27 88.77,66.11 88.29,65.63 88.02,65.63 87.55,65.15 87.29,65.15 86.86,64.73 86.44,64.73 85.93,65.24 85.64,65.24 85.25,65.62 84.8,65.62 84.42,66 83.97,66 83.69,65.72 81.64,65.72 81.16,65.24 79.25,65.24 78.79,64.78 76.19,64.78 75.65,64.24 74.28,64.24 74,64.52 74,65.46 73.62,65.84 70.95,65.84 70.14,65.03 62.85,65.03 61.78,63.96 v1(61.22,63.96)
  BOTTOM w0.149: v1(60.33,104.73) R127.2
FPGA_CXL_PRSNTX4_N: length 65.3
  L12_SIG4 w0.089: v1(83.44,43.99) 82.78,43.99 82.43,43.64 81.11,43.64 80.4,44.35 80.02,44.35 79.76,44.1 77.71,44.1 77.15,44.66 74.33,44.66 73.87,45.11 58.43,45.11 57.94,44.63 56.73,44.63 54.74,46.61 51.21,46.61 50.48,47.35 46.03,47.35 45.6,46.92 44.71,46.92 43.95,47.68 43.95,48.34 43.31,48.97 42.83,48.97 42.02,49.78 42.02,53.83 39,56.85 39,58.24 37.47,59.77 v1(37.47,60.15)
  BOTTOM w0.149: U22.2 38.56,64.5 38.73,64.66 R786.1 39.33,61.22 38.26,60.15 v1(37.47,60.15)
FPGA_CXL_RSTN: length 285.2
  L03_SIG1 w0.081: v1(222.51,18.82) 222.51,19.38 222.64,19.51 222.64,22.99 222.31,23.32 222.31,26.24 221.7,26.85 221.7,30.25 218.19,33.76 218.19,36.22 217.88,36.53 217.88,38.38 218.12,38.62 218.12,39.17 217.88,39.4 217.88,41.17 219.19,42.47 219.19,58.12 218.65,58.65 218.65,65.05 220.51,66.91 220.51,76.12 219.56,77.07 219.56,82.91 218.23,84.24 218.23,100.88 217.81,101.3 217.81,102.26 217.49,102.58 211.92,102.58 210.38,101.04 v1(209.81,101.04)
  L07_SIG3 w0.089: v1(88.22,43.07) 87.84,42.68 87.84,41.48 87.15,40.8 85.55,40.8 84.97,40.21 83.81,40.21 82.3,38.7 81.56,38.7 77.78,34.92 77.78,24.7 77.08,23.99 76.34,23.99 75.85,23.5 75.85,18.62 75.22,17.99 74.99,17.99 74.48,17.48 74.48,16.92 75.55,15.85 112.38,15.85 113.82,14.4 133.36,14.4 135.31,16.36 154.34,16.36 154.69,16.72 163.33,16.72 163.48,16.56 178.19,16.56 178.47,16.84 186.21,16.84 186.7,16.36 216.39,16.36 218.85,18.82 219.67,18.82 220.23,19.38 221.95,19.38 v1(222.51,18.82)
  BOTTOM w0.149: v1(209.81,101.04) 209.94,100.92 209.94,100.71 210.5,100.15 U88.3
FPGA_GNDSENSE: length 34.4
  L12_SIG4 w0.203: v1(132.66,71.83) 132.94,72.11 133.23,72.11 133.36,71.98 133.36,71.69 131.58,69.92 123.76,69.92 123.41,70.26 123.06,70.26 122.63,70.69 120.71,70.69 120.3,71.1 119.91,71.1 119.76,71.01 119.66,70.83 119.37,70.67 119.17,70.67 118.96,70.54 118.84,70.33 118.63,70.21 118.38,70.21 118.16,70.09 118.03,69.85 117.85,69.75 117.63,69.75 116.55,69.13 116.47,68.99 116.19,68.83 115.92,68.83 115.63,68.54 115.63,68.28 115.75,68.06 115.75,67.75 115.64,67.55 115.46,67.45 115.15,67.45 115,67.36 114.86,67.13 114.62,66.99 114.4,66.99 114.17,66.86 114.04,66.62 113.87,66.53 113.61,66.53 113.38,66.4 113.25,66.18 113.06,66.07 112.79,66.07 112.59,65.95 112.46,65.72 112.26,65.61 112,65.61 111.79,65.49 111.66,65.25 111.47,65.15 111.18,65.15 111,65.04 110.86,64.79 110.7,64.7 110.43,64.7 110.2,64.56 110.05,64.31 109.91,64.23 109.62,64.23 109.4,64.1 109.25,63.85 109.11,63.77 108.83,63.77 108.6,63.64 108.5,63.47 108.22,63.31 107.95,63.31 107.7,63.06 107.7,62.69 107.8,62.51 107.8,62.26 107.68,62.04 107.68,61.81 v1(108.14,61.01)
  BOTTOM w0.254: R534.1 v1(132.66,71.83)
FPGA_OSC_CLK1: length 20
  TOP w0.149: R107.2 75.22,75.87 v1(76.22,75.87)
  BOTTOM w0.149: v1(89.82,69.75) 89.54,70.02 89.54,70.31 89.29,70.56 89.29,70.82 89.42,70.95 89.42,71.29 89.29,71.43 89.29,71.45 89.16,71.58 88.91,71.58 88.4,72.09 88.07,72.09 87.79,72.37 87.79,72.67 87.85,72.74 87.85,73.14 87.54,73.46 87.23,73.46 86.8,73.89 86.47,73.89 85.99,74.37 85.58,74.37 85.2,74.75 84.87,74.75 84.49,74.37 84.04,74.37 83.66,74.75 83.22,74.75 82.84,74.37 82.44,74.37 82.03,74.78 81.66,74.78 81.25,74.37 80.8,74.37 80.42,74.75 80.09,74.75 79.64,74.3 78.19,74.3 76.61,75.87 v1(76.22,75.87)
FPGA_RCVD_CLK1_REFOUT_N: length 17
  TOP w0.102: C1009.1 72.95,53.02 73.18,53.02 v1(73.51,53.36)
  L14_SIG5 w0.079: 80.96,54.01 80.94,53.99 80.33,53.99 79.89,53.55 76.33,53.55 75.54,54.34 75.22,54.34 75.12,54.24 75.12,54.13 75.01,54.03 74.83,54.03 74.73,54.13 74.73,54.24 74.63,54.34 74.45,54.34 74.35,54.24 74.35,54.13 74.25,54.03 74.07,54.03 73.97,54.13 73.97,54.24 73.86,54.34 73.49,54.34 72.76,53.6 72.76,53.11 72.98,52.88 73.44,52.88 73.51,52.95 v1(73.51,53.36)
  L14_SIG5 w0.081: v1(84.24,52.73) 84.24,53 84.15,53.09 84,53.09 83.83,53.19 83.67,53.46 83.5,53.56 83.23,53.56 82.82,53.98 82.47,53.98 82.08,53.58 81.6,53.58 81.18,54.01 80.96,54.01
FPGA_RCVD_CLK1_REFOUT_P: length 16.7
  TOP w0.102: v1(73.51,52.47) 73.19,52.79 72.95,52.79 C1008.1
  L14_SIG5 w0.079: 80.96,54.21 80.95,54.22 80.24,54.22 79.79,53.77 76.43,53.77 75.64,54.57 73.4,54.57 72.53,53.7 72.53,53.01 72.89,52.65 73.33,52.65 v1(73.51,52.47)
  L14_SIG5 w0.081: v1(84.24,53.65) 84.24,53.33 84.19,53.29 84.06,53.29 83.97,53.34 83.81,53.6 83.55,53.76 83.31,53.76 82.9,54.17 82.39,54.17 82,53.78 81.68,53.78 81.26,54.21 80.96,54.21
FPGA_RCVD_CLK2_REFOUT_N: length 19.4
  TOP w0.102: v1(73.51,49.8) 73.18,49.46 72.95,49.46 C1011.1
  L07_SIG3 w0.081: 86.97,48.25 86.97,48.27 86.98,48.29 86.98,48.74 86.89,48.83 86.89,49.16 87.05,49.49 87.06,49.54 87,49.63 86.89,49.66 v1(86.63,49.51)
  L07_SIG3 w0.085: v1(73.51,49.8) 73.84,49.47 75.64,49.47 78.24,46.86 79.97,46.86 80.11,47.01 80.36,47.01 80.51,46.86 81.15,46.86 81.31,46.95 81.42,47.15 81.71,47.32 82.45,47.32 82.59,47.46 82.85,47.46 82.99,47.32 83.61,47.32 83.87,47.16 84,46.95 84.15,46.87 84.74,46.87 84.88,47.01 85.14,47.01 85.28,46.87 85.99,46.87 86.31,47.19 86.31,47.39 86.49,47.57 86.69,47.57 86.97,47.84 86.97,48.25
FPGA_RCVD_CLK2_REFOUT_P: length 19.3
  TOP w0.102: C1010.1 72.95,49.23 73.19,49.23 v1(73.51,48.91)
  L07_SIG3 w0.081: 87.19,48.25 87.19,48.27 87.18,48.29 87.18,48.82 87.09,48.91 87.09,49.11 87.24,49.43 87.26,49.59 87.19,49.72 87.22,49.85 v1(87.43,49.97)
  L07_SIG3 w0.085: 87.19,48.25 87.19,47.75 86.08,46.64 84.09,46.64 83.83,46.79 83.71,47 83.55,47.09 81.77,47.09 81.59,46.98 81.47,46.79 81.21,46.63 78.15,46.63 75.54,49.24 73.84,49.24 v1(73.51,48.91)
FPGA_TEMP0AN: length 26.2
  BOTTOM w0.229: v1(83.44,70.67) 83.7,70.92 83.7,71.21 83.89,71.4 83.89,71.77 83.63,72.03 83.25,72.03 82.83,71.61 82.46,71.61 82.04,72.03 81.66,72.03 81.24,71.61 80.87,71.61 80.45,72.03 80.07,72.03 79.64,71.61 79.28,71.61 79.05,71.83 78.87,71.83
  BOTTOM w0.254: v1(64.17,75.64) 64.17,74.58 64.67,74.08 65.52,74.08 66.23,73.38 68.67,73.38 69.1,72.95 69.1,71.33 69.73,70.69 77.38,70.69 78.52,71.83 78.87,71.83
FPGA_TEMP0AP: length 27.8
  BOTTOM w0.229: v1(84.24,71.13) 84.24,71.26 84.24,71.26 84.24,71.42 84.68,71.86 84.68,72.23 84.39,72.53 84.06,72.53 83.63,72.95 83.25,72.95 82.83,72.53 82.46,72.53 82.04,72.95 81.66,72.95 81.24,72.53 80.87,72.53 80.45,72.95 80.07,72.95 79.64,72.53 79.31,72.53 79,72.21 78.87,72.21
  BOTTOM w0.254: v1(63.41,75.64) 63.92,76.15 64.4,76.15 64.65,75.9 64.65,75.49 66.38,73.76 68.82,73.76 69.48,73.1 69.48,71.48 69.89,71.07 77.22,71.07 78.37,72.21 78.87,72.21
FPGA_TEMP3N: length 64.1
  L16_SIG6 w0.203: v1(114.52,69.29) 114.52,69.58 114.94,70.01 114.94,70.39 114.66,70.67 114.33,70.67 113.88,71.12 113.57,71.12 113.11,71.58 112.76,71.58 112.28,72.06 112,72.06 111.89,72.17 111.55,72.51 111.17,72.51 110.7,72.98 110.34,72.98 109.88,72.51 109.54,72.51 109.1,72.95 108.74,72.95 108.3,72.51 107.99,72.51 107.58,72.93 107.12,72.93 106.7,72.51 106.36,72.51 105.91,72.95 105.57,72.95 105.13,72.51 104.81,72.51 104.39,72.93 103.97,72.93 103.55,72.51 103.21,72.51 102.78,72.94 102.35,72.94 101.93,72.51 101.62,72.51 101.2,72.93 100.81,72.93 100.39,72.51 100.02,72.51 99.55,72.98 99.24,72.98 98.78,72.51 98.39,72.51 97.92,72.98 97.62,72.98 97.15,72.51 96.84,72.51 96.42,72.93 95.96,72.93 95.55,72.51 95.2,72.51 94.76,72.95 94.42,72.95 93.97,72.51 93.65,72.51 93.23,72.93 92.81,72.93 92.4,72.51 92.05,72.51 91.6,72.96 91.23,72.96 90.77,72.51 90.44,72.51 90,72.06 89.67,72.06 89.19,71.58 88.83,71.58 88.4,71.15 88.09,71.15 87.61,70.67 87.26,70.67 86.82,70.23 86.47,70.23 86.03,70.67 85.66,70.67 85.2,70.21 84.87,70.21 84.41,70.67 84.05,70.67 83.59,71.13 83.29,71.13 82.83,71.59 82.5,71.59 82.07,72.01 81.69,72.01 81.21,72.49 80.88,72.49 80.41,72.97 80.05,72.97 79.61,73.41 78.83,73.41 77.22,75.02 77.22,76 75.65,77.57 72.79,77.57 71.11,79.25 68.55,79.25 67.77,78.47 67.77,76.44 66.82,75.49 66.45,75.49 v1(66.2,75.74)
FPGA_TEMP3P: length 63.1
  L16_SIG6 w0.203: v1(113.72,69.75) 113.52,69.95 113.52,70.21 113.24,70.49 113.04,70.69 112.73,70.69 112.3,71.12 111.95,71.12 111.49,71.59 111.19,71.59 110.77,72.01 110.32,72.01 109.9,71.59 109.57,71.59 109.15,72.01 108.72,72.01 108.3,71.59 107.93,71.59 107.48,72.04 107.17,72.04 106.72,71.59 106.4,71.59 105.92,72.06 105.59,72.06 105.12,71.59 104.76,71.59 104.31,72.04 103.99,72.04 103.55,71.59 103.2,71.59 102.72,72.06 102.45,72.06 101.97,71.59 101.57,71.59 101.18,71.99 100.77,71.99 100.37,71.59 99.97,71.59 99.55,72.01 99.16,72.01 98.74,71.59 98.42,71.59 98,72.01 97.56,72.01 97.14,71.59 96.78,71.59 96.33,72.04 96.02,72.04 95.57,71.59 95.25,71.59 94.77,72.06 94.44,72.06 93.97,71.59 93.65,71.59 93.2,72.04 92.84,72.04 92.39,71.59 92.04,71.59 91.57,72.06 91.27,72.06 90.79,71.59 90.44,71.59 90,71.15 89.67,71.15 89.19,70.67 88.81,70.67 88.32,70.18 88.04,70.18 87.61,69.75 87.28,69.75 86.82,69.29 86.47,69.29 86.01,69.75 85.66,69.75 85.23,69.32 84.84,69.32 84.41,69.75 84.08,69.75 83.62,70.21 83.27,70.21 82.8,70.68 82.47,70.68 82,71.15 81.69,71.15 81.29,71.55 80.93,71.55 80.44,72.05 80.11,72.05 79.61,72.55 79.23,72.55 76.89,74.88 76.89,75.86 75.51,77.24 72.65,77.24 70.97,78.92 68.69,78.92 68.1,78.34 68.1,76.3 66.96,75.16 65.76,75.16 v1(65.18,75.74)
FPGA_TEMP4N: length 52.4
  TOP w0.254: v1(77.22,50.75) 76.92,50.75 76.59,51.08 76.59,52.15 77.35,52.91 77.35,77.96 74.18,81.13 69.19,81.13 R344.2
  L07_SIG3 w0.203: v1(77.22,50.75) 77.38,50.6 78.16,50.6 78.42,50.85 78.92,50.85 79.32,50.46 80,50.46 80.83,51.29 81.11,51.29 81.67,51.84 82.07,51.84 82.46,52.23 82.84,52.23 83.29,51.77 83.62,51.77 84.07,51.33 84.41,51.33 84.81,50.92 85.3,50.92 85.91,51.53 85.91,51.83 86.4,52.32 86.4,52.83 86.17,53.07 86.17,53.36 86.46,53.66 86.83,53.66 87.15,53.99 87.15,54.3 v1(87.43,54.57)
FPGA_TEMP4P: length 53.1
  TOP w0.254: v1(76.72,50.12) 76.72,50.42 76.21,50.92 76.21,52.31 76.97,53.07 76.97,77.8 74.02,80.75 69.31,80.75 R342.2
  L07_SIG3 w0.203: v1(87.43,53.65) 87.08,53.3 87.08,53.04 86.73,52.69 86.73,52.18 86.24,51.69 86.24,50.65 86.02,50.43 85.7,50.43 85.44,50.17 85.44,49.31 85.23,49.1 84.82,49.1 84.43,49.49 84.05,49.49 83.51,50.03 83.2,50.03 82.84,50.4 82.48,50.4 82.1,50.02 81.69,50.02 81.24,50.47 80.48,50.47 80.14,50.13 79.22,50.13 79,49.91 78.47,49.91 78.11,50.27 76.87,50.27 v1(76.72,50.12)
FPGA_TEMPDIODE0CN: length 28.5
  L14_SIG5 w0.203: v1(89.02,52.73) 89.02,52.46 89.47,52.02 89.47,51.63 89.85,51.24 89.85,51.04 89.97,50.92 90.61,50.28 90.61,49.58 91.78,48.42 93.92,48.42 94.7,47.64 94.7,47.08 95.51,46.27 95.51,44.61 96.35,43.78 96.35,41.56 95.49,40.69 92.67,40.69 90.87,38.9 90.87,36.92 90.16,36.21 87.13,36.21 v1(86.79,35.87)
FPGA_TEMPDIODE0CP: length 27.3
  L14_SIG5 w0.203: v1(86.79,36.88) 87.13,36.54 90.03,36.54 90.54,37.06 90.54,39.04 92.53,41.02 95.35,41.02 96.02,41.69 96.02,43.64 95.18,44.48 95.18,46.13 94.37,46.94 94.37,47.5 93.78,48.08 91.64,48.08 90.28,49.45 90.28,49.71 90.08,49.91 89.64,49.91 89.39,50.17 89.39,50.62 89.49,50.73 89.49,51.13 89.14,51.49 89.14,51.69 v1(89.02,51.81)
FPGA_VCC: length 43.7
  L03_SIG1 w0.254: 110.11,69.29 v1(109.74,69.29) v1(108.14,69.29) 107.46,69.29
  BOTTOM w0.229: R532.2 129.25,72.49 127.81,72.49 123.67,76.63 122.79,76.63 121.87,77.55 121.53,77.55 121.04,78.05 120.7,78.05 120.28,78.47 119.91,78.47 119.49,78.05 119.11,78.05 118.67,78.49 116.75,78.49 116.29,78.03 115.95,78.03 115.47,77.55 115.13,77.55 114.79,77.55 113.98,76.73 113.98,76.41 112.78,75.21 112.78,74.27 112.25,73.74 111.66,73.74 110.24,72.32 110.24,71.92 110.09,71.77 110.09,71.4 110.24,71.25 110.24,71.01 109.92,70.69 109.58,70.69 109.12,70.23 108.79,70.23 108.34,69.78 107.99,69.78 107.51,69.29 107.18,69.29 106.74,69.74 106.36,69.74 105.92,69.29 105.58,69.29 105.12,69.75 104.77,69.75 104.32,69.29 103.98,69.29 103.53,69.74 103.23,69.74 103.02,69.62 102.89,69.39 102.73,69.29 102.4,69.29 101.94,68.83 101.6,68.83 101.13,68.37 100.8,68.37 100.33,67.89 99.99,67.89 99.73,67.63 99.73,67.26 C511.1
  vias: v1(91.41,68.83) v1(91.41,67.91) v1(91.41,66.07) v1(91.41,65.15) v1(91.41,64.23) v1(91.41,55.03) v1(91.41,54.11) v1(92.21,68.37) v1(92.21,67.45) v1(92.21,65.61) v1(92.21,64.69) v1(92.21,62.85) v1(92.21,61.93) v1(92.21,60.09) v1(92.21,59.17) v1(92.21,57.33) v1(92.21,56.41) v1(92.21,54.57) v1(92.21,53.65) v1(93,67.91) v1(93,66.99) v1(93,65.15) v1(93,64.23) v1(93,62.39) v1(93,61.47) v1(93,59.63) v1(93,58.71) v1(93,56.87) v1(93,55.95) v1(93,54.11) v1(93.8,69.29) v1(93.8,67.45) v1(93.8,66.53) v1(93.8,64.69) v1(93.8,63.77) v1(93.8,61.93) v1(93.8,61.01) v1(93.8,59.17) v1(93.8,58.25) v1(93.8,56.41) v1(93.8,55.49) v1(93.8,54.57) v1(93.8,53.65) v1(94.6,69.75) v1(94.6,68.83) v1(94.6,66.99) v1(94.6,66.07) v1(94.6,64.23) v1(94.6,63.31) v1(94.6,61.47) v1(94.6,60.55) v1(94.6,58.71) v1(94.6,57.79) v1(94.6,55.95) v1(94.6,55.03) v1(95.39,69.29) v1(95.39,68.37) v1(95.39,66.53) v1(95.39,65.61) v1(95.39,63.77) v1(95.39,62.85) v1(95.39,61.01) v1(95.39,60.09) v1(95.39,58.25) v1(95.39,57.33) v1(95.39,55.49) v1(95.39,54.57) v1(95.39,53.65) v1(96.19,68.83) v1(96.19,67.91) v1(96.19,66.07) v1(96.19,65.15) v1(96.19,64.23) v1(96.19,63.31) v1(96.19,62.39) v1(96.19,61.47) v1(96.19,60.55) v1(96.19,59.63) v1(96.19,58.71) v1(96.19,57.79) v1(96.19,56.87) v1(96.19,55.03) v1(96.99,70.21) v1(96.99,69.29) v1(96.99,68.37) v1(96.99,67.45) v1(96.99,66.53) v1(96.99,57.33) v1(96.99,56.41) v1(96.99,54.57) v1(96.99,53.65) v1(97.79,67.91) v1(97.79,66.99) v1(97.79,56.87) v1(97.79,55.95) v1(98.58,70.21) v1(98.58,69.29) v1(98.58,67.45) v1(98.58,66.53) v1(98.58,57.33) v1(98.58,56.41) v1(98.58,55.49) v1(98.58,54.57) v1(98.58,53.65) v1(99.38,68.83) v1(99.38,66.99) v1(99.38,55.95) v1(99.38,55.03) v1(100.18,70.21) v1(100.18,69.29) v1(100.18,68.37) v1(100.18,66.53) v1(100.18,57.33) v1(100.18,55.49) v1(100.97,68.83) v1(100.97,67.91) v1(100.97,56.87) v1(100.97,55.03) v1(101.77,70.21) v1(101.77,69.29) v1(101.77,68.37) v1(101.77,67.45) v1(101.77,66.53) v1(101.77,57.33) v1(101.77,56.41) v1(101.77,54.57) v1(101.77,53.65) v1(102.57,67.91) v1(102.57,66.99) v1(102.57,56.87) v1(102.57,55.95) v1(103.36,70.21) v1(103.36,69.29) v1(103.36,67.45) v1(103.36,66.53) v1(103.36,57.33) v1(103.36,56.41) v1(103.36,55.49) v1(103.36,54.57) v1(103.36,53.65) v1(104.16,68.83) v1(104.16,66.99) v1(104.16,55.95) v1(104.16,55.03) v1(104.96,70.21) v1(104.96,69.29) v1(104.96,68.37) v1(104.96,66.53) v1(104.96,57.33) v1(104.96,55.49) v1(104.96,54.57) v1(104.96,53.65) v1(105.75,68.83) v1(105.75,67.91) v1(105.75,66.07) v1(105.75,65.15) v1(105.75,64.23) v1(105.75,63.31) v1(105.75,62.39) v1(105.75,61.47) v1(105.75,60.55) v1(105.75,59.63) v1(105.75,58.71) v1(105.75,57.79) v1(105.75,56.87) v1(105.75,55.03) v1(106.55,70.21) v1(106.55,69.29) v1(106.55,68.37) v1(106.55,67.45) v1(106.55,65.61) v1(106.55,64.69) v1(106.55,62.85) v1(106.55,61.93) v1(106.55,60.09) v1(106.55,59.17) v1(106.55,57.33) v1(106.55,56.41) v1(106.55,54.57) v1(106.55,53.65) v1(107.35,67.91) v1(107.35,66.99) v1(107.35,65.15) v1(107.35,64.23) v1(107.35,62.39) v1(107.35,61.47) v1(107.35,59.63) v1(107.35,58.71) v1(107.35,56.87) v1(107.35,55.95) v1(108.14,70.21) v1(108.14,67.45) v1(108.14,66.53) v1(108.14,64.69) v1(108.14,63.77) v1(108.14,59.17) v1(108.14,58.25) v1(108.14,56.41) v1(108.14,55.49) v1(108.14,54.57) v1(108.14,53.65) v1(108.14,52.73) v1(108.14,51.81) v1(108.94,68.83) v1(108.94,66.99) v1(108.94,66.07) v1(108.94,64.23) v1(108.94,63.31) v1(108.94,61.47) v1(108.94,60.55) v1(108.94,58.71) v1(108.94,57.79) v1(108.94,55.95) v1(108.94,55.03) v1(108.94,53.19) v1(108.94,52.27) v1(109.74,68.37) v1(109.74,66.53) v1(109.74,65.61) v1(109.74,63.77) v1(109.74,62.85) v1(109.74,61.01) v1(109.74,60.09) v1(109.74,58.25) v1(109.74,57.33) v1(109.74,55.49) v1(109.74,54.57) v1(117.1,37.16) v2(90.81,87.84) v2(90.81,86.82) v2(97.92,86.82) v2(108.97,87.84) v2(108.97,86.82) v2(110.24,37.16) v2(111.13,37.16) v2(113.67,37.16) v2(114.69,37.16) v2(115.96,37.16) v2(119.64,86.82) v2(121.42,87.84) v2(121.42,86.82) v2(125.36,87.84) v2(125.36,86.82) v3(104.66,38.18) v3(105.54,38.18) v3(106.31,38.18) v3(122.82,37.16) v3(123.45,37.8) v3(136.66,74.75) v3(136.66,65.1) v3(144.53,86.06) v3(144.53,84.91) v3(144.53,83.52) v3(144.53,82.12) v3(144.53,80.72) v3(144.53,79.33) v3(144.91,92.28) v3(144.91,90.63) v3(144.91,89.36) v3(144.91,77.8) v3(144.91,76.28) v3(144.91,74.88) v3(144.91,73.1) v3(144.91,71.45) v3(144.91,69.8) v3(144.91,68.15) v3(144.91,66.5) v3(144.91,64.98) v3(144.91,63.2) v3(144.91,61.93) v3(144.91,60.4) v3(144.91,58.63) v3(144.91,56.97) v3(144.91,55.32) v3(144.91,53.67) v3(144.91,52.02) v3(144.91,50.37) v3(144.91,48.85) v3(144.91,47.45) v3(144.91,45.93) v3(144.91,44.15) v3(144.91,42.62) v3(144.91,41.1) v3(144.91,39.58) v3(144.91,38.18) v3(144.91,36.78) v3(144.91,35.51) v3(145.3,87.71) v3(146.57,92.28) v3(146.57,90.63) v3(146.57,89.36) v3(146.57,87.71) v3(146.57,79.33) v3(146.57,77.8) v3(146.57,76.28) v3(146.57,74.88) v3(146.57,73.1) v3(146.57,71.45) v3(146.57,69.8) v3(146.57,68.15) v3(146.57,66.5) v3(146.57,64.98) v3(146.57,63.2) v3(146.57,61.93) v3(146.57,60.4) v3(146.57,58.63) v3(146.57,56.97) v3(146.57,55.32) v3(146.57,53.67) v3(146.57,52.02) v3(146.57,50.37) v3(146.57,48.85) v3(146.57,47.45) v3(146.57,45.93) v3(146.57,44.15) v3(146.57,42.62) v3(146.57,41.1) v3(146.57,39.58) v3(146.57,38.18) v3(146.57,36.78) v3(146.57,35.51) v3(146.82,86.06) v3(146.82,84.91) v3(146.82,83.52) v3(146.82,82.12) v3(146.82,80.72) v5(133.61,82.25) v5(133.61,80.69) v5(133.61,79.33) v5(133.61,77.8) v5(133.87,70.69) v5(133.87,69.29) v5(135.01,82.25) v5(135.01,80.69) v5(135.01,79.33) v5(135.01,77.8) v5(135.01,76.28) v5(135.01,73.1) v5(135.01,71.45) v5(135.01,69.8) v5(135.01,68.15) v5(136.41,82.25) v5(136.41,80.69) v5(136.41,79.33) v5(136.41,77.8) v5(136.41,76.28) v5(136.41,73.1) v5(136.41,71.45) v5(136.41,69.8) v5(136.41,68.15) v5(136.41,66.5) v5(137.8,82.25) v5(137.8,80.69) v5(137.8,79.33) v5(137.8,77.8) v5(137.8,76.28) v5(137.8,73.1) v5(137.8,71.45) v5(137.8,69.8) v5(137.8,68.15) v5(137.8,66.5) v5(137.8,64.98) v5(137.8,63.2) v5(137.8,61.93) v5(137.8,60.4) v5(137.8,58.63) v5(137.8,56.97) v5(137.8,55.32) v5(137.8,53.67) v5(137.8,52.02) v5(137.8,50.37) v5(137.8,48.85) v5(137.8,47.45) v5(137.8,45.93) v5(137.8,44.15) v5(137.8,42.62) v5(137.8,41.1) v5(137.8,39.58) v5(137.8,38.18) v5(139.2,80.69) v5(139.2,79.33) v5(139.2,77.8) v5(139.2,76.28) v5(139.2,74.88) v5(139.2,73.1) v5(139.2,71.45) v5(139.2,69.8) v5(139.2,68.15) v5(139.2,66.5) v5(139.2,64.98) v5(139.2,63.2) v5(139.2,61.93) v5(139.2,60.4) v5(139.2,58.63) v5(139.2,56.97) v5(139.2,55.32) v5(139.2,53.67) v5(139.2,52.02) v5(139.2,50.37) v5(139.2,48.85) v5(139.2,47.45) v5(139.2,45.93) v5(139.2,44.15) v5(139.2,42.62) v5(139.2,41.1) v5(139.2,39.58) v5(139.2,38.18) v5(139.45,82.25) v5(140.6,82.25) v5(140.6,80.69) v5(140.6,79.33) v5(140.6,77.8) v5(140.6,76.28) v5(140.6,74.88) v5(140.6,73.1) v5(140.6,71.45) v5(140.6,69.8) v5(140.6,68.15) v5(140.6,66.5) v5(140.6,64.98) v5(140.6,63.2) v5(140.6,61.93) v5(140.6,60.4) v5(140.6,58.63) v5(140.6,56.97) v5(140.6,55.32) v5(140.6,53.67) v5(140.6,52.02) v5(140.6,50.37) v5(140.6,48.85) v5(140.6,47.45) v5(140.6,45.93) v5(140.6,44.15) v5(140.6,42.62) v5(140.6,41.1) v5(140.6,39.58) v5(140.6,38.18) v5(141.74,90.63) v5(141.87,82.25) v5(141.99,80.69) v5(141.99,79.33) v5(141.99,77.8) v5(141.99,76.28) v5(141.99,74.88) v5(141.99,73.1) v5(141.99,71.45) v5(141.99,69.8) v5(141.99,68.15) v5(141.99,66.5) v5(141.99,64.98) v5(141.99,63.2) v5(141.99,61.93) v5(141.99,60.4) v5(141.99,58.63) v5(141.99,56.97) v5(141.99,55.32) v5(141.99,53.67) v5(141.99,52.02) v5(141.99,50.37) v5(141.99,48.85) v5(141.99,47.45) v5(141.99,45.93) v5(141.99,44.15) v5(141.99,42.62) v5(141.99,41.1) v5(141.99,39.58) v5(141.99,38.18) v5(142.12,92.28) v5(143.26,83.64) v5(143.26,82.12) v5(143.26,80.69) v5(143.39,92.28) v5(143.39,90.63) v5(143.39,89.23) v5(143.39,87.96) v5(143.39,79.33) v5(143.39,77.8) v5(143.39,76.28) v5(143.39,74.88) v5(143.39,73.1) v5(143.39,71.45) v5(143.39,69.8) v5(143.39,68.15) v5(143.39,66.5) v5(143.39,64.98) v5(143.39,63.2) v5(143.39,61.93) v5(143.39,60.4) v5(143.39,58.63) v5(143.39,56.97) v5(143.39,55.32) v5(143.39,53.67) v5(143.39,52.02) v5(143.39,50.37) v5(143.39,48.85) v5(143.39,47.45) v5(143.39,45.93) v5(143.39,44.15) v5(143.39,42.62) v5(143.39,41.1) v5(143.39,39.58) v5(143.39,38.18) v5(143.39,36.78) v5(143.39,35.51)
FPGA_VCC_GND: length 29.6
  L02_GND1 w0.254: v1(183.01,58.69) 182.44,58.69 ; v1(187.27,53.93) 186.7,53.93 ; v1(172.22,57.48) 172.73,57.48 ; v1(187.27,55.7) 186.7,55.7 ; v1(180.09,45.99) 180.09,46.56 ; v1(187.27,57.48) 186.7,57.48 ; v1(179.2,45.99) 179.2,46.56 ; v1(184.54,45.99) 184.54,46.56 ; v1(187.27,58.37) 186.7,58.37 ; v1(174.76,60.98) 174.76,60.4 ; v1(182.76,45.99) 182.76,46.56 ; v1(173.87,60.98) 173.87,60.4 ; v1(187.27,54.82) 186.7,54.82 ; v1(180.09,60.02) 179.71,60.02 ; v1(187.27,56.59) 186.7,56.59 ; v1(184.79,58.69) 185.36,58.69
  BOTTOM w0.254: v1(163.2,45.04) 164.09,45.04 164.35,44.78 ST8.2 R572.1 ; R580.1 ST9.2 164.35,59.26 164.09,59.51 v1(163.2,59.51) ; v1(163.2,88.47) 164.09,88.47 164.35,88.22 ST11.2 R596.1 ; v1(163.2,73.99) 164.09,73.99 164.35,73.74 ST10.2 R588.1
  vias: v1(176.92,54.56) v1(176.92,53.16) v1(176.92,51.77) v2(178.32,54.56) v2(178.32,53.16) v2(178.32,51.77) v2(179.71,54.56) v2(179.71,53.16) v2(179.71,51.77) v2(181.11,54.56) v2(181.11,53.16) v2(181.11,51.77) v2(182.51,54.56) v2(182.51,53.16) v2(182.51,51.77)
