# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HPS_TMS: length 310.8
  TOP w0.149: J6.57 v1(203.32,26.13)
  L05_SIG2 w0.081: v1(26.18,78.65) 25.77,79.06 25.77,79.76 25.42,80.11 24.98,80.11 24.68,80.42 24.68,80.8 24.44,81.03 21.87,81.03 21.7,81.21 21.01,81.21 20.68,81.54 20.68,81.77 20.38,82.07 18.55,82.07 16.62,80.14 11.68,80.14 11.12,79.58 10.52,79.58 8.64,77.69 8.25,77.69 7.17,76.61 7.17,70.61 6.08,69.52 6.08,65.08 4.88,63.88 4.88,61.04 5.9,60.02 5.9,58.15 6.94,57.11 6.94,54.03 6.71,53.8 6.71,50.85 5.93,50.07 5.93,46.51 6.89,45.54 6.89,42.96 9.41,40.45 9.41,31.7 9.73,31.38 9.73,27.93 10.37,27.28 11.31,27.28 12.05,26.55 12.05,24.62 14.45,22.22 26.79,22.22 26.91,22.11 26.91,21.59 27.02,21.47 27.18,21.47 27.29,21.59 27.29,22.11 27.41,22.22 28.34,22.22 29.05,21.51 33.11,21.51 33.54,21.08 34.85,21.08 34.96,20.97 34.96,20.73 35.07,20.62 35.23,20.62 35.35,20.73 35.35,21.46 35.46,21.58 35.62,21.58 35.73,21.47 35.73,20.73 35.84,20.62 36,20.62 36.12,20.73 36.12,20.97 36.23,21.08 38.16,21.08 43.66,15.58 46.36,15.58 46.92,16.14 53.46,16.14 55.25,14.35 56.28,14.35 58.78,11.85 62.53,11.85 63.08,11.3 63.08,10.58 64.38,9.28 76.09,9.28 76.58,8.79 78.33,8.79 78.82,9.28 126.63,9.28 127.75,10.41 127.75,11.17 128.04,11.46 133.45,11.46 136.2,14.21 137.58,14.21 138.63,15.26 174.69,15.26 174.98,15.55 192.89,15.55 195.33,17.99 195.59,17.99 195.79,17.78 195.79,17.55 194.38,16.14 194.38,15.89 194.58,15.69 194.81,15.69 199.61,20.49 199.61,20.69 199.38,20.92 199.16,20.92 196.48,18.24 196.22,18.24 196.02,18.44 196.02,18.67 198.77,21.43 198.77,21.66 198.57,21.86 198.32,21.86 197.62,21.16 197.37,21.16 197.19,21.34 197.19,21.62 201.7,26.13 v1(203.32,26.13)
INLET_TEMP_N: length 114.3
  L03_SIG1 w0.203: v1(21.7,60.67) 22.04,61 22.78,61 24.85,58.93 26.13,58.93 28.48,56.58 28.48,50.51 32.44,46.55 32.44,40.9 32.09,40.54 32.09,35.42 30.87,34.2 30.87,29.2 33.27,26.8 35.7,26.8 40.33,22.18 41.43,22.18 43.01,20.6 43.01,20.16 44.14,19.03 45.54,19.03 47.44,17.12 59.56,17.12 61.22,16.44 65.82,16.44 66.84,17.46 71.49,17.46 72.57,16.39 75.02,16.39 75.44,16.56 75.93,17.05 75.93,22.76 76.14,22.97 77.41,22.97 77.68,23.24 77.68,27.17 79.52,29.01 81.51,29.01 84.21,31.71 84.21,32.76 84.67,33.23 85.35,33.23 86.29,34.17 86.46,34.17 v1(86.79,33.84)
INLET_TEMP_P: length 114.1
  L03_SIG1 w0.203: v1(21.7,61.67) 22.04,61.33 22.91,61.33 24.98,59.26 26.27,59.26 28.81,56.72 28.81,50.65 32.77,46.69 32.77,40.76 32.42,40.4 32.42,35.28 31.2,34.06 31.2,29.34 33.41,27.13 35.84,27.13 40.46,22.51 41.57,22.51 43.34,20.74 43.34,20.3 44.28,19.36 45.68,19.36 47.58,17.45 59.63,17.45 61.28,16.77 65.68,16.77 66.7,17.79 71.63,17.79 72.7,16.72 74.96,16.72 75.25,16.84 75.6,17.18 75.6,23.19 76.32,23.91 77.11,23.91 77.35,24.16 77.35,27.31 79.38,29.34 81.37,29.34 83.88,31.85 83.88,32.9 84.54,33.56 85.21,33.56 86.15,34.5 86.43,34.5 v1(86.79,34.85)
IOEXP_INTN: length 69.9
  L14_SIG5 w0.081: v1(89.02,43.53) 88.65,43.16 88.65,42.95 88.27,42.57 88.07,42.57 87.61,42.12 87.26,42.12 85.91,40.77 79.92,40.77 78.82,41.86 72.47,41.86 71.18,43.16 59.54,43.16 55.61,39.22 54.7,39.22 48.78,33.3 48.78,32.72 42.6,26.55 32.7,26.55 v1(32.14,25.99)
  BOTTOM w0.149: v1(32.14,25.99) 31.95,25.8 R6895.1 31.37,24.78 30.93,24.78 30.69,24.53 U97.13
IREF: length 161.3
  TOP w0.203: 180.51,58.28 U61.33
  TOP w0.381: v1(180.9,59.04) 180.9,58.67 180.51,58.28 180.14,58.65 v1(180.14,59.03)
  TOP w0.457: v1(171.2,48.34) v1(171.2,49.86) v1(171.2,51.39) v1(171.2,52.91) v1(171.2,54.43) v1(171.2,55.96) v1(171.2,57.48) 171.2,58.44 R543.2
  L05_SIG2 w0.203: v1(163.2,29.16) 164.85,29.16 167.77,32.08 167.77,45.67 169.93,47.83 169.93,54.69 v1(171.2,55.96)
  L05_SIG2 w0.508: v1(180.9,59.04) 180.15,59.04 v1(180.14,59.03) 179.78,59.39 172.22,59.39 171.2,58.37 v1(171.2,57.48)
  L14_SIG5 w0.203: v1(171.2,52.91) 169.55,54.56 169.55,72.47 168.03,73.99 168.03,86.69 167.52,87.2 v1(163.2,87.2) ; v1(163.2,58.24) 165.11,58.24 166.25,57.1 166.25,53.04 169.43,49.86 v1(171.2,49.86) ; v1(171.2,48.34) 170.31,48.34 166.83,44.86 164.29,44.86 v1(163.2,43.77) ; v1(163.2,72.72) 165.87,72.72 167.9,70.69 167.9,53.8 170.31,51.39 v1(171.2,51.39)
  BOTTOM w0.254: v1(163.2,87.2) 163.14,87.14 R597.2 ; v1(163.2,58.24) 163.14,58.18 R581.2 ; R589.2 163.14,72.66 v1(163.2,72.72) ; R573.2 163.14,43.7 v1(163.2,43.77) ; v1(171.2,54.43) 171.97,53.67 R545.1 ; v1(163.2,29.16) 163.14,29.1 R605.2 ; R546.1 171.97,55.2 v1(171.2,55.96)
ISENSE0: length 24.9
  TOP w0.203: U61.4 177.71,49.89 176.92,49.1 176.41,49.1 176.28,48.97
  TOP w0.254: C711.1 v1(172.22,48.34) 175.65,48.34 176.28,48.97 ; U62.33 159.74,42.85 v1(159.9,43)
  L14_SIG5 w0.203: v1(159.9,43) 163.2,43 164.55,44.35 167.09,44.35 170.57,47.83 171.71,47.83 v1(172.22,48.34)
  BOTTOM w0.254: v1(159.9,43) 160.09,42.81 R573.1 161.36,42.37 R572.2
ISENSE1: length 44.2
  TOP w0.254: U61.43 175.73,55.66 175.52,55.45 172.73,55.45 v1(172.22,55.96) ; U66.33 159.74,28.24 v1(159.9,28.4)
  L05_SIG2 w0.203: v1(159.9,28.4) 161.3,29.8 164.73,29.8 167.27,32.34 167.27,46 169.43,48.16 169.43,55.07 170.82,56.47 171.71,56.47 v1(172.22,55.96)
  BOTTOM w0.254: R604.2 161.36,27.76 R605.1 160.09,28.21 v1(159.9,28.4)
ISENSE2: length 28.3
  TOP w0.203: 177.31,50.1 U61.3
  TOP w0.254: C729.1 172.54,49.48 176.69,49.48 177.31,50.1 ; U63.33 159.74,57.32 v1(159.9,57.48)
  L14_SIG5 w0.203: v1(172.22,49.86) 171.71,50.37 169.63,50.37 166.76,53.24 166.76,57.23 165.31,58.68 162.74,58.68 161.55,57.48 v1(159.9,57.48)
  BOTTOM w0.254: v1(159.9,57.48) 160.09,57.29 R581.1 161.36,56.85 R580.2
ISENSE3: length 38.9
  TOP w0.203: U61.52 175.57,51.56 175.27,51.26
  TOP w0.254: 175.27,51.26 172.35,51.26 v1(172.22,51.39) ; v1(159.9,71.96) 159.74,71.8 U64.33
  L14_SIG5 w0.203: v1(172.22,51.39) 172.09,51.39 171.58,51.89 170.44,51.89 168.41,53.93 168.41,70.82 166,73.23 162.95,73.23 161.68,71.96 v1(159.9,71.96)
  BOTTOM w0.254: R588.2 161.36,71.33 R589.1 160.09,71.77 v1(159.9,71.96)
ISENSE4: length 52.8
  TOP w0.203: 175.08,51.77 175.27,51.96 U61.51
  TOP w0.254: U65.33 159.74,86.28 v1(159.9,86.44) ; 175.08,51.77 173.3,51.77 C765.1
  L14_SIG5 w0.203: v1(159.9,86.44) 161.68,86.44 162.95,87.71 167.77,87.71 168.54,86.95 168.54,74.12 170.06,72.6 170.06,54.69 171.08,53.67 171.46,53.67 v1(172.22,52.91)
  BOTTOM w0.254: v1(159.9,86.44) 160.09,86.25 R597.1 161.36,85.8 R596.2
LT_1V8_SCK: length 166.7
  L12_SIG4 w0.089: v1(44.33,107.9) 44.84,107.39 46.67,107.39 46.87,107.19 48.78,107.19 49.16,107.57 49.16,108.61 49.82,109.27 137.82,109.27 140.79,106.29 159.09,106.29 v1(161.72,103.66)
  L14_SIG5 w0.081: v1(20.2,85.48) 20.2,85.55 22.57,87.92 24.17,87.92 26.09,89.84 27.44,89.84 28.19,90.58 31.71,90.58 31.86,90.74 35.33,90.74 36.35,91.77 39.72,91.77 42.5,94.54 44.81,94.54 45.02,94.74 45.85,94.74 47.03,95.92 47.03,99.5 47.68,100.15 47.68,100.87 47.48,101.07 47.48,101.93 47.06,102.35 47.06,105.88 45.52,107.42 44.81,107.42 v1(44.33,107.9)
LT_1V8_SCSN: length 172.1
  L12_SIG4 w0.089: v1(164.35,105.49) 164.35,107.14 161.75,109.74 140.51,109.74 140.11,110.14 48.22,110.14 v1(45.98,107.9)
  L14_SIG5 w0.081: v1(45.98,107.9) 46.74,107.14 47.71,107.14 49.21,105.64 49.21,100.38 49.4,100.19 49.4,97.78 48.6,96.98 47.76,96.98 47.37,96.59 47.37,95.83 46.05,94.51 45.21,94.51 44.92,94.23 43.57,94.23 42.31,92.97 41.46,92.97 39.71,91.21 37.53,91.21 37.12,90.81 36.13,90.81 34.98,89.66 31.68,89.66 31.01,90.33 28.31,90.33 27.5,89.52 26.34,89.52 24.14,87.33 23.25,87.33 21.72,85.8 21.72,84.2 v1(21.18,83.65)
  BOTTOM w0.149: v1(164.35,105.49) 164.32,105.47 U33.5
LT_1V8_SDI: length 172.1
  L12_SIG4 w0.089: v1(47.63,107.9) 49.26,109.53 138.64,109.53 139.7,108.47 160.66,108.47 161.02,108.1 161.02,105.59 v1(163.02,103.58)
  L14_SIG5 w0.081: v1(24.18,82.65) 23.77,83.06 22.92,83.06 22.69,83.29 22.69,85.8 23.49,86.61 24.02,86.61 26.63,89.21 27.56,89.21 28.39,90.04 30.36,90.04 31.2,89.21 35.07,89.21 36.42,90.55 37.32,90.55 37.63,90.86 40.11,90.86 41.33,92.08 43.01,92.08 43.62,92.69 43.62,93.63 43.86,93.87 44.94,93.87 45.35,94.27 46.14,94.27 46.57,94.7 48.25,94.7 50.55,97.01 50.55,101.98 50.81,102.24 50.81,106.89 49.16,108.54 48.27,108.54 v1(47.63,107.9)
LT_1V8_SPI_ERRN: length 176.1
  L12_SIG4 w0.089: v1(163.67,104.22) 161.89,106.01 161.89,108.48 161.25,109.12 140.11,109.12 139.39,109.84 48.68,109.84 v1(46.74,107.9)
  L14_SIG5 w0.081: v1(23.18,83.65) 23.58,84.05 24.42,84.05 24.7,84.33 24.7,86.5 26.37,88.17 26.87,88.17 28.51,89.8 29.31,89.8 30.33,88.78 35.01,88.78 36.49,90.25 37.72,90.25 37.99,90.52 40.31,90.52 41.03,91.24 42.91,91.24 43.75,92.08 44.23,92.08 44.56,92.41 44.56,93.05 45.55,94.04 46.24,94.04 46.59,94.39 50.15,94.39 51.34,95.58 51.34,108.46 50.88,108.92 47.76,108.92 v1(46.74,107.9)
  BOTTOM w0.149: R768.1 v1(23.18,83.65)
LT_3V3_SCK: length 76.2
  L14_SIG5 w0.081: v1(161.72,97.74) 162.53,98.55 164.67,98.55 166.08,97.14 166.08,93.77 166.43,93.43 168.56,93.43 170.15,91.84 173.91,91.84 175.52,90.22 175.52,66.68 179.05,63.15 184.08,63.15 188.86,58.37 188.86,48.18 187.09,46.41 184.07,46.41 v1(183.65,45.99)
LT_3V3_SCSN: length 45.7
  L14_SIG5 w0.081: v1(164.32,97.79) 163.76,97.79 163.26,97.3 163.26,96.84 163.77,96.33 163.77,95 163.56,94.78 163.56,93.71 164.78,92.49 166.59,92.49 168.96,90.12 171.33,90.12 171.71,89.74 171.71,65.8 v1(176.54,60.98)
LT_3V3_SDI: length 72.9
  L14_SIG5 w0.081: v1(181.87,45.99) 186.12,50.23 187.12,50.23 187.94,51.06 187.94,58.45 183.98,62.41 178.77,62.41 174.25,66.93 174.25,90.07 172.93,91.39 169.91,91.39 168.22,93.08 165.88,93.08 165.23,93.73 165.23,97.5 164.51,98.22 163.45,98.22 v1(163.02,97.79)
LT_3V3_SPI_ERRN: length 44.9
  L14_SIG5 w0.081: v1(163.67,97.16) 164.41,96.42 164.41,93.77 165.4,92.77 167.66,92.77 169.68,90.76 172,90.76 172.98,89.78 172.98,66.31 v1(178.32,60.98)
LT_SCL: length 8.7
  L16_SIG6 w0.081: v1(200.03,95.96) 200.03,98.88 199.27,99.65 199.27,102.15 J107.3
LT_SDA: length 4.2
  L16_SIG6 w0.081: v1(198.89,95.96) 198.89,98.54 J107.1
LT_SVID_SCL: length 8.9
  TOP w0.149: J13.3 236.93,31.58 R530.2
LT_SVID_SDA: length 4
  TOP w0.149: J13.1 239.08,33.42 R529.2
LTC_FAULT_N: length 256
  TOP w0.203: 184.22,51.33 183.98,51.56 U61.18 ; 184.34,51.96 U61.19
  TOP w0.254: 184.56,50.98 186.1,50.98 v1(186.38,51.26)
  TOP w0.267: 184.34,51.96 184.74,51.56 186.07,51.56 v1(186.38,51.26) ; 184.56,50.98 184.22,51.33
  L05_SIG2 w0.081: v1(167.69,18.37) 167.69,21.07 173.06,26.44 173.06,28.15 173.82,28.91 177.81,28.91 180.35,31.45 180.35,31.7 181.95,33.3 181.95,40.08 181.62,40.41 181.62,45.04 182.3,45.72 182.3,46.48 182.51,46.69 184.54,46.69 184.79,46.43 185.94,46.43 186.82,47.32 186.82,50.82 v1(186.38,51.26)
  L12_SIG4 w0.089: v1(167.69,18.37) 165.7,16.39 155.43,16.39 154.29,17.53 154.29,19.74 152.99,21.03 151.92,21.03 150.25,22.71 147.38,22.71 145.47,24.62 145.47,24.92 145.24,25.15 144.25,25.15 143,26.4 134.22,26.4 131.98,24.17 131.98,21.54 131.68,21.24 131.68,20.3 131.52,20.13 131.52,19.62 131.07,19.18 131.07,17.59 129.79,16.31 117.96,16.31 117.41,15.75 87.15,15.75 86.88,16.03 78.04,16.03 77.67,16.4 74.52,16.4 70.94,19.97 70.94,23.71 65.44,29.21 65.44,34.98 59.77,40.64 58.83,40.64 58.66,40.82 57.92,40.82 57.58,41.16 55.77,41.16 55.53,40.92 47.56,40.92 46.13,42.35 43.64,42.35 41.49,44.5 41.49,44.8 41.14,45.15 40.58,45.15 39.76,45.98 39.25,45.98 38.53,46.7 38.53,47.05 34.68,50.89 34.68,52.05 32.23,54.5 32.23,56.81 31.48,57.56 31.48,60.02 31.66,60.2 31.66,63.02 27.72,66.96 27.72,70.59 27.19,71.12 26.96,71.12 26.68,71.4 26.68,73.82 27.08,74.22 32.36,74.22 32.63,73.95 32.63,73.2 v1(33.18,72.65)
  BOTTOM w0.149: R72.2 34.04,73.1 33.59,72.65 v1(33.18,72.65)
LTC_INTVCC: length 5.2
  TOP w0.203: U61.31 181.31,57.17 181.68,57.53
  TOP w0.381: C690.2 182.19,58.95 182.19,58.05 181.68,57.53
LTC_SYNC: length 5.9
  TOP w0.203: 181.71,49.64 U61.14
  TOP w0.267: 181.71,49.64 183.08,48.28 184.09,48.28 185.43,46.94 R540.2
LTC_VDD25: length 3.5
  TOP w0.203: 182.88,56.48 182.51,56.12 U61.28
  TOP w0.325: 182.88,56.48 183.67,56.48
  TOP w0.381: C691.1 184.79,57.61 183.67,56.48
LTC_VDD33: length 2.8
  TOP w0.203: 181.87,56.9 181.71,56.74 U61.30
  TOP w0.381: v1(183.01,57.8) 182.77,57.8 181.87,56.9
  vias: v1(172.22,58.5) v1(175.65,60.98) v1(177.43,60.98) v1(179.2,60.98) v1(180.98,45.99) v1(183.9,58.69) v1(185.43,45.99) v1(187.27,52.15) v1(187.27,51.26) v1(187.27,49.48) v1(187.27,48.59) v1(187.27,47.7) v3(231.4,30.3) v3(231.4,29.03) v3(232.54,29.03) v3(232.67,30.3) v3(233.81,30.3) v3(233.81,29.03)
MAX10_50MHZ_CLK: length 16.4
  BOTTOM w0.149: v1(15.28,74.5) 15.96,75.19 29.71,75.19 30.18,75.65 v1(31.18,75.65)
MAX10_CONFIG_SEL: length 9.6
  BOTTOM w0.149: v1(29.18,76.65) 29.48,76.65 30.04,76.1 32.95,76.1 33.94,77.09 36.32,77.09 R78.1 R77.2
MAX10_FPGA_RESETN: length 95.3
  L12_SIG4 w0.089: v1(80.26,43.07) 77.29,43.07 76.69,43.67 68.84,43.67 68.49,44.02 67.19,44.02 66.83,43.67 66.02,43.67 65.67,44.02 60.43,44.02 60.08,43.67 56.14,43.67 55.46,42.98 49.94,42.98 47.76,45.16 46.24,45.16 45.8,45.6 45.45,45.6 45.14,45.29 44.51,45.29 43.64,46.15 43.49,46.15 43.14,46.51 43.14,47.07 41.51,48.69 40.67,48.69 39.78,49.58 39.78,52.73 37.29,55.22 36.3,55.22 35.44,56.09 35.44,59.9 34.93,60.4 34.93,68.4 34.18,69.16 v1(34.18,71.65)
  BOTTOM w0.149: v1(89.82,50.43) 89.82,50.11 89.42,49.71 89.42,49.25 89.57,49.1 89.57,45.27 89.42,45.11 89.42,44.73 89.54,44.61 89.54,43.44 89.19,43.08 88.81,43.08 88.32,42.6 88.02,42.6 87.59,42.17 87.23,42.17 86.85,42.55 86.42,42.55 86.01,42.14 85.61,42.14 85.1,42.65 84.84,42.65 84.42,43.07 v1(80.26,43.07) 74.05,43.07 R6898.1
MAX10_JTAG_EN: length 214.1
  L07_SIG3 w0.089: v1(207.78,101.55) 206.34,103 205.57,103 199.52,109.04 195.72,109.04 195.31,109.45 140.95,109.45 140.55,109.86 129.6,109.86 129.29,109.55 119.77,109.55 119.46,109.86 102.04,109.86 101.81,109.63 101.07,109.63 100.85,109.86 87,109.86 86.75,109.6 83.22,109.6 82.96,109.86 72.8,109.86 72.5,109.55 53.37,109.55 v1(52.23,108.41)
  L14_SIG5 w0.081: v1(27.18,84.61) 26.63,85.16 26.63,87.55 28.52,89.45 29.18,89.45 30.48,88.15 34.88,88.15 36.75,90.02 39,90.02 39.28,89.74 41.08,89.74 41.61,90.27 43.09,90.27 43.44,90.63 43.44,90.88 43.77,91.21 44.2,91.21 45.02,92.03 45.02,93.14 45.68,93.8 46.34,93.8 46.64,94.11 50.35,94.11 52.23,95.99 v1(52.23,108.41)
  BOTTOM w0.149: v1(27.18,84.61) 27.76,84.03 27.76,83.45 28.07,83.14 28.46,83.14 28.71,82.88 28.71,79.18 v1(28.18,78.65)
MAX10_NCONFIG: length 65.5
  L05_SIG2 w0.081: v1(30.55,104.09) 31.76,104.09 32.52,104.85 v1(32.52,105.68) 31.82,106.38 26.74,106.38 v1(26.17,106.95)
  L07_SIG3 w0.089: v1(17.41,60.4) 18.29,60.4 22.24,64.35 24.48,64.35 26.8,66.67 26.8,67.97 26.98,68.15 27.26,68.15 27.56,68.44 27.56,71.63 27.78,71.85 27.78,74.9 28.03,75.15 28.38,75.15 29.88,76.65 v1(30.18,76.65) 30.18,76.95 30.67,77.44 30.67,85.66 29.72,86.61 29.72,89.92 30.18,90.38 30.18,94.29 30.89,94.99 30.89,98.03 29.88,99.04 29.88,103.42 v1(30.55,104.09)
  BOTTOM w0.149: R504.2 v1(30.55,104.09) ; v1(17.41,60.4) 17.41,60.02 17.22,59.83 R506.2 ; v1(26.17,106.95) R507.2
MAX10_NSTATUS: length 9.6
  BOTTOM w0.149: R80.1 36.9,79.67 36.33,79.1 32.93,79.1 32.65,78.82 32.65,78.44 32.39,78.18 31.88,78.18 31.73,78.03 31.73,77.35 31.55,77.17 29.66,77.17 v1(29.18,77.65)
MAX_1V2: length 5.5
  BOTTOM w0.254: 18.77,68.15 19.69,68.15 20.07,67.77 C659.2 R499.2
  vias: v1(21.18,85.5) v1(21.18,84.65) v1(23.18,71.65) v1(24.18,71.65) v1(25.18,76.65) v1(25.18,74.65) v1(25.18,71.65) v1(26.18,77.65) v1(26.18,76.65) v1(26.18,75.65) v1(27.18,76.65) v1(27.18,75.65) v1(27.18,74.65) v1(28.18,77.65) v1(28.18,75.65) v1(29.18,78.65) v1(31.18,74.65) v1(31.18,73.65) v3(16.73,69.61) v3(16.73,68.21) v3(16.73,66.94) v3(18.15,69.61) v3(18.15,68.21) v3(18.15,66.94)
MAX_1V2_FPGA_SPARE0: length 80.1
  L12_SIG4 w0.089: v1(31.18,72.65) 31.68,72.15 31.68,70.42 31.94,70.15 32.3,70.15 32.68,69.77 32.68,69.44 32.93,69.19 33.33,69.19 33.61,68.91 33.61,68.27 v1(34.04,67.83) 34.55,67.33 34.55,61.62 34.37,61.45 34.37,57.79 34.93,57.23 34.93,55.96 35.5,55.39 35.5,53.99 38.49,51.01 38.49,49.99 40.19,48.29 41.18,48.29 42.86,46.61 42.86,45.75 43.85,44.75 47.46,44.75 49.64,42.57 58.83,42.57 59.65,43.39 71.12,43.39 71.71,42.8 76.84,42.8 77.4,42.24 79.84,42.24 80.09,42.5 80.4,42.5 80.86,42.95 84.34,42.95 85,43.61 85.25,43.61 85.83,44.2 v1(85.83,44.45)
  BOTTOM w0.149: R56.2 R40.1 v1(34.04,67.83)
MAX_1V2_FPGA_SPARE1: length 82.7
  L12_SIG4 w0.089: v1(32.18,71.65) 32.69,72.16 34.4,72.16 34.68,71.88 34.68,69.17 35.44,68.4 35.44,60.4 38.36,57.48 38.36,55.58 40.27,53.67 40.27,49.74 40.75,49.25 41.41,49.25 43.39,47.27 43.62,47.27 44.58,46.31 45.63,46.31 46.37,45.56 48,45.56 49.74,43.82 54.34,43.82 54.97,44.45 56.14,44.45 56.45,44.15 58.75,44.15 59.34,44.73 71.58,44.73 72.22,44.1 76.87,44.1 77.34,43.63 78.71,43.63 78.95,43.87 79.69,43.87 80.07,43.49 80.7,43.49 80.93,43.26 83.4,43.26 84.11,43.97 84.46,43.97 84.92,44.43 85.23,44.43 v1(86.63,45.83)
  BOTTOM w0.149: R41.1 R57.2 34.36,72.09 32.61,72.09 v1(32.18,71.65)
MAX_1V2_FPGA_SPARE2: length 85.3
  L03_SIG1 w0.081: v1(36.9,73.23) 36.9,73.8 36.08,74.63 35.57,74.63 35,74.06 35,73.8 34.38,73.19 30.64,73.19 v1(30.18,73.65)
  L12_SIG4 w0.089: v1(87.43,45.37) 87.01,45.78 87.01,46.07 86.79,46.29 86.48,46.29 85.48,45.29 84.72,45.29 84.34,44.91 83.95,44.91 83.57,44.53 83.19,44.53 82.92,44.8 82.32,44.8 82.05,44.53 81.57,44.53 81.31,44.79 80.78,44.79 80.56,44.57 80.03,44.57 79.69,44.91 77.65,44.91 77.4,45.16 75.04,45.16 74.54,45.66 71.29,45.66 71,45.95 67.8,45.95 67.55,46.21 57.77,46.21 57.08,46.89 51.57,46.89 50.76,47.7 48.27,47.7 47.82,48.15 46.07,48.15 45.75,48.47 45.75,48.64 44.25,50.14 43.29,50.14 42.97,50.46 42.97,55.03 41.71,56.29 41.71,57.86 40.52,59.06 38.87,59.06 37.95,59.97 37.95,60.2 36.34,61.81 36.34,65.12 35.85,65.61 35.85,69.45 36.18,69.78 36.18,72.51 v1(36.9,73.23)
  BOTTOM w0.149: v1(36.9,73.23) R42.1
MAX_1V2_FPGA_SPARE3: length 87.5
  L12_SIG4 w0.089: v1(32.18,72.65) 31.68,73.15 30.98,73.15 30.68,72.85 30.68,70.86 31.68,69.86 31.68,68.07 32.46,67.3 32.46,66.74 33.51,65.69 33.51,57.51 34.5,56.52 34.5,54.1 36.84,51.77 36.84,50.5 39.63,47.7 40.52,47.7 42.17,46.05 42.17,45.8 44.13,43.84 45.52,43.84 46.63,42.74 48.13,42.74 48.69,42.18 59.69,42.18 60.58,43.07 70.2,43.07 71.09,42.18 76.27,42.18 76.57,41.88 79.93,41.88 80.04,41.77 80.5,41.77 80.78,42.04 81.26,42.04 81.72,42.5 82.1,42.5 82.35,42.24 82.89,42.24 83.19,42.55 83.73,42.55 84.03,42.24 84.46,42.24 84.74,42.52 85.15,42.52 85.58,42.95 85.86,42.95 86.24,43.34 86.24,43.6 v1(86.63,43.99)
  BOTTOM w0.149: v1(32.18,72.65) 32.68,73.15 33.47,73.15 33.68,73.35 33.68,73.95 33.88,74.15 34.84,74.15 R59.2 R43.1
MAX_1V8: length 129.4
  BOTTOM w0.203: 136.51,95.12 135.86,95.12 135.49,94.74 135.49,94.26 135.92,93.84 135.92,93.8 136.51,94.39 136.51,95.12
  BOTTOM w0.254: R38.2 v1(30.92,91.26) ; R36.2 v1(23.3,91.26) ; 27.95,53.27 29.11,53.27 U9.B4 29.11,52.27 27.95,52.27
  BOTTOM w0.305: 165.36,106.76 165.3,106.7 R737.2 ; C655.2 R498.2 32.39,97.74 32.65,97.49 34.04,97.49
  BOTTOM w0.381: C51.2 v1(27.3,92.26) ; 161.42,105.62 160.03,104.22 160.03,102.62 158.07,100.66 157.11,100.66 153.63,97.18 138.57,97.18 136.51,95.12 ; 161.42,105.62 161.42,106.25 161.93,106.76 167.01,106.76 167.58,106.19 R359.2 167.58,103.67 U33.10 ; 161.42,105.62 C461.2 162.37,105.61 U33.2 ; 135.92,93.8 135.54,93.42 134.75,93.42 132.21,90.88 122.05,90.88 120.53,89.36 120.53,86.31 119.9,85.68 79.26,85.68 73.21,79.63 72.83,79.63 72.52,79.33 72.52,79.09 v2(72.41,78.97) ; C49.2 v1(34.92,92.26)
  vias: v1(22.18,74.65) v1(22.18,73.65) v1(23.18,85.5) v1(24.18,80.65) v1(25.18,80.65) v1(25.62,54.82) v1(25.62,53.8) v1(26.8,88.66) v1(27.18,80.65) v1(28.18,80.65) v1(29.22,93.26) v1(29.3,91.26) v1(31.88,59.58) v1(32.9,59.58) v1(33.92,59.58) v1(34.93,59.58) v1(36.92,93.26) v1(36.92,91.26) v1(37.82,92.26) v3(34.81,96.47) v3(34.81,95.58) v3(34.81,94.69)
MAX_2V5: length 3.8
  TOP w0.254: R497.2 C651.2
  TOP w0.305: C651.2 35.31,97.74 34.93,97.36 34.22,97.36
  BOTTOM w0.381: C94.1 v1(24.18,79.65)
  vias: v1(23.18,72.65) v1(30.18,79.65) v1(30.18,72.65) v1(31.18,79.65) v1(36.84,81.6) v3(33.28,96.47) v3(33.28,95.58) v3(33.28,94.69)
MAX_CONF_DONE: length 14
  BOTTOM w0.149: Q1.1 25.57,86.88 R81.1 26.8,86.31 26.58,86.08 26.58,84.13 26.68,84.03 26.68,83.39 26.93,83.14 27.31,83.14 27.62,82.83 27.62,78.51 28.02,78.11 29.72,78.11 v1(30.18,77.65)
MAX_I2C_SCL: length 623.3
  TOP w0.149: EU1.12 63.29,82.38 v1(63.29,83.17) ; v1(94.22,36.76) 93.44,36.76 EU2.12 ; U96.B3 v1(198.86,80.2) ; U93.B3 v1(47.9,91.11) ; U44.6 v1(226.85,58.04) ; U23.36 58.34,51.73 58.17,51.89 57.47,51.89 v1(57.09,51.51)
  TOP w0.152: v1(228.99,46.81) 228.99,46.75 228.48,46.24 U50.1 ; v1(225.43,77.8) 225.74,77.8 226.06,78.13 U54.1
  L03_SIG1 w0.081: v1(47.9,91.11) 47.9,91.79 49.03,92.92 50.93,92.92 51.32,93.3 54.74,93.3 55.25,92.79 55.25,92.41 55.51,92.15 59.16,92.15 63.29,88.03 63.29,85.41 64.35,84.36 64.35,83.72 63.79,83.17 v1(63.29,83.17) ; v1(228.99,46.81) 229.5,47.32 229.5,48.85 229.01,49.33 229.01,55.3 228.1,56.21 226.68,56.21 226.27,56.62 226.27,57.46 v1(226.85,58.04) ; v1(57.09,51.51) 57.09,51.2 57.21,51.08 57.21,50.4 56.9,50.09 56.9,47.91 55.05,46.05 55.05,44.76 44.17,33.88 44.17,28.42 42.7,26.95 41.21,26.95 v1(40.77,27.38) 40.77,27.92 41.43,28.58 41.43,29.29 40.42,30.3 38.49,30.3 37.47,31.32 34.27,31.32 v1(33.33,30.38) ; v1(23.76,65.8) 24.15,66.2 25.86,66.2 26.8,67.13 31.12,67.13 31.76,66.5 34.38,66.5 38.49,70.61 38.49,72.47 v1(38.74,72.72)
  L05_SIG2 w0.081: v1(63.29,83.17) 62.65,83.17 59.23,79.75 44.37,79.75 43.31,78.69 43.31,75.64 40.39,72.72 v1(38.74,72.72) ; v1(94.22,36.76) 94.59,36.38 94.59,35.21 95.05,34.75 95.05,31.45 96.76,29.75 111.87,29.75 113.94,27.68 113.94,26.82 114.61,26.14 116.59,26.14 116.77,25.97 116.77,23.76 117.58,22.95 117.58,21.23 122.29,16.52 124.75,16.52 125.36,17.12 126.12,17.12 126.37,17.37 127.21,17.37 128.02,18.18 129.52,18.18 129.75,18.42 129.75,18.76 130.04,19.06 130.59,19.06 131.55,20.02 v1(132.01,20.02)
  L07_SIG3 w0.089: v1(23.76,65.8) 23.21,65.25 18.06,65.25 16.87,64.06 16.87,62.91 16.52,62.56 13.22,62.56 6.78,56.13 4.5,56.13 1.4,53.03 1.4,45.99 v1(2.1,45.29) 4.63,45.29 5.54,46.21 16.01,46.21 16.26,46.46 23.17,46.46 23.91,45.72 23.91,42.78 23.63,42.5 23.63,38.35 25.12,36.86 27.69,36.86 28.99,35.56 28.99,34.72 v1(33.33,30.38)
  L14_SIG5 w0.081: v1(132.01,20.02) 135.74,20.02 136.23,19.54 146.03,19.54 148.98,16.59 218.98,16.59 224.52,22.13 224.52,28.32 217.66,35.18 217.66,42.73 217.05,43.34 212.63,43.34 205.37,50.6 205.37,64.21 202.06,67.52 202.06,77.83 201.63,78.26 200.84,78.26 200.11,79 199.45,79 199.27,79.17 199.27,79.8 v1(198.86,80.2) 198.46,80.61 198.46,83.09 198.94,83.57 198.94,90.83 198.28,91.49 198.28,95.2 198.61,95.53 199.57,95.53 v1(200.03,95.07) ; v1(53.63,37.44) 54.36,38.18 72.85,38.18 77.43,33.61 77.43,31.91 78.44,30.89 84.13,30.89 85.61,32.36 90.15,32.36 94.22,36.43 v1(94.22,36.76)
  L16_SIG6 w0.081: v1(226.85,58.04) 228.75,59.95 233.36,59.95 242.07,68.66 243.72,68.66 J12.1 244.99,71.2 v1(242.64,71.2) 237.12,71.2 234.8,73.52 226.8,73.52 226.12,74.2 226.12,77.12 v1(225.43,77.8) 224.92,78.31 222,78.31 220.73,79.58 219.67,79.58 218.09,81.16 218.09,82.22 210.45,89.87 203.33,89.87 200.41,92.79 200.41,94.69 v1(200.03,95.07) ; v1(53.63,37.44) 53.63,41.87 53.98,42.23 53.98,48.21 55.76,49.99 56.97,49.99 57.54,50.56 57.54,51.07 v1(57.09,51.51) ; v1(236.93,38.31) 235.78,39.45 230.64,39.45 229.37,40.72 229.37,43.13 228.99,43.51 v1(228.99,46.81)
MAX_I2C_SDA: length 642.4
  TOP w0.149: v1(63.29,84.15) 63.8,83.64 EU1.11 ; U93.A3 v1(48.7,91.91) ; U44.5 v1(226.85,56.77) ; U96.A3 v1(199.66,79.4) ; EU2.11 94.71,36.24 v1(95.26,36.78) ; U23.35 57.26,52.23 v1(57.09,52.4)
  TOP w0.152: v1(230.27,43.97) 230.2,43.89 U50.19 ; v1(224.39,80.47) U54.19
  L03_SIG1 w0.081: v1(226.85,56.77) 228.38,56.77 230.23,54.92 230.23,49.33 231.22,48.34 231.22,47.49 230.61,46.88 230.61,44.31 v1(230.27,43.97) ; v1(48.7,91.91) 49.45,92.66 50.81,92.66 51.06,92.41 54.36,92.41 54.87,91.9 54.87,91.77 55.51,91.14 59.17,91.14 62.73,87.57 62.73,84.71 v1(63.29,84.15) ; v1(31.91,30.38) 33.28,31.75 37.85,31.75 38.28,31.32 40.19,31.32 41.84,29.67 v1(41.84,27.38) 42.43,27.38 43.54,28.5 43.54,33.94 54.54,44.94 54.54,46.56 55.4,47.42 55.4,49.43 56.37,50.4 56.37,51.01 56.7,51.34 56.7,52.01 v1(57.09,52.4) ; v1(38.74,74.25) 39.25,73.74 39.25,72.47 38.87,72.09 38.87,70.37 34.74,66.25 31.5,66.25 31.12,66.63 26.93,66.63 26.11,65.8 v1(24.77,65.8)
  L05_SIG2 w0.081: v1(63.29,84.15) 60.97,84.15 60.33,83.52 60.33,81.74 58.59,80 44.12,80 43.06,78.95 43.06,76.1 40.75,73.79 39.2,73.79 v1(38.74,74.25) ; v1(130.77,20.78) 130.55,20.26 130.55,19.95 129.56,18.97 128.23,18.97 127.43,18.17 126.47,18.17 126.14,17.83 126.14,17.64 125.89,17.39 125.11,17.39 124.55,16.82 122.48,16.82 117.98,21.32 117.98,25.18 117.63,25.53 117.63,26.62 117.28,26.98 114.61,26.98 114.36,27.23 114.36,28.02 113.74,28.63 113.74,29.56 112.99,30.3 97.17,30.3 95.66,31.81 95.66,36.38 v1(95.26,36.78)
  L07_SIG3 w0.089: v1(24.77,65.8) 24.33,66.25 17.87,66.25 16.73,65.1 13.95,65.1 6.38,57.54 5.16,57.54 1.02,53.4 1.02,45.48 v1(2.1,44.4) 6.28,44.4 7.04,45.16 22.05,45.16 22.71,45.82 23.22,45.82 23.55,45.49 23.55,43.74 23.2,43.39 23.2,38.18 25.03,36.35 27.54,36.35 28.43,35.46 28.43,33.86 v1(31.91,30.38)
  L14_SIG5 w0.081: v1(95.26,36.78) 94.62,36.15 94.29,36.15 89.67,31.52 85.63,31.52 84.08,29.97 78.34,29.97 76.61,31.7 76.61,33.4 72.35,37.67 54.49,37.67 54.24,37.42 v1(54.24,36.78) ; v1(130.77,20.78) 131.38,20.17 131.38,19.59 132.42,18.54 146.69,18.54 148.9,16.33 220.91,16.33 223.27,18.7 223.27,20.3 224.95,21.97 224.95,28.35 218.9,34.39 218.9,42.5 217.61,43.79 213.04,43.79 206.1,50.73 206.1,64.37 202.7,67.77 202.7,77.9 201.51,79.1 201.02,79.1 200.72,79.4 v1(199.66,79.4) 199.66,80.25 199.26,80.65 199.26,83 199.88,83.62 199.88,91.42 198.89,92.41 v1(198.89,95.07)
  L16_SIG6 w0.081: v1(54.24,36.78) 54.24,41.23 54.49,41.48 54.49,46.81 55.38,47.7 56.4,47.7 57.16,48.47 57.16,49.48 57.67,49.99 58.17,49.99 58.55,50.37 58.55,51.72 58.2,52.07 57.42,52.07 v1(57.09,52.4) ; v1(239.08,38.31) 237.56,39.83 230.77,39.83 230.27,40.32 v1(230.27,43.97) ; v1(198.89,95.07) 199.4,95.58 200.29,95.58 201.05,94.82 201.05,93.42 203.84,90.63 211.08,90.63 219.13,82.58 219.13,80.88 220.15,79.86 221.85,79.86 222.43,79.28 223.2,79.28 v1(224.39,80.47) 226.96,77.9 226.96,76.28 227.94,75.29 235.05,75.29 238,72.34 248.93,72.34 J12.3 247.66,67.52 242.07,67.52 233.59,59.03 229.11,59.03 v1(226.85,56.77)
MAX_VCCD:
  vias: v1(22.18,85.24) v1(22.18,84.65) v1(22.18,71.65) v1(23.22,79.61) v1(31.18,80.65) v1(31.18,71.65)
NIOS_CLK: length 14.8
  L14_SIG5 w0.081: v1(37.38,88.09) 38.72,86.76 38.72,80.6 39.22,80.09 39.22,78.08 38.51,77.37 38.31,77.37 38.21,77.27 36.37,77.27 v1(35.76,76.66)
NIOS_CSN: length 13.7
  L14_SIG5 w0.081: v1(28.84,85.55) 29.42,86.13 30.16,86.13 30.69,85.6 30.69,80.32 30.94,80.06 31.33,80.06 32.74,78.65 v1(33.18,78.65)
  BOTTOM w0.149: U45.1 29.66,85.55 R432.1 28.77,85.61 v1(28.84,85.55)
NIOS_IO0: length 14.9
  L14_SIG5 w0.081: v1(34.18,77.65) 34.63,78.11 35.95,78.11 38.34,80.5 38.34,86.52 36.99,87.86 36.99,88.97 v1(37.38,89.36)
NIOS_IO1: length 12.3
  L14_SIG5 w0.081: v1(30.45,86.82) 31.8,85.47 31.8,80.02 32.8,79.02 33.33,79.02 33.74,78.62 33.74,78.18 33.48,77.93 32.9,77.93 v1(32.18,78.65)
NIOS_IO2: length 15.4
  L14_SIG5 w0.081: v1(34.18,78.65) 33.55,79.28 32.95,79.28 32.62,79.6 32.62,85.53 30.87,87.28 30.23,87.28 v1(28.77,88.73)
  BOTTOM w0.149: U45.3 R433.1 v1(28.77,88.73)
NIOS_IO3: length 13.6
  L14_SIG5 w0.081: v1(33.18,79.65) 33.61,80.09 33.61,81 33.84,81.23 36.71,81.23 36.9,81.04 v1(36.9,80.72) 37.29,81.12 37.29,81.82 37.88,82.4 37.88,83.9 36.08,85.7 36.08,86.34 36.56,86.82 v1(37.38,86.82)
OUTLET_TEMP_N: length 224.3
  L14_SIG5 w0.203: v1(92.44,31.11) 92.09,30.76 92.09,30.42 91.52,29.85 85.39,29.85 84.07,28.53 73.66,28.53 72.88,27.75 72.88,25.12 73.59,24.41 73.59,21.74 74.07,21.26 74.07,20.65 73.39,19.98 73.39,17.24 75.92,14.71 129.46,14.71 131.54,16.79 142.83,16.79 144.28,18.24 146.57,18.24 148.78,16.03 223.19,16.03 235.01,27.85 235.01,46.25 236.88,48.12 237.31,48.12 v1(237.64,48.46)
OUTLET_TEMP_P: length 224.9
  L14_SIG5 w0.203: v1(91.42,31.11) 91.76,30.76 91.76,30.56 91.38,30.18 85.25,30.18 83.93,28.86 73.52,28.86 72.55,27.89 72.55,24.99 73.26,24.28 73.26,21.6 73.74,21.12 73.74,20.79 73.06,20.11 73.06,17.1 75.79,14.38 129.6,14.38 131.68,16.46 142.97,16.46 144.42,17.91 146.44,17.91 148.65,15.7 223.32,15.7 235.34,27.71 235.34,46.11 237.02,47.79 237.31,47.79 v1(237.64,47.46)
OVERTEMP_LEDN: length 40.6
  TOP w0.149: v1(36.71,107.27) 36.65,107.33 D5.C
  L07_SIG3 w0.089: v1(36.71,107.27) 36.71,106.63 35.83,105.75 33.38,105.75 32.38,104.75 32.38,94.68 31.25,93.55 31.25,91.84 31.63,91.46 31.63,77.45 31.33,77.15 30.98,77.15 30.68,76.85 30.68,76.41 30.42,76.15 29.88,76.15 28.68,74.95 28.68,74.55 28.18,74.05 v1(28.18,73.65)
  BOTTOM w0.149: v1(36.71,107.27) 36.9,107.08 R780.1
PCIE_3V3_AUX: length 2
  BOTTOM w0.381: U2.8 41.76,21.82 42.17,21.41 v1(42.17,20.34)
  vias: v1(34.11,19.64) v1(34.2,26.05) v1(34.17,24.15) v1(44.27,20.4) v1(50.3,11.45) v1(51.44,11.45) v1(55.51,11.45) v3(54.24,8.33) v3(54.24,7.44) v3(54.87,8.33) v3(54.87,7.44)
PCIE_3V3_EP_CLKREQN: length 6.7
  TOP w0.17: J1.B12 58.65,6.4 58.83,6.58 58.83,10.2 C16.1
PCIE_3V3_EP_PERSTN: length 91
  L07_SIG3 w0.089: v1(60.33,12.4) 59.76,12.97 58.81,12.97 55.16,16.61 55.16,20.11 52.59,22.68 49.41,22.68 48.06,24.03 43.7,24.03 43.57,24.16 43.57,27 44.33,27.76 44.33,31.7 43.72,32.31 43.72,37.22 43.08,37.86 43.08,39.29 43.9,40.11 43.9,41.48 41.61,43.77 40.77,43.77 35.48,49.06 35.48,68.14 34.3,69.32 34.3,70.94 34.6,71.25 34.6,73.23 v1(34.18,73.65)
  BOTTOM w0.149: J1.A11 55.46,4.3 55.46,8.92 56.52,9.98 R6.2 57.09,10.56 57.79,11.25 59.7,11.25 60.33,11.89 v1(60.33,12.4)
PCIE_3V3_EP_PWRBRKN: length 95.2
  TOP w0.17: R774.1 R12.2 v1(73.73,12.65)
  L07_SIG3 w0.089: v1(34.18,74.65) 34.88,73.95 34.88,71.63 35.31,71.2 35.31,70.11 35.78,69.64 35.78,65.52 38.62,62.69 38.62,57.1 39.76,55.96 39.76,45.16 40.86,44.06 41.83,44.06 44.23,41.66 44.23,40.03 43.44,39.24 43.44,38.11 43.97,37.57 43.97,32.69 44.71,31.96 44.71,27.51 43.95,26.75 43.95,24.46 44.08,24.34 48.39,24.34 49.66,23.07 58.83,23.07 60.05,21.85 68.15,21.85 70.01,19.99 70.01,16.37 v1(73.73,12.65)
PCIE_3V3_EP_SMBCLK: length 31.7
  TOP w0.149: J1.B5 49.65,8.98 49.28,9.35 49.28,10.43 R1.1 R3.2 50.72,10.56 50.86,10.7 50.86,11.97 v1(48.14,14.68)
  L16_SIG6 w0.081: v1(41.39,24.36) 42.48,24.36 43.47,23.37 45.17,23.37 46.62,21.92 46.62,20.98 48.14,19.46 v1(48.14,14.68)
  BOTTOM w0.149: 39.89,27.26 39.89,24.59 40.11,24.36 v1(41.39,24.36)
PCIE_3V3_EP_SMBDAT: length 32
  TOP w0.149: J1.B6 50.65,9.77 R4.2 51.63,10.37 52.27,10.37 R2.1 52.32,10.7 52.08,10.7 51.95,10.82 51.95,11.89 v1(49.16,14.68)
  L16_SIG6 w0.081: v1(41.39,25.63) 42.27,25.63 43.9,24.01 45.12,24.01 47.2,21.92 47.56,21.92 47.89,21.59 47.89,20.96 49.49,19.36 49.49,15.01 v1(49.16,14.68)
  BOTTOM w0.149: v1(41.39,25.63) 42.07,25.63 42.68,26.24 42.68,27.26
PCIE_3V3_EP_WAKEN: length 6.5
  TOP w0.149: J1.B11 55.51,4.25 R8.1
PCIE_EP_3V3:
  vias: v1(49.41,11.45) v1(52.59,11.45) v1(54.49,11.45) v3(52.33,8.33) v3(52.33,7.44) v3(53.09,8.33) v3(53.09,7.44) v3(53.09,6.43)
PCIE_EP_12V: length 73
  L14_SIG5 w0.305: v1(248.86,93.42) 249.82,92.47 249.82,85.04 244.14,79.36 244.14,76.49 241.05,73.41 241.05,53.93 240.55,53.42 235.85,53.42 233.31,50.88 233.31,39.7 231.02,37.42 227.36,37.42 v3(226.6,38.18)
  BOTTOM w0.305: v1(226.51,43.4) 227.13,44.02 R456.1
  vias: v1(224.48,43.4) v1(224.48,42.89) v1(224.48,42.38) v1(224.48,41.88) v1(225.49,43.4) v1(225.49,42.89) v1(225.49,42.38) v1(225.49,41.88) v1(226.51,42.89) v1(226.51,42.38) v1(226.51,41.88) v1(226.96,39.96) v3(46.49,8.71) v3(46.49,8.08) v3(46.49,7.44) v3(46.49,6.81) v3(46.49,6.17) v3(47.12,8.71) v3(47.12,8.08) v3(47.12,7.44) v3(47.12,6.81) v3(47.12,6.17) v3(47.76,8.71) v3(47.76,8.08) v3(47.76,7.44) v3(47.76,6.81) v3(47.76,6.17) v3(48.39,8.71) v3(48.39,8.08) v3(48.39,7.44) v3(220.89,39.58) v3(220.89,38.18) v3(220.89,36.78) v3(220.89,33.99) v3(222.28,33.99) v3(222.28,32.59) v3(225.2,39.58) v3(225.2,38.18) v3(225.2,36.78) v3(225.2,33.99) v3(225.2,32.59) v3(226.6,36.78) v3(226.6,33.99) v3(226.6,32.59) v5(220.86,35.38) v5(222.26,39.58) v5(222.26,38.18) v5(222.26,36.78) v5(222.26,35.38) v5(223.78,39.58) v5(223.78,38.18) v5(223.78,36.78) v5(223.78,35.38) v5(223.78,33.99) v5(223.78,32.59) v5(225.18,35.38) v5(226.58,35.38)
PCIE_EP_JTAG_TCK: length 15.4
  BOTTOM w0.149: U31.1 47.25,12.64 47.12,12.51 47.12,12.14 47.25,12.02 47.89,12.02 48.08,11.83 R334.1 48.08,10.94 47.76,10.62 47.25,10.62 47.02,10.39 47.02,9.6 47.15,9.48 47.38,9.48 47.51,9.6 47.51,9.98 47.63,10.11 47.89,10.11 48.01,9.98 48.01,9.6 48.14,9.48 48.78,9.48 49.28,8.97 49.28,7.7 49.41,7.57 49.79,7.57 49.92,7.44 49.92,7.19 49.79,7.06 49.44,7.06 49.31,6.94 49.31,6.68 49.44,6.56 49.79,6.56 49.92,6.43 49.92,6.05 49.65,5.78 J1.A5
PCIE_EP_JTAG_TDI: length 13.8
  BOTTOM w0.149: U31.3 48.99,13.94 49.16,13.77 49.16,12.07 48.93,11.84 48.93,10.68 R331.2 48.62,10.59 48.48,10.45 48.48,10.11 48.61,9.98 49.03,9.98 49.66,9.35 50.3,9.35 50.43,9.22 50.43,8.84 50.3,8.71 49.88,8.71 49.79,8.63 49.79,8.33 49.92,8.21 50.3,8.21 50.43,8.08 50.43,5.97 50.65,5.74 J1.A6
PCIE_EP_JTAG_TDO: length 13.8
  BOTTOM w0.149: R328.1 54.74,15.19 53.09,13.54 53.09,11.2 51.06,9.17 51.06,5.97 51.65,5.38 J1.A7
PCIE_EP_JTAG_TMS: length 14.4
  BOTTOM w0.149: U28.1 54.35,12.64 54.24,12.52 54.24,12.14 54.36,12.02 54.74,12.02 55,11.76 55,11.12 R326.2 54.63,10.37 55,10 55,9.6 54.87,9.48 54.49,9.48 54.36,9.6 54.36,9.86 54.24,9.98 53.86,9.98 53.73,9.86 53.73,9.6 53.6,9.48 52.2,9.48 51.57,8.84 51.57,6.94 52.48,6.02 52.48,4.27 J1.A8
PCIE_EP_PRSNT_N: length 236.2
  L14_SIG5 w0.081: v1(251.47,38.43) 243.85,30.81 243.85,18.25 239.02,13.43 137.51,13.43 134.02,9.93 129.68,9.93 127.01,7.27 59.63,7.27 57.8,9.1 49.28,9.1 48.52,9.86 v1(46.49,9.86)
  L16_SIG6 w0.081: v1(251.47,34.62) v1(251.47,35.89) v1(251.47,37.16) v1(251.47,38.43)
  BOTTOM w0.149: J1.A1 45.8,4.25 45.8,9.17 v1(46.49,9.86)
PCIE_EP_PRSNT_NX1: length 205.8
  TOP w0.17: v1(61.48,10.49) 63.65,8.31 J1.B17
  L14_SIG5 w0.081: v1(61.48,10.49) 61.98,9.98 77.24,9.98 78.72,11.46 85.18,11.46 86.49,12.78 130.44,12.78 133.03,15.37 144.21,15.37 145.55,16.72 146.95,16.72 148.29,15.37 223.76,15.37 236.35,27.97 236.35,33.12 241.66,38.43 v1(243.85,38.43)
PCIE_EP_PRSNT_NX4: length 187.8
  TOP w0.17: C28.1 77.65,10.35 v1(77.65,9.86) J1.B31
  L14_SIG5 w0.081: v1(77.65,9.86) 91.22,9.86 92.84,11.48 120.12,11.48 120.91,12.27 130.94,12.27 133.8,15.13 144.59,15.13 145.55,16.08 146.82,16.08 147.79,15.11 224.08,15.11 237.01,28.04 237.01,33.15 241.03,37.16 v1(243.85,37.16)
PCIE_EP_PRSNT_NX8: length 169.9
  TOP w0.17: v1(95.77,10.56) 94.65,9.45 J1.B48
  L14_SIG5 w0.081: v1(243.85,35.89) 240.65,32.69 240.65,27 238.77,25.12 236.66,25.12 226.7,15.17 225.15,15.17 224.86,14.87 147.52,14.87 146.82,15.57 145.62,15.57 144.93,14.89 134.58,14.89 131.38,11.69 121.65,11.69 119.95,9.99 96.33,9.99 v1(95.77,10.56)
PCIE_EP_PRSNT_NX16: length 146.8
  TOP w0.17: J1.B81 127.65,7.43 125.74,9.35 122.63,9.35 v1(121.42,10.56)
  L14_SIG5 w0.081: v1(243.85,34.62) 241.38,32.15 241.38,26.94 238.62,24.19 236.34,24.19 226.78,14.64 147.12,14.64 146.57,15.19 145.85,15.19 145.3,14.64 135.09,14.64 131.75,11.3 129.08,11.3 128.34,10.56 v1(121.42,10.56)
PCIE_EP_RX_CN0: length 6.6
  BOTTOM w0.116: C2.2 63.35,10.32 arc(63.3,10.25) 63.28,10.16 63.28,6.55 arc(63.3,6.46) 63.35,6.39
  BOTTOM w0.17: J1.A17 63.65,5.96 arc(63.63,6.07) 63.57,6.17 63.35,6.39
PCIE_EP_RX_CN1: length 6.6
  BOTTOM w0.116: C7.2 68.35,10.32 arc(68.3,10.25) 68.28,10.16 68.28,6.55 arc(68.3,6.46) 68.35,6.39
  BOTTOM w0.17: 68.35,6.39 68.57,6.17 arc(68.63,6.07) 68.65,5.96 J1.A22
PCIE_EP_RX_CN2: length 6.6
  BOTTOM w0.116: C9.2 72.35,10.32 arc(72.3,10.25) 72.28,10.16 72.28,6.55 arc(72.3,6.46) 72.35,6.39
  BOTTOM w0.17: 72.35,6.39 72.57,6.17 arc(72.63,6.07) 72.65,5.96 J1.A26
PCIE_EP_RX_CN3: length 6.6
  BOTTOM w0.116: C11.2 76.35,10.32 arc(76.3,10.25) 76.28,10.16 76.28,6.55 arc(76.3,6.46) 76.35,6.39
  BOTTOM w0.17: J1.A30 76.65,5.96 arc(76.63,6.07) 76.57,6.17 76.35,6.39
PCIE_EP_RX_CN4: length 6.6
  BOTTOM w0.116: C13.2 82.35,10.32 arc(82.3,10.25) 82.28,10.16 82.28,6.55 arc(82.3,6.46) 82.35,6.39
  BOTTOM w0.17: 82.35,6.39 82.57,6.17 arc(82.63,6.07) 82.65,5.96 J1.A36
PCIE_EP_RX_CN5: length 6.6
  BOTTOM w0.116: C15.2 86.35,10.32 arc(86.3,10.25) 86.28,10.16 86.28,6.55 arc(86.3,6.46) 86.35,6.39
  BOTTOM w0.17: J1.A40 86.65,5.96 arc(86.63,6.07) 86.57,6.17 86.35,6.39
PCIE_EP_RX_CN6: length 6.6
  BOTTOM w0.116: C20.2 90.35,10.32 arc(90.3,10.25) 90.28,10.16 90.28,6.55 arc(90.3,6.46) 90.35,6.39
  BOTTOM w0.17: J1.A44 90.65,5.96 arc(90.63,6.07) 90.57,6.17 90.35,6.39
PCIE_EP_RX_CN7: length 6.6
  BOTTOM w0.116: C26.2 94.35,10.32 arc(94.3,10.25) 94.28,10.16 94.28,6.55 arc(94.3,6.46) 94.35,6.39
  BOTTOM w0.17: J1.A48 94.65,5.96 arc(94.63,6.07) 94.57,6.17 94.35,6.39
PCIE_EP_RX_CN8: length 6.6
  BOTTOM w0.116: C32.2 99.35,10.32 arc(99.3,10.25) 99.28,10.16 99.28,6.55 arc(99.3,6.46) 99.35,6.39
  BOTTOM w0.17: J1.A53 99.65,5.96 arc(99.63,6.07) 99.57,6.17 99.35,6.39
PCIE_EP_RX_CN9: length 6.6
  BOTTOM w0.116: C34.2 103.35,10.32 arc(103.3,10.25) 103.28,10.16 103.28,6.55 arc(103.3,6.46) 103.35,6.39
  BOTTOM w0.17: 103.35,6.39 103.57,6.17 arc(103.63,6.07) 103.65,5.96 J1.A57
PCIE_EP_RX_CN10: length 6.6
  BOTTOM w0.116: C36.2 107.35,10.32 arc(107.3,10.25) 107.28,10.16 107.28,6.55 arc(107.3,6.46) 107.35,6.39
  BOTTOM w0.17: J1.A61 107.65,5.96 arc(107.63,6.07) 107.57,6.17 107.35,6.39
PCIE_EP_RX_CN11: length 6.6
  BOTTOM w0.116: C39.2 111.35,10.32 arc(111.3,10.25) 111.28,10.16 111.28,6.55 arc(111.3,6.46) 111.35,6.39
  BOTTOM w0.17: J1.A65 111.65,5.96 arc(111.63,6.07) 111.57,6.17 111.35,6.39
PCIE_EP_RX_CN12: length 6.6
  BOTTOM w0.116: C41.2 115.35,10.32 arc(115.3,10.25) 115.28,10.16 115.28,6.55 arc(115.3,6.46) 115.35,6.39
  BOTTOM w0.17: J1.A69 115.65,5.96 arc(115.63,6.07) 115.57,6.17 115.35,6.39
PCIE_EP_RX_CN13: length 6.6
  BOTTOM w0.116: C43.2 119.35,10.32 arc(119.3,10.25) 119.28,10.16 119.28,6.55 arc(119.3,6.46) 119.35,6.39
  BOTTOM w0.17: J1.A73 119.65,5.96 arc(119.63,6.07) 119.57,6.17 119.35,6.39
PCIE_EP_RX_CN14: length 6.6
  BOTTOM w0.116: C45.2 123.35,10.32 arc(123.3,10.25) 123.28,10.16 123.28,6.55 arc(123.3,6.46) 123.35,6.39
  BOTTOM w0.17: J1.A77 123.65,5.96 arc(123.63,6.07) 123.57,6.17 123.35,6.39
PCIE_EP_RX_CN15: length 6.6
  BOTTOM w0.116: C47.2 127.35,10.32 arc(127.3,10.25) 127.28,10.16 127.28,6.55 arc(127.3,6.46) 127.35,6.39
  BOTTOM w0.17: 127.35,6.39 127.57,6.17 arc(127.63,6.07) 127.65,5.96 J1.A81
PCIE_EP_RX_CP0: length 6.6
  BOTTOM w0.116: C1.2 62.98,10.32 arc(63.02,10.25) 63.04,10.16 63.04,6.55 arc(63.02,6.46) 62.97,6.39
  BOTTOM w0.17: 62.97,6.39 62.74,6.15 arc(62.68,6.06) 62.65,5.95 J1.A16
PCIE_EP_RX_CP1: length 6.6
  BOTTOM w0.116: C6.2 67.98,10.32 arc(68.02,10.25) 68.04,10.16 68.04,6.55 arc(68.02,6.46) 67.97,6.39
  BOTTOM w0.17: J1.A21 67.65,5.95 arc(67.68,6.06) 67.74,6.15 67.97,6.39
PCIE_EP_RX_CP2: length 6.6
  BOTTOM w0.116: C8.2 71.98,10.32 arc(72.02,10.25) 72.04,10.16 72.04,6.55 arc(72.02,6.46) 71.97,6.39
  BOTTOM w0.17: J1.A25 71.65,5.95 arc(71.68,6.06) 71.74,6.15 71.97,6.39
PCIE_EP_RX_CP3: length 6.6
  BOTTOM w0.116: C10.2 75.98,10.32 arc(76.02,10.25) 76.04,10.16 76.04,6.55 arc(76.02,6.46) 75.97,6.39
  BOTTOM w0.17: J1.A29 75.65,5.95 arc(75.68,6.06) 75.74,6.15 75.97,6.39
PCIE_EP_RX_CP4: length 6.6
  BOTTOM w0.116: C12.2 81.98,10.32 arc(82.02,10.25) 82.04,10.16 82.04,6.55 arc(82.02,6.46) 81.97,6.39
  BOTTOM w0.17: J1.A35 81.65,5.95 arc(81.68,6.06) 81.74,6.15 81.97,6.39
PCIE_EP_RX_CP5: length 6.6
  BOTTOM w0.116: C14.2 85.98,10.32 arc(86.02,10.25) 86.04,10.16 86.04,6.55 arc(86.02,6.46) 85.97,6.39
  BOTTOM w0.17: 85.97,6.39 85.74,6.15 arc(85.68,6.06) 85.65,5.95 J1.A39
PCIE_EP_RX_CP6: length 6.6
  BOTTOM w0.116: C18.2 89.98,10.32 arc(90.02,10.25) 90.04,10.16 90.04,6.55 arc(90.02,6.46) 89.97,6.39
  BOTTOM w0.17: J1.A43 89.65,5.95 arc(89.68,6.06) 89.74,6.15 89.97,6.39
PCIE_EP_RX_CP7: length 6.6
  BOTTOM w0.116: C24.2 93.98,10.32 arc(94.02,10.25) 94.04,10.16 94.04,6.55 arc(94.02,6.46) 93.97,6.39
  BOTTOM w0.17: 93.97,6.39 93.74,6.15 arc(93.68,6.06) 93.65,5.95 J1.A47
PCIE_EP_RX_CP8: length 6.6
  BOTTOM w0.116: C31.2 98.98,10.32 arc(99.02,10.25) 99.04,10.16 99.04,6.55 arc(99.02,6.46) 98.97,6.39
  BOTTOM w0.17: 98.97,6.39 98.74,6.15 arc(98.68,6.06) 98.65,5.95 J1.A52
PCIE_EP_RX_CP9: length 6.6
  BOTTOM w0.116: C33.2 102.98,10.32 arc(103.02,10.25) 103.04,10.16 103.04,6.55 arc(103.02,6.46) 102.97,6.39
  BOTTOM w0.17: J1.A56 102.65,5.95 arc(102.68,6.06) 102.74,6.15 102.97,6.39
PCIE_EP_RX_CP10: length 6.6
  BOTTOM w0.116: C35.2 106.98,10.32 arc(107.02,10.25) 107.04,10.16 107.04,6.55 arc(107.02,6.46) 106.97,6.39
  BOTTOM w0.17: 106.97,6.39 106.74,6.15 arc(106.68,6.06) 106.65,5.95 J1.A60
PCIE_EP_RX_CP11: length 6.6
  BOTTOM w0.116: C38.2 110.98,10.32 arc(111.02,10.25) 111.04,10.16 111.04,6.55 arc(111.02,6.46) 110.97,6.39
  BOTTOM w0.17: J1.A64 110.65,5.95 arc(110.68,6.06) 110.74,6.15 110.97,6.39
PCIE_EP_RX_CP12: length 6.6
  BOTTOM w0.116: C40.2 114.98,10.32 arc(115.02,10.25) 115.04,10.16 115.04,6.55 arc(115.02,6.46) 114.97,6.39
  BOTTOM w0.17: J1.A68 114.65,5.95 arc(114.68,6.06) 114.74,6.15 114.97,6.39
PCIE_EP_RX_CP13: length 6.6
  BOTTOM w0.116: C42.2 118.98,10.32 arc(119.02,10.25) 119.04,10.16 119.04,6.55 arc(119.02,6.46) 118.97,6.39
  BOTTOM w0.17: J1.A72 118.65,5.95 arc(118.68,6.06) 118.74,6.15 118.97,6.39
PCIE_EP_RX_CP14: length 6.6
  BOTTOM w0.116: C44.2 122.98,10.32 arc(123.02,10.25) 123.04,10.16 123.04,6.55 arc(123.02,6.46) 122.97,6.39
  BOTTOM w0.17: 122.97,6.39 122.74,6.15 arc(122.68,6.06) 122.65,5.95 J1.A76
PCIE_EP_RX_CP15: length 6.6
  BOTTOM w0.116: C46.2 126.98,10.32 arc(127.02,10.25) 127.04,10.16 127.04,6.55 arc(127.02,6.46) 126.97,6.39
  BOTTOM w0.17: J1.A80 126.65,5.95 arc(126.68,6.06) 126.74,6.15 126.97,6.39
PCIE_EP_RX_N0: length 93.1
  L16_SIG6 w0.085: v6(63.49,11) 63.26,11.22 63.26,11.46 63.32,11.6 63.56,11.79 68.35,13.91 70.53,14.57 75.93,15.78 79.66,16.34 81.63,17.16 81.9,17.43 82.07,17.84 82.07,22.63 82.43,23.48 82.43,26.75 82.48,27.28 82.77,27.98 84.71,29.92 87.04,31.48 90.61,32.96 92.32,34.1 93.45,35.48 93.73,35.75 94.19,35.94 95.33,35.94 95.74,36.12 96.17,36.54 97.12,36.93 99.86,36.93 101.82,37.75 103.2,37.75 104.37,37.26 107.67,37.26 108.96,37.8 115.27,37.8 121.06,40.2 122.75,41.89 123.1,42.41 123.26,42.8 124.14,47.21 124.14,53.09 arc(123.94,53.57) 123.46,53.77 123.2,53.77 arc(123.1,53.8) 123.03,53.88 122.97,53.97 arc(122.85,54.12) 122.69,54.22 121.61,54.67 arc(121.49,54.74) 121.4,54.84 121.35,54.94 arc(121.19,55.1) 120.97,55.15 120.86,55.15 arc(120.72,55.19) 120.61,55.3 120.56,55.38 arc(120.39,55.55) 120.16,55.61 120,55.61 arc(119.81,55.56) 119.67,55.43 119.65,55.38 arc(119.6,55.34) 119.53,55.35 U8.AL5
PCIE_EP_RX_N1: length 94.3
  L16_SIG6 w0.085: U8.AM8 117.14,56.08 arc(117.18,56.15) 117.16,56.23 117.14,56.26 arc(117.1,56.39) 117.13,56.52 117.2,56.69 arc(117.38,56.91) 117.65,56.99 117.79,56.99 arc(118.04,56.92) 118.2,56.72 118.22,56.66 arc(118.31,56.55) 118.45,56.51 118.54,56.51 arc(118.7,56.48) 118.85,56.38 119.07,56.16 arc(119.16,56.09) 119.27,56.07 119.37,56.07 arc(119.45,56.09) 119.51,56.13 119.73,56.35 arc(119.88,56.45) 120.06,56.49 120.13,56.49 arc(120.41,56.41) 120.62,56.21 120.64,56.17 arc(120.71,56.1) 120.81,56.07 120.88,56.07 arc(121,56.06) 121.11,56.01 122.02,55.49 arc(122.12,55.41) 122.2,55.3 122.23,55.25 arc(122.3,55.18) 122.41,55.15 122.54,55.15 arc(122.78,55.09) 122.96,54.92 123.03,54.79 arc(123.1,54.72) 123.2,54.69 123.62,54.69 124.19,54.46 124.67,53.97 124.95,53.31 124.95,46.54 124.17,42.61 124.04,42.3 123.51,41.51 120.1,38.1 118.03,36.71 116.48,36.07 97.33,36.07 96.91,35.9 95.27,34.25 93.51,33.08 87.3,30.51 85.09,29.03 83.78,27.71 83.46,27.08 83.46,24.05 82.81,22.49 82.81,17.71 82.52,17.01 81.97,16.46 79.85,15.58 71.66,13.95 70.14,13.32 69.4,12.83 68.36,11.79 68.26,11.55 68.26,11.22 v6(68.49,11)
PCIE_EP_RX_N2: length 89.1
  L16_SIG6 w0.085: U8.AR5 119.53,57.19 arc(119.6,57.18) 119.65,57.22 119.67,57.27 arc(119.81,57.4) 120,57.45 120.16,57.45 arc(120.39,57.39) 120.56,57.22 120.61,57.14 arc(120.72,57.03) 120.86,56.99 120.97,56.99 arc(121.19,56.94) 121.35,56.78 121.4,56.68 arc(121.49,56.58) 121.61,56.51 122.69,56.06 arc(122.85,55.96) 122.97,55.81 123.03,55.72 arc(123.1,55.64) 123.2,55.61 123.79,55.61 124.64,55.26 125.27,54.63 125.76,53.44 125.76,46.39 125.01,42.6 124.4,41.12 121.48,38.21 118.25,36.05 117.94,35.74 117.72,35.22 117.55,35.05 117.2,34.9 105.45,34.9 105,34.72 104.37,34.08 101.88,33.05 96.54,31.99 92.7,30.4 88.86,29.63 85.6,28.29 84.41,27.3 84.28,27.11 84.21,26.88 84.21,19.18 84.05,18.41 83.41,16.86 82.32,15.77 80.19,14.89 76.69,13.83 73.56,13.2 73.11,12.75 72.93,12.32 72.42,11.81 72.26,11.44 72.26,11.22 v6(72.49,11)
PCIE_EP_RX_N3: length 91.4
  L16_SIG6 w0.085: U8.AT8 117.14,57.92 arc(117.18,57.99) 117.16,58.07 117.14,58.1 arc(117.1,58.23) 117.13,58.36 117.2,58.53 arc(117.38,58.75) 117.65,58.83 117.79,58.83 arc(118.04,58.76) 118.2,58.56 118.22,58.5 arc(118.31,58.39) 118.45,58.35 118.54,58.35 arc(118.7,58.32) 118.85,58.22 119.07,58 arc(119.16,57.93) 119.27,57.91 119.37,57.91 arc(119.45,57.93) 119.51,57.97 119.73,58.19 arc(119.88,58.29) 120.06,58.33 120.13,58.33 arc(120.41,58.25) 120.62,58.05 120.64,58.01 arc(120.71,57.94) 120.81,57.91 120.88,57.91 arc(121,57.9) 121.11,57.85 122.02,57.33 arc(122.12,57.25) 122.2,57.14 122.23,57.09 arc(122.3,57.02) 122.41,56.99 122.54,56.99 arc(122.78,56.93) 122.96,56.76 123.03,56.63 arc(123.1,56.56) 123.2,56.53 123.85,56.53 125.44,55.88 125.9,55.42 126.64,53.62 126.64,46.18 125.86,42.25 125.44,41.23 124.24,39.45 119.82,35.03 116.81,33.78 107.91,33.78 101.61,31.17 98.07,30.47 95.42,29.05 95.01,28.63 94.63,27.73 94.63,18.63 94.23,17.65 94.05,17.38 93.36,16.69 91.91,15.72 91.15,15.41 87.32,14.64 80.67,11.89 77.89,11.89 76.49,11.61 76.26,11.39 76.26,11.22 v6(76.49,11)
PCIE_EP_RX_N4: length 84.7
  L16_SIG6 w0.085: v6(82.49,11) 82.26,11.22 82.26,11.41 82.3,11.51 82.87,11.89 87.31,13.73 90.82,14.43 92.25,15.02 93.51,15.86 94.49,16.84 94.89,17.43 95.4,18.66 95.4,27.17 95.85,28.25 96.37,28.77 98.17,29.74 102.43,30.58 108.31,33.02 117.26,33.02 120.11,34.2 122.9,36.07 124.01,37.18 125.99,40.14 126.64,41.72 127.48,45.95 127.48,53.93 126.7,55.81 125.78,56.73 124.04,57.45 123.2,57.45 arc(123.1,57.48) 123.03,57.56 122.97,57.65 arc(122.85,57.8) 122.69,57.9 121.61,58.35 arc(121.49,58.42) 121.4,58.52 121.35,58.62 arc(121.19,58.78) 120.97,58.83 120.86,58.83 arc(120.72,58.87) 120.61,58.98 120.56,59.06 arc(120.39,59.23) 120.16,59.29 120,59.29 arc(119.81,59.24) 119.67,59.11 119.65,59.06 arc(119.6,59.02) 119.53,59.03 U8.AW5
PCIE_EP_RX_N5: length 86.9
  L16_SIG6 w0.085: v6(86.49,11) 86.26,11.22 86.26,11.4 86.62,11.76 87.06,12.06 92.76,14.42 94.22,15.39 95.14,16.31 95.59,16.99 96.16,18.36 96.16,27.05 96.47,27.8 96.91,28.24 99.37,29.26 103.54,30.09 108.9,32.31 117.78,32.31 120.48,33.43 123.26,35.28 124.77,36.8 126.75,39.76 127.52,41.62 128.35,45.81 128.35,54.28 127.52,56.3 126.25,57.56 124.3,58.37 123.2,58.37 arc(123.1,58.4) 123.03,58.47 122.96,58.6 arc(122.78,58.77) 122.54,58.83 122.41,58.83 arc(122.3,58.86) 122.23,58.93 122.2,58.98 arc(122.12,59.09) 122.02,59.17 121.11,59.69 arc(121,59.74) 120.88,59.75 120.81,59.75 arc(120.71,59.78) 120.64,59.85 120.62,59.89 arc(120.41,60.09) 120.13,60.17 120.06,60.17 arc(119.88,60.13) 119.73,60.03 119.51,59.81 arc(119.45,59.77) 119.37,59.75 119.27,59.75 arc(119.16,59.77) 119.07,59.84 118.85,60.06 arc(118.7,60.16) 118.54,60.19 118.45,60.19 arc(118.31,60.23) 118.22,60.34 118.2,60.4 arc(118.04,60.6) 117.79,60.67 117.65,60.67 arc(117.38,60.59) 117.2,60.37 117.13,60.2 arc(117.1,60.07) 117.14,59.94 117.16,59.91 arc(117.18,59.83) 117.14,59.76 U8.AY8
PCIE_EP_RX_N6: length 82.5
  L16_SIG6 w0.085: U8.BC5 119.53,60.87 arc(119.6,60.86) 119.65,60.9 119.67,60.95 arc(119.81,61.08) 120,61.13 120.16,61.13 arc(120.39,61.07) 120.56,60.9 120.61,60.82 arc(120.72,60.71) 120.86,60.67 120.97,60.67 arc(121.19,60.62) 121.35,60.46 121.4,60.36 arc(121.49,60.26) 121.61,60.19 122.69,59.74 arc(122.85,59.64) 122.97,59.49 123.03,59.4 arc(123.1,59.32) 123.2,59.29 124.32,59.29 126.85,58.25 128.28,56.81 129.14,54.72 129.14,45.28 128.37,41.41 127.29,38.79 124.77,35.02 123.46,33.71 118.24,31.55 109.68,31.55 102.94,28.76 97.49,27.67 97.1,27.29 96.92,26.85 96.92,18 96.2,16.26 94.69,14.76 92,12.96 90.61,11.82 90.3,11.51 90.26,11.41 90.26,11.22 v6(90.49,11)
PCIE_EP_RX_N7: length 81.7
  L16_SIG6 w0.085: U8.BG5 119.53,62.71 arc(119.6,62.7) 119.65,62.74 119.67,62.79 arc(119.81,62.92) 120,62.97 120.16,62.97 arc(120.39,62.91) 120.56,62.74 120.61,62.66 arc(120.72,62.55) 120.86,62.51 120.97,62.51 arc(121.19,62.46) 121.35,62.3 121.43,62.16 arc(121.52,62.05) 121.63,61.98 122.71,61.53 arc(122.88,61.43) 123,61.28 123.02,61.24 arc(123.1,61.16) 123.21,61.13 124.12,61.13 126.56,60.13 128.81,57.88 129.83,55.41 129.83,44.31 129.16,40.96 128.26,38.78 125.66,34.89 123.72,32.95 118.68,30.86 110.21,30.86 108.62,30.21 107.42,29.01 106.83,27.57 106.83,19.41 106.49,17.7 106.34,17.48 105.29,16.43 104.33,15.79 94.41,11.68 94.32,11.59 94.26,11.44 94.26,11.22 v6(94.49,11)
PCIE_EP_RX_N8: length 79.9
  L16_SIG6 w0.085: v6(99.49,11) 99.26,11.22 99.26,11.37 99.36,11.61 99.64,11.89 102.92,14.08 105.62,15.52 106.4,16.3 107.21,17.51 107.59,19.43 107.59,27.22 108.09,28.43 109.08,29.43 110.9,30.18 119.42,30.18 123.76,31.97 126.8,35.02 128.81,38.03 130.01,40.92 130.64,44.08 130.64,55.84 129.63,58.28 126,61.9 123.5,62.94 arc(123.42,62.97) 123.33,62.97 123.19,62.97 arc(123.1,63) 123.03,63.06 123,63.12 arc(122.88,63.27) 122.71,63.37 121.63,63.82 arc(121.52,63.89) 121.43,64 121.35,64.14 arc(121.19,64.3) 120.97,64.35 120.86,64.35 arc(120.72,64.39) 120.61,64.5 120.56,64.58 arc(120.39,64.75) 120.16,64.81 120,64.81 arc(119.81,64.76) 119.67,64.63 119.65,64.58 arc(119.6,64.54) 119.53,64.55 U8.BL5
PCIE_EP_RX_N9: length 79.7
  L16_SIG6 w0.085: U8.BR5 119.53,66.39 arc(119.6,66.38) 119.65,66.42 119.67,66.47 arc(119.81,66.6) 120,66.65 120.16,66.65 arc(120.39,66.59) 120.56,66.42 120.61,66.34 arc(120.72,66.23) 120.86,66.19 120.97,66.19 arc(121.19,66.14) 121.35,65.98 121.43,65.84 arc(121.52,65.73) 121.63,65.66 122.71,65.22 arc(122.87,65.11) 122.99,64.97 123.02,64.91 arc(123.1,64.84) 123.2,64.81 123.48,64.81 127.32,63.22 127.97,62.57 128.52,61.24 128.85,60.76 129.96,59.64 131.45,56.05 131.45,43.87 130.78,40.51 129.5,37.4 127.63,34.61 124.3,31.28 119.93,29.47 111.64,29.47 109.64,28.64 108.72,27.72 108.35,26.82 108.35,19.65 107.8,16.87 107.1,15.82 103.88,12.6 103.5,12.03 103.26,11.47 103.26,11.22 v6(103.49,11)
