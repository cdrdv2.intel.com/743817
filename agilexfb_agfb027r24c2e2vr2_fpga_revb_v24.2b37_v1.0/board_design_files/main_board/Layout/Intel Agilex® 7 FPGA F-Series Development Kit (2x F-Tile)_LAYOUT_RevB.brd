# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_VCC_HSSI_GND: length 5.2
  BOTTOM w0.254: C784.2 164.08,30.56 164.35,30.29 ST14.2 R604.1
FPGA_VCC_HSSI_GNDSENSE: length 121.3
  TOP w0.203: U61.41 177.31,56.21 176.77,56.75 v1(176.66,56.75)
  L05_SIG2 w0.203: v1(176.66,56.75) 176.94,56.47 176.94,56.17 176.02,55.25 176.02,50.06 168.54,42.58 168.54,31.77 163.51,26.75 163.51,25.09 160.32,21.9 148.22,21.9 146.72,23.4 136.2,23.4 136.02,23.57 v1(135.9,23.57)
  BOTTOM w0.254: R6900.2 100.72,46.74 100.36,46.38 100.36,43.89 101.25,43 101.25,40.9 103.13,39.02 103.13,38.59 104.91,36.81 104.91,33.38 106.21,32.08 128.61,32.08 134.07,26.62 134.07,24.56 135.25,23.38 135.71,23.38 v1(135.9,23.57)
FPGA_VCC_HSSI_GXF: length 11.3
  BOTTOM w0.229: v1(102.58,57.79) 102.58,57.51 101.95,56.89 101.62,56.89 101.13,56.39 100.79,56.39 100.33,55.93 99.99,55.93 99.73,55.67 99.73,55.3 99.83,55.21 99.83,54.85 99.73,54.75 99.73,54.38 99.83,54.29 99.83,53.93 99.73,53.83 99.73,53.46 99.83,53.37 99.83,53.01 99.73,52.91 99.73,52.54 99.83,52.45 99.83,52.09 99.73,51.99 99.73,51.62 99.83,51.53 99.83,51.17 99.73,51.07 99.73,50.7 99.83,50.61 99.83,48.91 R6899.1
  vias: v1(74.43,72.6) v1(74.43,71.96) v1(74.43,58.5) v1(74.43,57.74) v1(89.82,64.23) v1(89.82,63.31) v1(89.82,62.39) v1(89.82,61.47) v1(89.82,60.55) v1(89.82,59.63) v1(89.82,58.71) v1(89.82,57.79) v1(89.82,56.87) v1(89.82,55.95) v1(89.82,55.03) v1(89.82,54.11) v1(90.61,64.69) v1(90.61,63.77) v1(90.61,62.85) v1(90.61,61.93) v1(90.61,61.01) v1(90.61,60.09) v1(90.61,59.17) v1(90.61,58.25) v1(90.61,57.33) v1(90.61,56.41) v1(90.61,55.49) v1(90.61,54.57) v1(91.41,62.39) v1(91.41,60.55) v1(91.41,58.71) v1(91.41,56.87) v1(93,71.59) v1(93,70.67) v1(93.8,71.13) v1(93.8,70.21) v1(99.4,62.39) v1(99.4,61.47) v1(99.4,58.71) v1(99.4,57.79) v1(100.93,65.94) v1(100.93,65.15) v1(100.93,58.71) v1(100.93,57.79) v1(102.58,62.39) v1(102.58,61.47) v1(102.58,58.71) v1(110.53,66.99) v1(110.53,65.15) v1(110.53,63.31) v1(110.53,61.47) v1(111.33,70.21) v1(111.33,69.29) v1(111.33,68.37) v1(111.33,67.45) v1(111.33,66.53) v1(111.33,65.61) v1(111.33,64.69) v1(111.33,63.77) v1(111.33,62.85) v1(111.33,61.93) v1(111.33,61.01) v1(111.33,60.09) v1(112.13,69.75) v1(112.13,68.83) v1(112.13,67.91) v1(112.13,66.99) v1(112.13,66.07) v1(112.13,65.15) v1(112.13,64.23) v1(112.13,63.31) v1(112.13,62.39) v1(112.13,61.47) v1(112.13,60.55) v1(112.13,59.63) v1(126.12,59.51) v1(126.25,65.74) v1(126.75,58.88) v1(127.01,65.23) v3(144.91,34.37) v3(144.91,33.35) v3(144.91,32.34) v3(144.91,31.19) v3(144.91,30.05) v3(144.91,28.78) v3(144.91,27.64) v3(144.91,26.11) v3(144.91,24.59) v3(146.57,34.37) v3(146.57,33.35) v3(146.57,32.34) v3(146.57,31.19) v3(146.57,30.05) v3(146.57,28.78) v3(146.57,27.64) v3(146.57,26.11) v3(146.57,24.59) v5(137.29,28.78) v5(137.29,27.64) v5(138.69,28.78) v5(138.69,27.64) v5(140.22,28.78) v5(140.22,27.64) v5(141.87,30.05) v5(141.87,28.78) v5(141.87,27.64) v5(143.39,31.19) v5(143.39,30.05) v5(143.39,28.78) v5(143.39,27.64) v5(143.64,34.37) v5(143.64,33.35) v5(143.64,32.34)
FPGA_VCC_HSSI_GXF_PG: length 6.6
  TOP w0.203: 179.31,57.53 U61.36
  TOP w0.267: 179.31,57.53 177.89,58.95 176.72,58.95 175.65,60.02 v1(175.65,60.09)
FPGA_VCC_HSSI_SENSE: length 122.3
  TOP w0.203: U61.40 177.71,56.59 v1(177.55,56.75)
  L05_SIG2 w0.203: v1(135.9,22.81) 136.02,22.81 136.28,23.07 146.58,23.07 148.08,21.57 160.46,21.57 163.84,24.96 163.84,26.61 168.87,31.63 168.87,42.44 176.35,49.93 176.35,55.11 177.27,56.03 177.27,56.47 v1(177.55,56.75)
  BOTTOM w0.254: v1(135.9,22.81) 135.71,23 135.09,23 133.69,24.41 133.69,26.46 128.45,31.7 106.05,31.7 104.53,33.23 104.53,36.65 102.75,38.43 102.75,38.86 100.87,40.74 100.87,42.85 99.98,43.74 99.98,46.38 99.7,46.66 R6899.2
FPGA_VCC_PG: length 4
  TOP w0.203: 180.51,48.17 U61.11
  TOP w0.267: v1(180.98,46.88) 180.98,47.7 180.51,48.17
FPGA_VCCA_PLL: length 0.8
  L07_SIG3 w0.381: 99.96,72.75 v1(100.18,72.97) 100.26,73.05 100.62,73.05
  vias: v1(95.39,50.89) v1(96.99,72.97) v1(98.58,50.89) v1(101.77,50.89) v1(103.36,72.97) v1(104.96,50.89) v1(106.55,72.97) v3(82.3,36.15) v3(82.3,35.13) v3(82.3,34.11) v3(83.32,36.15) v3(83.32,35.13) v3(83.32,34.11) v3(84.59,36.15) v3(84.72,35.13) v3(84.72,34.11) v3(91.75,38.94) v3(93.1,38.94)
FPGA_VCCCLK_GXF: length 51.9
  L05_SIG2 w0.254: v1(131.01,73.79) 131.96,72.84 131.96,71.58 132.47,71.07 132.47,70.44
  L05_SIG2 w0.279: v1(134.03,60.02) 135.14,61.13 135.14,67.01 132.47,69.67 132.47,70.44
  BOTTOM w0.305: R119.2 R841.2
  BOTTOM w0.381: R841.2 v1(131.01,73.79) ; C1026.2 57.72,96.47 U91.5 ; U12.5 58.73,104.46 59,104.73 R126.2 C107.2
  BOTTOM w0.635: 62.36,85.58 62.36,74.25 62.85,73.76 63.58,73.76 64.5,72.85 64.5,71.3 64.14,70.94 64.14,68.66 64.52,68.28 67.9,68.28 70.06,66.12 73.79,66.12 74.24,65.67
  vias: v1(86.63,65.15) v1(87.43,65.61) v1(114.52,59.17) v1(115.31,59.63)
FPGA_VCCERT_FGT_GXF: length 18.7
  TOP w0.254: R6852.2 57.37,75.17 56.9,75.64 53.98,75.64 53.73,75.39 L10.2
  BOTTOM w0.229: v1(97.79,57.79) 97.79,57.49 97.34,57.05 97.34,56.68 97.43,56.6 97.43,56.22 97.17,55.97 96.84,55.97 96.34,55.47 96.01,55.47 95.55,55.01 95.21,55.01 94.75,54.55 94.41,54.55 93.95,54.09 93.62,54.09 93.16,53.63 92.81,53.63 92.39,53.21 92.38,53.21 92.34,53.17 92.02,53.17 91.77,52.91 91.77,52.54 91.85,52.45 91.85,52.08 91.77,52 91.77,51.62 91.85,51.53 91.85,51.16 91.77,51.08 91.77,50.7 91.85,50.61 91.85,50.24 91.77,50.16 91.77,49.78 91.96,49.59 R6857.2
  vias: v1(70.62,60.91) v1(70.62,60.15) v1(74.43,70.21) v1(74.43,69.67) v1(74.43,68.3) v1(74.43,67.77) v1(74.43,64.72) v1(74.43,63.07) v1(74.43,60.91) v1(74.43,60.15) v1(74.43,56.09) v1(74.43,55.32) v1(75.32,64.85) v1(75.52,63.07) v1(88.22,64.23) v1(88.22,63.31) v1(88.22,62.39) v1(88.22,61.47) v1(88.22,60.55) v1(88.22,59.63) v1(88.22,58.71) v1(88.22,57.79) v1(88.22,56.87) v1(89.02,63.77) v1(89.02,61.93) v1(89.02,60.09) v1(89.02,58.25) v1(89.02,56.41) v1(112.92,67.45) v1(112.92,65.61) v1(112.92,63.77) v1(112.92,61.93) v1(112.92,60.09) v1(113.72,67.91) v1(113.72,66.99) v1(113.72,66.07) v1(113.72,65.15) v1(113.72,64.23) v1(113.72,63.31) v1(113.72,62.39) v1(113.72,61.47) v1(113.72,60.55) v2(82.15,87.71) v2(82.15,86.82) v3(54.82,72.35) v3(54.82,71) v3(54.82,70.06) v3(54.82,68.79) v3(54.82,67.77) v3(54.82,66.63) v3(55.71,72.35) v3(55.71,71) v3(55.71,70.06) v3(55.71,68.79) v3(55.71,67.77) v3(55.71,66.63) v3(56.98,72.35) v3(56.98,71) v3(56.98,70.06) v3(56.98,68.79) v3(56.98,67.77) v3(56.98,66.63) v3(57.87,72.35) v3(57.87,71) v3(57.87,70.06) v3(57.87,68.79) v3(57.87,67.77) v3(57.87,66.63)
FPGA_VCCERT_FGT_GXF_PG: length 5.8
  TOP w0.149: U93.C8 v1(52.7,89.51)
  L05_SIG2 w0.081: v1(52.7,89.51) 53.5,89.51 53.9,89.91 54.66,89.91 55.13,90.38 55.13,92.26 v1(54.69,92.69)
FPGA_VCCFUSEWR_GXF: length 7.2
  TOP w0.254: 206,42.24 204.6,42.24 204.35,41.99 C865.2
  TOP w0.381: C865.2 R666.1
  vias: v1(88.22,65.15) v1(89.02,65.61) v1(112.92,59.17) v1(113.72,59.63) v3(206,41.1) v3(206,39.58) v3(207.14,41.1) v3(207.14,39.58)
FPGA_VCCFUSEWR_GXF_PG: length 2.4
  TOP w0.254: v1(207.14,36.03) U70.4
  BOTTOM w0.254: v1(207.14,36.03) R663.2 R667.1
FPGA_VCCH_FGT_GXF:
  vias: v1(86.63,64.23) v1(86.63,63.31) v1(86.63,62.39) v1(86.63,61.47) v1(86.63,60.55) v1(86.63,59.63) v1(86.63,58.71) v1(86.63,57.79) v1(86.63,56.87) v1(87.43,63.77) v1(87.43,61.93) v1(87.43,60.09) v1(87.43,58.25) v1(87.43,56.41) v1(114.52,67.45) v1(114.52,65.61) v1(114.52,63.77) v1(114.52,61.93) v1(114.52,60.09) v1(115.31,67.91) v1(115.31,66.99) v1(115.31,66.07) v1(115.31,65.15) v1(115.31,64.23) v1(115.31,63.31) v1(115.31,62.39) v1(115.31,61.47) v1(115.31,60.55) v3(96.91,39.96) v3(96.91,38.94) v3(97.92,39.96) v3(97.92,38.94) v3(98.94,39.96) v3(98.94,38.94) v3(99.96,39.96) v3(99.96,38.94)
FPGA_VCCH_PG: length 2.5
  TOP w0.254: v1(63.64,71.83) U80.4
  BOTTOM w0.254: v1(63.64,71.83) R741.2 R644.1
FPGA_VCCH_SDM: length 5.8
  TOP w0.381: R742.2 C977.2 68.92,73.74 69.16,73.5 C1046.2
  L05_SIG2 w0.381: 92.21,70.82 92.21,70.82 v1(92.21,71.13)
  vias: v3(68.21,72.72) v3(68.21,71.96)
FPGA_VCCIO_1V2: length 122.1
  TOP w0.254: 67.06,17.48 66.93,17.61 U78.2 ; 191.52,103.58 191.39,103.45 U77.2
  TOP w0.305: U19.F9 v1(80.99,23.56) ; U16.F1 v1(110.36,23.56) ; U17.F9 v1(105.37,23.56) ; U18.F9 v1(93.18,23.56) ; U18.F1 v1(85.98,23.56) ; U16.F9 v1(117.56,23.56) ; U15.F1 v1(122.56,23.56) ; R6865.2 181.4,85.64 182,85.04 182,81.99 181.74,81.74 L13.2 ; U15.F9 v1(129.76,23.51) ; U17.F1 v1(98.17,23.56)
  TOP w0.381: v2(101.94,97.9) v2(101.94,99.03) J4.206 ; v2(101.94,105.52) v2(101.94,106.65) J5.206 ; R721.2 195.02,104.85 v3(193.81,104.85) ; v2(105.29,86.82) 105.29,87.14 C534.1 105.29,87.52 v2(105.29,87.84) ; v2(94.75,86.82) 94.75,87.14 C537.1 94.75,87.52 v2(94.75,87.84) ; v2(112.66,87.84) 112.66,87.45 112.53,87.33 112.66,87.2 v2(112.66,86.82) ; v2(101.23,87.84) 101.23,87.52 C538.1 101.23,87.14 v2(101.23,86.82)
  BOTTOM w0.203: 8.82,25.96 8.39,25.53 8.39,25.22 ; v1(217.3,99.01) 217.65,99.35 U87.1 ; 219.01,98.63 219.34,98.95 U87.12 ; U90.1 9.76,31.36 ; 8.39,31.44 8.39,31.75 8.82,32.18 ; v1(209.81,99.01) 210.15,99.35 U88.1 ; 211.84,98.41 U88.12 ; U89.1 9.76,25.14
  BOTTOM w0.229: v1(106.55,51.81) 106.55,51.51 106.11,51.07 106.11,50.44 106.31,50.24 106.31,48.91 R6871.2
  BOTTOM w0.254: 128.57,102.73 C166.1 ; C166.1 129.72,102.73 ; C166.1 129.15,102.16 ; 103.07,95.11 C138.1 104.22,95.11 ; C185.1 122.91,102.76 ; C185.1 121.77,102.76 ; C185.1 122.34,102.19 ; 99.29,103.27 R155.2 99.86,102.69 ; 100.56,102.76 C170.1 ; C170.1 101.13,102.19 ; C170.1 101.7,102.76 ; 125.91,98.85 C154.1 126.48,99.42 ; C137.1 107.62,98.85 ; C137.1 106.48,98.85 ; C137.1 107.05,99.42 ; 106.18,94.54 C135.1 ; C135.1 106.76,95.11 ; C135.1 105.61,95.11 ; 126.02,95.14 C155.1 ; C155.1 127.16,95.14 ; C155.1 126.59,94.57 ; 110.72,99.08 C140.1 111.86,99.08 ; C169.1 107.05,107.04 ; C169.1 107.62,106.47 ; C169.1 106.48,106.47 ; 128.99,98.85 C132.1 128.42,99.42 ; 108.18,102.73 C173.1 ; C173.1 108.75,102.16 ; C173.1 109.32,102.73 ; 103.59,98.48 R143.2 103.02,99.05 ; 108.99,99.05 C141.1 110.13,99.05 ; C133.1 125.45,95.14 ; C133.1 124.88,94.57 ; C133.1 124.31,95.14 ; 128.57,95.11 C134.1 ; C134.1 129.15,94.54 ; C134.1 129.72,95.11 ; 100.56,95.14 C136.1 ; C136.1 101.13,94.57 ; C136.1 101.7,95.14 ; 122.11,99.42 C151.1 122.68,98.85 ; 99.29,94.5 R139.2 ; R139.2 99.29,95.65 ; R139.2 99.86,95.07 ; C184.1 125.45,102.76 ; C184.1 124.31,102.76 ; C184.1 124.88,102.19 ; 128.42,107.04 C168.1 128.99,106.47 ; R382.2 65.37,106.21 ; R382.2 R381.2 64.68,104.63 ; R382.2 64.8,105.64 ; 110.13,106.67 C175.1 108.99,106.67 ; C472.1 66.99,104.34 U39.2 ; v1(36.86,66.94) v1(37.78,66.94) 38.42,66.94 39.33,66.04 R786.2 ; 108.75,94.54 C139.1 ; C139.1 108.18,95.11 ; C139.1 109.32,95.11 ; 105.08,98.85 C142.1 104.51,99.42 ; C167.1 124.04,107.04 ; C167.1 124.61,106.47 ; C167.1 123.47,106.47 ; 105.08,106.47 C172.1 104.51,107.04 ; 103.02,106.67 R159.2 103.59,106.1 ; 123.47,98.85 C150.1 ; C150.1 124.61,98.85 ; C150.1 124.04,99.42 ; v1(63.13,40.21) 63.74,39.6 69.69,39.6 R6898.2 ; 104.22,102.73 C174.1 103.07,102.73 ; 106.18,102.16 C171.1 ; C171.1 105.61,102.73 ; C171.1 106.76,102.73 ; C188.1 127.16,102.76 ; C188.1 126.02,102.76 ; C188.1 126.59,102.19 ; C177.1 122.11,107.04 ; C177.1 121.54,106.47 ; C177.1 122.68,106.47 ; 110.72,106.7 C176.1 111.86,106.7 ; 121.77,95.14 C143.1 ; C143.1 122.91,95.14 ; C143.1 122.34,94.57
  BOTTOM w0.305: C1024.1 10.14,31.36 9.76,31.36 ; 9.76,25.14 10.14,25.14 C1022.1 ; 64.68,104.63 64.68,103.18 65.03,102.82 66.05,102.82 66.26,103.04 C472.1
  BOTTOM w0.381: v1(10.42,26.49) 9.89,25.96 8.82,25.96 ; C974.1 74.11,23.43 v1(74.19,23.36) ; v2(121.49,98.9) 121.55,98.85 C151.1 ; v1(217.3,98) 218.38,98 219.01,98.63 ; v1(208.86,103.08) R821.2 ; U22.8 32.31,61.25 v1(32.77,60.78) ; 211.84,98.41 211.43,98 v1(209.81,98) ; 8.82,32.18 9.89,32.18 v1(10.42,32.72) ; U22.1 37.77,65.15 37.78,65.16 v1(37.78,66.94) ; C186.1 126.48,107.02
  vias: v1(10.42,31.7) v1(10.42,25.48) v1(32.84,25.35) v1(32.9,55.07) v1(33.92,55.07) v1(34.04,66.94) v1(35.06,55.07) v1(35.76,75.39) v1(35.76,70.56) v1(37.79,74.12) v1(62.75,24.72) v1(63.89,27.13) v1(63.89,25.99) v1(65.16,27.13) v1(65.16,26.11) v1(66.43,27.13) v1(70.24,25.73) v1(71.25,26.37) v1(71.25,25.35) v1(71.25,24.34) v1(72.4,24.34) v1(74.19,27.36) v1(74.19,25.76) v1(74.19,21.76) v1(74.19,18.56) v1(74.99,26.56) v1(74.99,24.16) v1(78.99,25.76) v1(79.79,26.56) v1(79.79,24.16) v1(80.59,25.76) v1(80.59,20.96) v1(80.59,17.76) v1(83.2,18.56) v1(83.25,22.56) v1(84.15,38.05) v1(85.18,38.06) v1(85.58,22.56) v1(86.38,27.36) v1(86.38,25.76) v1(86.38,21.76) v1(86.38,18.56) v1(87.18,26.56) v1(87.18,24.16) v1(88.78,24.16) v1(90.38,26.56) v1(90.38,24.16) v1(91.18,25.76) v1(91.98,26.56) v1(91.98,24.16) v1(92.21,70.21) v1(92.78,25.76) v1(92.78,20.96) v1(92.78,17.76) v1(93.58,20.16) v1(93.8,52.73) v1(93.8,51.81) v1(95.39,52.73) v1(95.39,51.81) v1(96.99,72.05) v1(96.99,71.13) v1(97.77,22.56) v1(98.58,72.05) v1(98.58,71.13) v1(98.57,27.36) v1(98.57,25.76) v1(98.57,21.76) v1(98.57,18.56) v1(99.39,102.68) v1(99.39,95.06) v1(99.37,26.56) v1(99.37,24.16) v1(100.18,72.05) v1(100.18,71.13) v1(100.97,24.16) v1(101.77,72.05) v1(101.77,71.13) v1(102.57,26.56) v1(102.57,24.16) v1(103.36,72.05) v1(103.36,71.13) v1(103.37,25.76) v1(104.17,26.56) v1(104.17,24.16) v1(104.96,72.05) v1(104.96,71.13) v1(104.96,52.73) v1(104.96,51.81) v1(104.97,25.76) v1(104.97,20.96) v1(104.97,17.76) v1(105.77,20.16) v1(106.55,72.05) v1(106.55,71.13) v1(106.55,52.73) v1(108.14,72.05) v1(108.14,71.13) v1(109.96,22.56) v1(110.76,27.36) v1(110.76,25.76) v1(110.76,21.76) v1(110.76,18.56) v1(111.29,102.3) v1(111.29,94.68) v1(111.56,26.56) v1(111.56,24.16) v1(113.16,24.16) v1(113.84,106.52) v1(113.83,102.31) v1(113.84,98.9) v1(113.83,94.69) v1(114.76,26.56) v1(114.76,24.16) v1(115.56,25.76) v1(116.36,26.56) v1(116.36,24.16) v1(117.16,25.76) v1(117.16,20.96) v1(117.16,17.76) v1(117.96,20.16) v1(122.16,22.56) v1(122.96,27.36) v1(122.96,25.76) v1(122.96,21.76) v1(122.96,18.56) v1(123.76,26.56) v1(123.76,24.16) v1(125.36,24.16) v1(126.96,26.56) v1(126.96,24.16) v1(127.76,25.76) v1(128.56,26.56) v1(128.56,24.16) v1(129.36,25.76) v1(129.36,20.96) v1(129.36,17.76) v1(130.16,20.16) v1(131.22,98.01) v1(208.8,101.04) v1(208.8,100.03) v2(96.84,96) v2(96.91,97.87) v2(100.24,106.9) v2(100.24,99.28) v2(101.04,102.71) v2(101.04,95.09) v2(101.99,37.16) v2(103,37.16) v2(103.64,102.53) v2(103.64,94.91) v2(104.49,106.52) v2(104.49,98.9) v2(106.19,102.68) v2(106.19,95.06) v2(107.04,106.52) v2(107.04,98.9) v2(108.74,102.68) v2(108.74,95.06) v2(109.59,106.52) v2(109.59,98.9) v2(111.29,106.52) v2(111.29,98.9) v2(121.49,106.52) v2(122.34,102.68) v2(122.34,95.06) v2(124.04,106.52) v2(124.04,98.9) v2(124.89,102.68) v2(124.89,95.06) v2(126.59,106.52) v2(126.59,102.68) v2(126.59,98.9) v2(126.59,95.06) v2(128.29,106.52) v2(128.29,98.9) v2(129.14,102.68) v2(129.14,95.06) v2(129.99,106.52) v2(129.99,98.9) v2(130.76,102.86) v2(130.76,95.24) v2(132.54,106.52) v2(132.54,102.82) v2(132.54,98.9) v2(132.54,95.2) v3(67.32,16.03) v3(67.32,15.19) v3(68.08,16.03) v3(68.08,15.19) v3(171.08,86.74) v3(171.08,85.47) v3(171.08,84.2) v3(171.08,82.93) v3(171.08,81.66) v3(172.35,86.74) v3(172.35,85.47) v3(172.35,84.2) v3(172.35,82.93) v3(172.35,81.66) v3(173.62,86.74) v3(173.62,85.47) v3(173.62,84.2) v3(173.62,82.93) v3(173.62,81.66) v3(174.89,86.74) v3(174.89,85.47) v3(174.89,84.2) v3(174.89,82.93) v3(174.89,81.66) v3(176.28,86.74) v3(176.28,85.47) v3(176.28,84.2) v3(176.28,82.93) v3(176.28,81.66) v3(176.28,80.39) v3(177.55,86.74) v3(177.55,85.47) v3(177.55,84.2) v3(177.55,82.93) v3(177.55,81.66) v3(177.55,80.39) v3(178.82,86.74) v3(178.82,85.47) v3(178.82,84.2) v3(178.82,82.93) v3(178.82,81.66) v3(178.82,80.39) v3(192.84,104.85) v3(192.84,104.09) v3(193.81,104.09)
FPGA_VCCIO_1V2_PG: length 58.2
  TOP w0.149: U96.F8 v1(195.66,75.4)
  L14_SIG5 w0.081: v1(195.66,75.4) 196.06,75.01 196.7,75.01 196.86,75.16 196.86,76.51 196.76,76.61 196.2,76.61 196.07,76.74 194.75,76.74 193.89,75.87 193.89,73 195.04,71.85 195.98,71.85 197.75,70.08 197.75,65.48 199.78,63.45 199.78,52.28 200.81,51.24 200.81,43.61 199.42,42.22 199.42,39.47 199.93,38.97 200.16,38.97 200.49,38.64 200.49,32.49 199.63,31.63 198.37,31.63 v1(197.42,32.02)
FPGA_VCCIO_SDM_HPS: length 16.9
  TOP w0.254: R706.2 C920.2 194.57,41.99 194.83,42.24 196.22,42.24 ; v1(194.7,65.61) 194.44,65.35 U36.2
  TOP w0.381: C101.2 73.07,79.74 73.07,78.05 U10.4
  BOTTOM w0.254: R366.2 v1(192.67,64.02) ; v1(208.8,20.27) 208.47,20.6 R205.2
  BOTTOM w0.381: v1(204.1,29.29) 204.1,28.59 R207.2 ; v1(194.7,65.61) C466.1 R6896.2
  vias: v1(2.1,50.62) v1(2.1,46.18) v1(2.1,42.24) v1(3.88,41.35) v1(4.2,53.48) v1(5.66,41.35) v1(10.29,53.48) v1(11.69,42.43) v1(13.15,54.69) v1(13.15,52.66) v1(13.15,48.72) v1(13.15,44.66) v1(14.1,32.08) v1(14.1,31.19) v1(14.17,54.69) v1(14.17,52.66) v1(14.29,49.74) v1(14.29,48.72) v1(14.29,46.69) v1(14.29,45.67) v1(15.12,32.08) v1(15.12,31.19) v1(19.57,21.22) v1(20.58,21.22) v1(21.6,21.22) v1(23.63,21.22) v1(25.53,34.81) v1(25.6,52.78) v1(25.6,51.89) v1(25.6,43.39) v1(26.42,52.78) v1(26.42,51.89) v1(70.72,77.8) v1(72.71,80.22) v1(90.61,72.97) v1(90.61,72.05) v1(93.8,72.05) v1(109.74,53.65) v1(109.74,52.73) v1(109.74,51.81) v1(209.86,29.42) v1(244.1,42.24) v1(250.2,53.67) v1(250.2,52.4) v1(250.2,51.13) v1(250.2,49.86) v1(250.2,46.05) v1(250.2,44.78) v1(250.2,43.51) v2(217.69,68.98) v3(196.22,41.1) v3(196.22,39.58) v3(197.37,41.1) v3(197.37,39.58)
FPGA_VCCIO_SDM_HPS_PG: length 2.4
  TOP w0.254: v1(197.37,36.03) U74.4
  BOTTOM w0.254: v1(197.37,36.03) R704.2 R711.1
FPGA_VCCLSENSE: length 33.1
  L12_SIG4 w0.203: v1(108.14,61.93) 108.44,62.22 108.44,62.54 108.7,62.8 108.82,62.85 109.05,62.85 109.28,62.98 109.42,63.23 109.56,63.31 109.85,63.31 110.08,63.44 110.21,63.67 110.38,63.77 110.66,63.77 110.87,63.88 111,64.11 111.2,64.23 111.44,64.23 111.67,64.36 111.77,64.54 112.04,64.69 112.24,64.69 112.47,64.82 112.61,65.06 112.76,65.15 113.05,65.15 113.26,65.27 113.39,65.5 113.58,65.61 113.84,65.61 114.06,65.73 114.18,65.95 114.39,66.07 114.66,66.07 114.84,66.18 114.96,66.37 115.23,66.53 115.45,66.53 115.64,66.64 115.76,66.83 116.02,66.99 116.22,66.99 116.45,67.12 116.54,67.27 116.54,67.65 116.44,67.74 116.44,68.05 116.75,68.35 117.05,68.35 117.22,68.46 117.37,68.71 117.54,68.81 117.77,68.81 117.98,68.9 118.37,69.29 118.68,69.29 119.11,68.86 119.49,68.86 119.9,69.27 120.28,69.27 120.73,69.73 121.06,69.73 121.5,69.29 123.46,69.29 123.76,69.59 131.72,69.59 133.69,71.56 133.69,72.12 133.36,72.44 132.94,72.44 v1(132.66,72.72)
  BOTTOM w0.254: R533.1 v1(132.66,72.72)
FPGA_VCCPLL:
  vias: v1(71.13,73.56) v1(71.89,73.56) v1(90.61,70.21) v1(91.41,71.59) v1(110.53,54.11)
FPGA_VCCPLLDIG_HPS:
  vias: v1(110.53,53.19) v2(83.32,37.15)
FPGA_VCCPLLDIG_SDM:
  vias: v1(92.21,72.05)
FPGA_VCCPT: length 10
  TOP w0.254: R6862.2 182.89,71.61 182.89,74.32 182.71,74.5 L12.2 ; v1(211.59,36.03) U70.7
  BOTTOM w0.229: v1(96.19,53.19) 96.55,52.83 96.55,52.54 96.65,52.44 96.65,52.1 96.55,51.99 96.55,51.62 96.65,51.52 96.65,51.18 96.55,51.07 96.55,50.7 96.65,50.6 96.65,48.97 R6869.2
  vias: v1(69.48,75.95) v1(69.63,76.76) v1(97.79,70.67) v1(99.38,53.19) v1(100.97,70.67) v1(102.57,53.19) v1(104.16,70.67) v1(105.75,53.19) v1(107.35,70.67) v1(199.65,30.3) v1(200.29,30.3) v1(201.68,30.3) v1(202.7,30.3) v1(217.37,19.38) v1(218.45,20.27) v1(218.51,19.38) v2(71.76,51.01) v2(72.14,50.5) v2(72.52,51.01) v2(98.18,35.51) v2(99.96,35.51) v2(109.23,37.16) v3(98.18,34.45) v3(98.18,33.48) v3(99.07,34.45) v3(99.07,33.48) v3(99.96,34.45) v3(99.96,33.48) v3(171.08,73.03) v3(171.08,71.76) v3(171.08,70.23) v3(171.08,68.96) v3(172.35,73.03) v3(172.35,71.76) v3(172.35,70.23) v3(172.35,68.96) v3(173.62,73.03) v3(173.62,71.76) v3(173.62,70.23) v3(173.62,68.96) v3(174.89,73.03) v3(174.89,71.76) v3(174.89,70.23) v3(174.89,68.96) v3(176.16,73.03) v3(176.16,71.76) v3(176.16,70.23) v3(176.16,68.96) v3(177.55,73.03) v3(177.55,71.76) v3(177.55,70.23) v3(177.55,68.96) v3(178.82,73.03) v3(178.82,71.76) v3(178.82,70.23) v3(178.82,68.96) v3(211.59,41.61) v3(211.59,40.59) v3(211.59,39.58) v3(212.61,41.61) v3(212.61,40.59) v3(212.61,39.58)
FPGA_VCCPT_PG: length 5
  TOP w0.149: U96.C8 v1(197.26,75.4)
  L12_SIG4 w0.089: v1(197.26,75.4) 197.26,74.82 197.89,74.2 198.29,74.2 199.32,73.17 v1(200.41,73.17)
FPGA_VCCR_CORE: length 16.9
  TOP w0.254: R6855.2 43.23,75.17 43.7,75.64 46.62,75.64 46.87,75.39 L11.2
  L12_SIG4 w0.305: 102.22,69.75 102.56,69.75 v1(102.57,69.75) 102.58,69.75 102.85,69.47 ; 106.26,69.73 106.23,69.75 v1(105.75,69.75) 105.74,69.75 105.47,69.47
  BOTTOM w0.229: v1(107.35,54.11) 106.38,54.11 105.94,53.67 105.57,53.67 105.15,54.09 104.77,54.09 104.33,53.66 104,53.66 103.55,53.21 103.22,53.21 102.88,52.87 102.88,52.58 103.01,52.45 103.01,52.08 102.88,51.95 102.88,51.66 103.01,51.53 103.01,51.16 102.88,51.03 102.88,50.37 103.01,50.24 103.01,48.79 R6859.2
  vias: v1(71.44,68.4) v1(94.6,54.11) v1(96.19,69.75) v1(97.79,54.11) v1(99.38,69.75) v1(100.97,54.11) v1(104.16,54.11) v1(108.94,69.75) v3(44.03,72.35) v3(44.03,71) v3(44.03,70.06) v3(44.03,68.79) v3(44.03,67.77) v3(44.03,66.63) v3(44.91,72.35) v3(44.91,71) v3(44.91,70.06) v3(44.91,68.79) v3(44.91,67.77) v3(44.91,66.63) v3(46.44,72.35) v3(46.44,71) v3(46.44,70.06) v3(46.44,68.79) v3(46.44,67.77) v3(46.44,66.63) v3(47.33,72.35) v3(47.33,67.77) v3(47.33,66.63) v3(79,32.46) v3(79,31.45) v3(79,30.43) v3(80.14,32.46) v3(80.14,31.45) v3(80.14,30.43) v3(81.29,32.46) v3(81.29,31.45) v3(81.29,30.43)
FPGA_VCCR_CORE_PG: length 251.6
  TOP w0.149: U93.F8 v1(52.7,87.91)
  L07_SIG3 w0.089: v1(46.24,60.28) 48.59,57.92 48.59,52.85 51.44,50 51.44,45.04 v1(52.2,44.27)
  L12_SIG4 w0.089: v1(52.7,87.91) 51.82,87.04 51.82,82.88 50.55,81.61 47.33,81.61 45.85,80.14 44.63,80.14 43.01,78.51 43.01,75.72 41.36,74.07 41.36,69.88 41.16,69.67 41.16,66.65 40.8,66.3 40.8,63.12 42.25,61.67 43.44,61.67 44.84,60.28 v1(46.24,60.28)
  L16_SIG6 w0.081: v1(198.64,30.3) 196.22,27.89 196.22,26.62 192.26,22.66 192.26,19.1 188.86,15.7 138.18,15.7 133.61,11.13 129.5,11.13 127.28,8.92 62.09,8.92 60.85,10.16 60.42,10.16 58.55,12.02 58.55,14.3 53.09,19.76 52.71,19.76 50.93,21.54 50.93,22.18 47.76,25.35 47.76,39.83 v1(52.2,44.27)
  BOTTOM w0.149: v1(198.64,30.3) 198.64,31.05 198.38,31.31 R712.1
FX2_D_N: length 14.6
  TOP w0.102: v4(12.09,92.17) 12.34,92.43 12.76,92.43 12.9,92.29 U49.9 ; J10.2 5.13,96.39 5.26,96.52 5.87,96.52 5.98,96.41 U48.2 6.64,96.18 6.86,96.18 v4(7.12,96.43)
  L03_SIG1 w0.079: v4(7.12,96.43) 6.96,96.27 6.54,96.27 6.07,95.8 6.07,93.73 7.37,92.43 11.83,92.43 v4(12.09,92.17)
FX2_D_P: length 14.6
  TOP w0.102: J10.3 5.19,95.74 5.32,95.6 5.87,95.6 5.98,95.71 U48.1 6.64,95.95 6.86,95.95 v4(7.12,95.69) ; U49.8 12.91,92.79 12.78,92.66 12.34,92.66 v4(12.09,92.91)
  L03_SIG1 w0.079: v4(12.09,92.91) 11.83,92.66 8.26,92.66 8.12,92.8 7.86,92.8 7.72,92.66 7.46,92.66 7.08,93.04 7.08,93.25 6.9,93.43 6.69,93.43 6.3,93.82 6.3,94.08 6.44,94.23 6.44,94.48 6.3,94.63 6.3,94.88 6.44,95.03 6.44,95.28 6.3,95.43 6.3,95.71 6.63,96.04 7.06,96.04 7.12,95.98 v4(7.12,95.69)
FX2_FLAGA: length 34.6
  TOP w0.149: U49.29 v1(22.56,89.79)
  L12_SIG4 w0.089: v1(22.56,89.79) 22.56,90.16 22.99,90.59 22.99,90.76 23.12,90.88 23.29,90.88 23.38,90.8 23.38,90.59 23.46,90.5 23.67,90.5 23.76,90.59 23.76,91.18 23.84,91.26 24.05,91.26 24.14,91.18 24.14,90.25 24.01,90.12 23.12,90.12 22.99,89.99 22.99,89.87 23.12,89.74 23.38,89.74 23.5,89.61 23.5,89.49 23.38,89.36 22.13,89.36 22,89.23 22,89.11 22.13,88.98 23.48,88.98 23.6,88.85 23.6,88.24 23.45,88.09 22.57,88.09 22.49,88.18 22.49,88.47 22.36,88.6 22.11,88.6 21.98,88.47 21.98,87.84 22.14,87.67 23.5,87.67 23.6,87.57 23.6,87.43 23.5,87.33 21.82,87.33 21.72,87.23 21.72,86.57 21.85,86.44 21.98,86.44 22.11,86.57 22.11,86.86 22.23,86.99 23.5,86.99 23.6,86.88 23.6,86.74 23.5,86.64 22.59,86.64 22.49,86.54 22.49,86.4 22.59,86.3 23.5,86.3 23.6,86.2 23.6,86.03 23.5,85.93 22.83,85.93 22.74,85.84 22.74,85.21 22.84,85.11 23.4,85.11 23.5,85.01 23.5,84.87 23.4,84.77 22.84,84.77 22.74,84.67 22.74,84.53 22.84,84.43 23.4,84.43 23.5,84.33 23.5,84.18 23.4,84.08 22.84,84.08 22.74,83.98 22.74,83.55 22.34,83.15 22.08,83.15 21.68,82.75 21.68,82.45 21.38,82.15 20.98,82.15 20.68,81.85 20.68,81.46 20.18,80.96 v1(20.18,80.65)
FX2_FLAGB: length 34.1
  TOP w0.149: U49.30 v1(21.8,90.29)
  L12_SIG4 w0.089: v1(19.18,81.65) 19.68,82.15 20.49,82.15 20.68,82.34 20.68,82.98 20.85,83.15 21.49,83.15 21.72,83.39 21.72,83.64 21.34,84.03 21.34,84.27 21.72,84.65 21.72,84.91 21.6,85.04 21.6,85.42 21.8,85.63 22.24,85.63 22.36,85.75 22.36,85.96 22.26,86.06 21.47,86.06 21.34,86.18 21.34,87.56 21.62,87.84 21.62,89.39 21.85,89.61 21.85,89.74 21.72,89.87 21.34,89.87 20.99,90.22 20.99,91.37 20.33,92.03 20.33,94.78 20.39,94.84 20.39,95.65 19.69,96.34 18,96.34 17.91,96.43 17.91,96.76 18,96.85 19.95,96.85 20.73,96.07 20.73,94.57 20.96,94.34 20.96,94.06 20.73,93.83 20.73,93.65 20.96,93.42 20.96,93.3 20.71,93.04 20.71,92.92 20.84,92.79 21.22,92.79 21.34,92.66 21.34,92.53 21.22,92.41 20.84,92.41 20.71,92.28 20.71,92.15 20.84,92.03 21.34,92.03 21.47,91.9 21.47,91.65 21.34,91.52 21.34,90.38 21.43,90.29 v1(21.8,90.29)
FX2_FLAGC: length 34.2
  TOP w0.149: U49.31 v1(22.56,90.79)
  L12_SIG4 w0.089: v1(22.56,90.79) 22.27,90.79 22.17,90.89 22.17,91.08 22.35,91.26 22.74,91.26 22.99,91.52 22.99,91.77 23.12,91.9 23.5,91.9 23.76,91.65 24.39,91.65 24.52,91.52 24.52,89.74 23.96,89.18 23.96,88.09 24.09,87.96 24.25,87.96 24.34,88.05 24.34,88.93 24.65,89.23 25.28,89.23 25.41,89.11 25.41,88.94 25.31,88.84 24.82,88.84 24.72,88.74 24.72,88.06 24.82,87.96 24.96,87.96 25.06,88.06 25.06,88.4 25.16,88.5 25.31,88.5 25.41,88.4 25.41,87.21 25.31,87.11 25.16,87.11 25.06,87.21 25.06,87.48 24.96,87.58 24.82,87.58 24.72,87.48 24.72,86.87 24.82,86.77 25.31,86.77 25.41,86.67 25.41,86.53 25.19,86.31 24.52,86.31 24.34,86.49 24.34,87.33 24.21,87.45 24.09,87.45 23.96,87.33 23.96,85.88 23.76,85.68 23.76,85.3 24.01,85.04 24.52,85.04 24.77,84.79 24.77,84.41 24.52,84.15 23.88,84.15 23.76,84.03 23.76,83.55 23.36,83.15 22.98,83.15 22.68,82.85 22.68,82.46 22.37,82.15 21.98,82.15 21.68,81.85 21.68,81.46 21.37,81.15 20.98,81.15 20.68,80.85 20.68,80.5 21.03,80.15 21.53,80.15 22.17,79.52 22.17,79.39 22.04,79.26 21.91,79.26 21.53,79.65 v1(21.18,79.65)
FX2_PA0: length 36.1
  TOP w0.149: U49.33 v1(22.56,91.79)
  L07_SIG3 w0.089: v1(19.18,80.65) 19.18,80.27 19.68,79.76 19.68,79.33 19.91,79.11 20.44,79.11 20.68,78.86 20.68,78.49 21.02,78.15 21.44,78.15 21.68,77.91 21.68,77.41 21.92,77.17 23.38,77.17 23.68,77.47 23.68,82.83 23.38,83.14 22.81,83.14 22.56,83.39 22.56,85.86 22.36,86.06 21.85,86.06 21.72,86.18 21.72,86.44 21.85,86.57 22.87,86.57 22.99,86.44 22.99,86.06 23.12,85.93 23.38,85.93 23.5,86.06 23.5,86.95 23.37,87.07 21.85,87.07 21.72,87.2 21.72,87.45 21.85,87.58 23.38,87.58 23.5,87.71 23.5,87.96 23.38,88.09 22.87,88.09 22.74,88.22 22.74,89.23 22.61,89.36 22.36,89.36 22.23,89.23 22.23,88.22 22.11,88.09 21.85,88.09 21.72,88.22 21.72,89.61 22.23,90.12 22.23,90.5 21.98,90.76 21.6,90.76 21.34,91.01 21.34,91.52 21.62,91.79 v1(22.56,91.79)
FX2_PA1: length 34.9
  TOP w0.149: U49.34 v1(21.8,92.29)
  L07_SIG3 w0.089: v1(21.8,92.29) 20.58,92.29 20.45,92.42 20.45,92.66 20.58,92.79 21.29,92.79 21.42,92.92 21.42,93.8 21.29,93.93 21.09,93.93 20.96,93.8 20.96,93.42 20.84,93.3 20.58,93.3 20.45,93.42 20.45,95.07 20.33,95.2 20.07,95.2 19.95,95.07 19.95,93.17 19.69,92.92 19.69,92.66 19.95,92.41 19.95,91.9 20.07,91.77 20.84,91.77 20.96,91.65 20.96,91.39 20.84,91.26 20.07,91.26 19.95,91.14 19.95,89.87 20.07,89.74 20.71,89.74 20.84,89.87 20.84,90.07 20.71,90.2 20.45,90.2 20.33,90.32 20.33,90.5 20.45,90.63 21.22,90.63 21.34,90.5 21.34,85.93 21.6,85.68 21.6,79.2 21.72,79.07 21.98,79.07 22.11,79.2 22.11,80.09 22.23,80.22 22.55,80.22 22.68,80.09 22.68,77.87 22.89,77.65 v1(23.18,77.65)
FX2_PA2: length 34.7
  TOP w0.149: U49.35 v1(22.56,92.79)
  L07_SIG3 w0.089: v1(22.56,92.79) 22.89,92.79 23.71,91.98 23.71,91.44 23.88,91.26 24.39,91.26 24.52,91.14 24.52,90.88 24.39,90.76 23.63,90.76 23.5,90.63 23.5,90.38 23.63,90.25 24.39,90.25 24.52,90.12 24.52,89.49 24.39,89.36 24.01,89.36 23.88,89.23 23.88,89.11 24.01,88.98 24.77,88.98 25.03,89.23 25.66,89.23 25.92,88.98 25.92,88.22 25.41,87.71 25.41,86.82 25.53,86.69 25.79,86.69 25.92,86.82 25.92,87.58 26.04,87.71 26.3,87.71 26.42,87.58 26.42,86.31 25.66,85.55 25.66,77.44 25.38,77.15 24.98,77.15 24.68,76.85 24.68,76.45 24.38,76.15 21.98,76.15 21.68,76.45 21.68,76.8 21.37,77.12 20.94,77.12 20.76,77.29 20.76,77.79 20.36,78.18 19.71,78.18 v1(19.18,77.65)
FX2_PA3: length 34.9
  TOP w0.149: U49.36 v1(21.8,93.29)
  L07_SIG3 w0.089: v1(21.8,93.29) 21.8,92.87 22.36,92.3 22.85,92.3 23.12,92.03 23.12,91.72 22.79,91.39 22.79,91.21 23.12,90.88 23.12,90.63 22.87,90.38 22.87,90.12 22.99,89.99 23.37,89.99 23.5,89.87 23.5,89.61 23.37,89.49 23.25,89.49 23.12,89.36 23.12,89.11 23.25,88.98 23.5,88.98 23.88,88.6 24.9,88.6 25.15,88.85 25.41,88.85 25.53,88.72 25.53,88.34 25.41,88.22 24.01,88.22 23.88,88.09 23.88,87.96 24.01,87.84 24.77,87.84 24.9,87.71 24.9,87.45 24.77,87.33 24.01,87.33 23.88,87.2 23.88,86.47 24.03,86.31 24.26,86.31 24.39,86.44 24.39,86.82 24.52,86.95 24.7,86.95 24.82,86.82 24.82,86.44 24.95,86.31 25.53,86.31 25.66,86.18 25.66,86.06 25.53,85.93 24.8,85.93 24.67,85.8 24.67,85.4 25.28,84.79 25.28,84.11 25.19,84.03 24.9,84.03 24.77,84.15 24.77,84.66 24.39,85.04 23.88,85.04 23.72,84.88 23.72,84.62 23.63,84.53 23.46,84.53 23.38,84.62 23.38,84.95 23.29,85.04 23.08,85.04 22.99,84.95 22.99,84.28 23.12,84.15 24.26,84.15 24.67,83.75 24.67,77.55 24.18,77.05 v1(24.18,76.65)
FX2_PA4: length 35.5
  TOP w0.149: U49.37 v1(22.44,93.79)
  L07_SIG3 w0.089: v1(22.44,93.79) 22.93,93.79 24.23,92.5 24.68,92.5 24.9,92.28 24.9,91.9 25.03,91.77 25.41,91.77 25.79,91.39 25.79,90.12 26.55,89.36 26.93,89.36 27.44,88.85 27.44,86.95 27.67,86.72 27.67,77.44 27.38,77.15 26.93,77.15 26.68,76.9 26.68,76.45 26.35,76.13 25.93,76.13 25.68,75.87 25.68,75.45 25.35,75.13 25,75.13 24.68,74.8 24.68,74.55 24.28,74.15 21.98,74.15 21.68,74.45 21.68,74.95 21.48,75.15 20.98,75.15 20.58,75.55 20.58,75.95 20.38,76.15 19.98,76.15 19.69,76.44 19.69,76.91 19.41,77.19 18.98,77.19 18.68,77.5 18.68,78.15 v1(19.18,78.65)
FX2_PA5: length 34.7
  TOP w0.149: v1(22.44,94.79) 21.93,94.29 U49.38
  L07_SIG3 w0.089: v1(22.44,94.79) 21.97,95.26 21.02,95.26 20.84,95.08 20.84,94.57 21.09,94.31 21.6,94.31 21.86,94.05 21.86,93.81 22.4,93.27 22.93,93.27 24.14,92.06 24.14,91.77 24.26,91.65 24.56,91.65 24.87,91.33 24.87,89.89 25.03,89.74 25.66,89.74 26.42,88.98 26.42,88.42 26.93,87.91 26.93,85.8 26.68,85.55 26.68,77.45 26.38,77.15 25.88,77.15 25.68,76.95 25.68,76.45 25.38,76.15 24.98,76.15 24.68,75.85 24.68,75.35 24.46,75.14 21.99,75.14 21.68,75.45 21.68,75.85 21.38,76.15 20.91,76.15 20.71,76.35 20.71,76.69 20.18,77.22 v1(20.18,77.65)
FX2_PA6: length 37
  TOP w0.149: U49.39 v1(21.67,94.79)
  L07_SIG3 w0.089: v1(19.18,76.65) 19.18,76.27 19.68,75.77 19.68,75.35 19.88,75.15 20.48,75.15 20.68,74.95 20.68,74.43 20.96,74.15 21.38,74.15 21.68,73.85 21.68,73.35 21.88,73.15 24.38,73.15 24.68,73.45 24.68,73.85 24.98,74.15 25.26,74.15 25.68,74.57 25.68,74.9 25.93,75.15 26.26,75.15 26.62,75.51 26.62,75.89 26.88,76.15 27.26,76.15 27.68,76.57 27.68,76.9 27.93,77.15 28.32,77.15 28.68,77.51 28.68,84.61 29.25,85.19 29.25,85.78 27.83,87.2 27.83,89.09 26.8,90.12 26.8,91.01 25.78,92.03 25.78,92.4 24.64,93.55 23.73,93.55 22.99,94.29 22.18,94.29 v1(21.67,94.79)
FX2_PA7: length 35.6
  TOP w0.149: U49.40 21.56,95.29 21.85,95.58 v1(21.85,95.84)
  L07_SIG3 w0.089: v1(21.18,78.65) 21.18,79.02 20.71,79.49 20.71,85.68 20.96,85.93 20.96,86.11 20.84,86.24 20.16,86.24 20.07,86.33 20.07,86.57 20.2,86.69 20.84,86.69 20.96,86.82 20.96,87.58 20.84,87.71 20.66,87.71 20.53,87.58 20.53,87.2 20.4,87.07 20.2,87.07 20.07,87.2 20.07,87.96 20.33,88.22 20.84,88.22 20.96,88.34 20.96,88.6 20.84,88.72 20.45,88.72 20.33,88.85 20.33,89.23 20.2,89.36 19.95,89.36 19.82,89.23 19.82,88.98 19.69,88.85 19.44,88.85 19.31,88.98 19.31,89.36 19.56,89.61 19.56,90.44 19.44,90.57 19.25,90.57 19.06,90.38 19.06,89.87 18.93,89.74 18.68,89.74 18.55,89.87 18.55,90.5 18.8,90.76 18.8,91.21 18.93,91.34 19.31,91.34 19.44,91.47 19.44,91.65 19.31,91.77 18.96,91.77 18.8,91.93 18.8,92.15 19.18,92.53 19.18,92.79 18.83,93.14 18.83,93.32 19.18,93.68 19.18,93.93 18.8,94.31 18.8,94.56 18.94,94.69 19.18,94.69 19.31,94.82 19.31,95.07 19.18,95.2 18.93,95.2 18.8,95.33 18.8,96.22 18.93,96.34 19.18,96.34 19.31,96.22 19.31,95.84 19.44,95.71 19.57,95.71 19.69,95.84 19.69,96.22 19.82,96.34 20.02,96.34 20.15,96.22 20.15,95.84 20.27,95.71 20.45,95.71 20.58,95.84 20.58,96.22 20.71,96.34 20.96,96.34 21.09,96.22 21.09,95.96 21.22,95.84 v1(21.85,95.84)
FX2_PB0: length 35
  TOP w0.149: v1(16.39,86.82) 15.35,87.86 U49.18
  L12_SIG4 w0.089: v1(20.18,76.65) 19.78,76.65 19.28,77.15 17.93,77.15 17.79,77.29 17.79,77.68 17.66,77.8 16.35,77.8 16.26,77.71 16.26,77.51 16.35,77.42 17.03,77.42 17.15,77.29 17.15,77.17 17.03,77.04 14.99,77.04 14.87,77.17 14.87,77.29 14.99,77.42 15.67,77.42 15.76,77.51 15.76,77.71 15.67,77.8 14.41,77.8 14.29,77.93 14.29,78.64 13.98,78.95 13.98,80 13.89,80.09 13.68,80.09 13.6,80 13.6,79.54 13.51,79.45 12.71,79.45 12.58,79.58 12.58,79.71 12.71,79.83 13.13,79.83 13.22,79.92 13.22,80.13 13.13,80.22 12.71,80.22 12.58,80.34 12.58,80.47 12.71,80.6 13.22,80.6 13.72,81.11 13.72,81.23 13.6,81.36 13.47,81.36 13.09,80.98 12.71,80.98 12.58,81.1 12.58,82.63 12.83,82.88 13.51,82.88 13.6,82.79 13.6,82.59 13.51,82.5 13.22,82.5 13.09,82.37 13.09,82.25 13.22,82.12 13.89,82.12 13.98,82.21 13.98,83.29 14.08,83.39 14.25,83.39 14.36,83.28 14.36,82.86 14.46,82.76 14.64,82.76 14.74,82.86 14.74,83.9 14.87,84.03 15.37,84.03 15.5,84.15 15.5,84.66 16.39,85.55 v1(16.39,86.82)
FX2_PB1: length 34
  TOP w0.149: U49.19 v1(15.85,88.34)
  L12_SIG4 w0.089: v1(19.18,75.65) 19.18,75.26 19.06,75.14 17.91,75.14 17.79,75.01 17.79,74.63 17.66,74.5 16.77,74.5 16.64,74.37 16.64,74.25 16.77,74.12 18.55,74.12 18.68,73.99 18.68,73.61 18.04,72.98 16.22,72.98 16.14,73.07 16.14,73.27 16.22,73.36 17.66,73.36 17.79,73.48 17.79,73.61 17.66,73.74 16.39,73.74 16.29,73.84 16.29,74.6 15.63,75.26 15.12,75.26 14.23,76.15 14.23,76.66 11.82,79.07 11.82,83.01 14.74,85.93 14.74,87.71 14.87,87.84 15.12,87.84 15.25,87.71 15.25,86.95 15.37,86.82 15.5,86.82 15.63,86.95 15.63,88.12 v1(15.85,88.34)
FX2_PB2: length 34
  TOP w0.149: U49.20 v1(16.35,87.71)
  L12_SIG4 w0.089: v1(16.35,87.71) 16.77,87.71 16.9,87.58 16.9,87.16 17.15,86.91 17.15,86.77 16.86,86.48 16.86,86.35 17.15,86.06 17.15,85.88 16.86,85.59 16.86,85.46 17.15,85.17 17.15,85.04 17.03,84.91 16.26,84.91 15.88,84.53 15.88,83.26 15.76,83.14 15.25,83.14 15.11,83 15.11,82.76 15.24,82.63 15.56,82.63 15.88,82.3 15.88,81.61 15.76,81.49 15.25,81.49 15.12,81.36 15.12,80.6 15.25,80.47 15.37,80.47 15.5,80.6 15.5,80.98 15.63,81.1 15.76,81.1 15.88,80.98 15.88,79.33 15.76,79.2 15.63,79.2 15.5,79.33 15.5,79.96 15.37,80.09 15.25,80.09 15.12,79.96 15.12,79.33 14.99,79.2 14.87,79.2 14.74,79.33 14.74,81.74 14.87,81.87 15.37,81.87 15.5,81.99 15.5,82.12 15.37,82.25 14.49,82.25 14.36,82.12 14.36,79.07 14.69,78.74 15.7,78.74 15.88,78.56 15.88,78.31 16.04,78.15 19.47,78.15 19.68,77.95 19.68,77.46 19.99,77.15 20.4,77.15 20.89,76.65 v1(21.18,76.65)
FX2_PB3: length 34.5
  TOP w0.149: U49.21 v1(16.85,88.34)
  L12_SIG4 w0.089: v1(20.18,75.65) 19.68,76.15 17.25,76.15 17.15,76.05 17.15,75.9 17.28,75.77 17.69,75.77 17.79,75.67 17.79,75.5 17.68,75.39 17.28,75.39 17.15,75.26 17.15,74.99 17.05,74.88 16.88,74.88 16.77,74.99 16.77,76.53 16.65,76.65 16.51,76.65 16.39,76.53 16.39,75.39 16.28,75.28 16.12,75.28 16.01,75.39 16.01,76.53 15.9,76.64 15.74,76.64 15.63,76.53 15.63,76.02 15.5,75.9 15.12,75.9 14.74,76.28 14.74,76.66 12.96,78.44 12.96,78.56 13.09,78.69 13.47,78.69 13.6,78.82 13.6,78.95 13.47,79.07 12.33,79.07 12.2,79.2 12.2,82.76 12.71,83.26 13.34,83.26 13.73,83.65 13.73,83.8 13.49,84.03 13.49,84.18 13.59,84.28 13.73,84.28 13.97,84.04 14.12,84.04 14.22,84.14 14.22,84.28 13.98,84.52 13.98,84.66 14.08,84.76 14.22,84.76 14.46,84.52 14.6,84.52 14.7,84.62 14.7,84.77 14.46,85 14.46,85.15 14.56,85.25 14.7,85.25 14.94,85.01 15.34,85.01 15.97,85.64 15.97,85.97 15.87,86.07 15.35,86.07 15.25,86.17 15.25,86.31 15.35,86.41 15.87,86.41 15.97,86.51 15.97,87.93 16.38,88.34 v1(16.85,88.34)
FX2_PB4: length 34.8
  TOP w0.149: U49.22 v1(17.35,87.45)
  L12_SIG4 w0.089: v1(23.18,76.65) 23.18,76.28 22.68,75.78 22.68,75.43 22.39,75.14 21.87,75.14 21.68,74.95 21.68,74.46 21.4,74.18 20.1,74.18 19.68,73.75 19.68,73.46 19.48,73.26 18.75,73.26 18.09,72.6 16.01,72.6 14.54,74.07 14.54,75.21 13.74,76.01 13.74,76.59 11.44,78.89 11.44,83.26 14.36,86.18 14.36,88.6 14.61,88.85 16.9,88.85 17.23,88.52 17.23,87.96 17.35,87.84 v1(17.35,87.45)
FX2_PB5: length 34.4
  TOP w0.149: U49.23 v1(17.85,88.34)
  L12_SIG4 w0.089: v1(23.18,75.65) 23.18,75.19 22.68,74.69 22.68,74.44 22.39,74.15 21.97,74.15 21.69,73.87 21.69,73.53 21.41,73.25 20.08,73.25 19.85,73.03 18.98,73.03 18.17,72.21 15.88,72.21 14.05,74.04 14.05,75.06 12.83,76.28 12.83,76.91 11.06,78.69 11.06,83.39 13.98,86.31 13.98,88.75 14.46,89.23 17.15,89.23 17.66,88.72 17.66,88.54 v1(17.85,88.34)
FX2_PB6: length 34.5
  TOP w0.149: U49.24 v1(18.35,87.45)
  L12_SIG4 w0.089: v1(19.18,73.65) 19.73,74.21 19.73,74.9 19.99,75.15 20.44,75.15 20.68,75.38 20.68,75.94 20.9,76.17 21.33,76.17 21.57,76.41 21.57,76.94 21.34,77.17 20.84,77.17 20.68,77.33 20.68,77.86 20.38,78.16 19.9,78.16 19.68,78.38 19.68,78.83 19.44,79.07 17.79,79.07 17.28,78.56 16.52,78.56 16.39,78.69 16.39,79.45 16.52,79.58 18.42,79.58 18.55,79.71 18.55,79.83 18.42,79.96 18.17,79.96 18.04,80.09 18.04,80.6 17.91,80.72 17.79,80.72 17.66,80.6 17.66,80.09 17.53,79.96 16.39,79.96 16.26,80.09 16.26,80.22 16.39,80.34 17.15,80.34 17.28,80.47 17.28,80.6 17.15,80.72 16.39,80.72 16.26,80.85 16.26,82.5 16.39,82.63 16.52,82.63 16.64,82.5 16.64,81.23 16.77,81.1 16.9,81.1 17.03,81.23 17.03,83.28 16.89,83.41 16.4,83.41 16.27,83.54 16.27,83.72 16.4,83.84 16.89,83.84 17.03,83.98 17.03,84.41 17.53,84.91 17.53,86.64 v1(18.35,87.45)
FX2_PB7: length 33.7
  TOP w0.149: U49.25 v1(18.85,88.34)
  L12_SIG4 w0.089: v1(20.18,74.65) 20.48,74.65 21.02,75.19 21.4,75.19 21.71,75.51 21.71,75.79 22.08,76.15 22.41,76.15 22.66,76.41 22.66,77.8 22.33,78.13 22,78.13 21.68,78.46 21.68,78.99 21.47,79.2 20.91,79.2 20.71,79.4 20.71,79.86 20.35,80.22 20.03,80.22 19.78,80.47 19.78,80.75 19.5,81.03 18.66,81.03 18.44,81.25 18.44,81.72 18.3,81.87 17.91,81.87 17.79,81.99 17.79,82.25 17.91,82.37 18.59,82.37 18.68,82.46 18.68,83.14 18.55,83.26 17.88,83.26 17.79,83.35 17.79,83.56 17.88,83.64 18.65,83.64 18.8,83.8 18.8,83.94 18.7,84.04 18.34,84.04 18.24,84.14 18.24,84.28 18.34,84.38 18.7,84.38 18.8,84.48 18.8,84.62 18.7,84.72 18.34,84.72 18.24,84.82 18.24,85.01 18.34,85.11 18.7,85.11 18.8,85.21 18.8,85.35 18.7,85.45 18.34,85.45 18.24,85.55 18.24,86.01 18.42,86.18 18.93,86.18 19.18,86.44 19.18,86.82 19.37,87.01 19.73,87.01 19.82,87.1 19.82,87.37 19.73,87.45 19.5,87.45 19.37,87.58 19.37,88.66 19.57,88.85 19.57,89.99 19.44,90.12 17.75,90.12 17.66,90.03 17.66,89.83 17.75,89.74 18.17,89.74 18.3,89.61 18.3,89.11 18.42,88.98 18.55,88.98 18.68,89.11 18.68,89.61 18.8,89.74 18.95,89.74 19.06,89.63 19.06,88.98 18.85,88.77 v1(18.85,88.34)
FX2_PD0: length 12.6
  TOP w0.149: U49.45 v1(19.35,97.74)
  L07_SIG3 w0.089: v1(24.39,97.23) 24.01,97.61 24.01,98.12 24.14,98.25 24.52,98.25 24.65,98.38 24.65,98.76 24.52,98.88 23.38,98.88 23.12,98.63 23.12,97.33 22.89,97.11 22.59,97.11 22.36,97.33 22.36,98 22.11,98.25 21.7,98.25 21.19,97.74 20.84,97.74 20.33,98.25 19.86,98.25 v1(19.35,97.74)
  BOTTOM w0.149: v1(24.39,97.23) 24.67,96.96 24.67,96.71 24.93,96.44 U6.16
FX2_PD1: length 13.5
  TOP w0.149: U49.46 v1(18.85,98.76)
  L07_SIG3 w0.089: v1(18.85,98.76) 18.85,99.19 19.06,99.39 20.07,99.39 20.71,98.76 21.09,98.76 21.22,98.88 21.22,99.27 21.34,99.39 21.85,99.39 21.98,99.27 21.98,98.88 22.11,98.76 22.49,98.76 23.12,99.39 25.15,99.39 v1(26.04,98.5)
  BOTTOM w0.149: U6.3 26.75,97.8 v1(26.04,98.5)
FX2_PD2: length 13
  TOP w0.149: U49.47 v1(18.35,97.74)
  L07_SIG3 w0.089: v1(18.35,97.74) 18.94,97.15 21.81,97.15 22.74,96.22 23.88,96.22 24.65,95.46 25.28,95.46 26.04,94.69 27.19,94.69 v1(27.82,94.06)
  BOTTOM w0.149: U6.9 27.15,94.73 v1(27.82,94.06)
FX2_PD3: length 13.4
  TOP w0.149: U49.48 v1(17.85,98.76)
  L07_SIG3 w0.089: v1(25.15,94.06) 23.76,94.06 22.23,95.58 22.23,96.04 22.02,96.25 21.56,96.25 21.09,96.73 18.68,96.73 17.85,97.55 v1(17.85,98.76)
  BOTTOM w0.149: v1(25.15,94.06) 25.4,94.3 25.65,94.3 25.95,94.6 U6.12
FX2_PD4: length 34.7
  TOP w0.149: U49.49 v1(17.35,97.74)
  L07_SIG3 w0.089: v1(17.35,97.74) 17.35,97.31 17.15,97.11 17.15,96.47 17.28,96.34 17.46,96.34 17.59,96.47 17.59,96.85 17.71,96.98 17.91,96.98 18.04,96.85 18.04,96.4 18.42,96.02 18.42,95.84 18.3,95.71 18.04,95.71 17.91,95.58 17.91,89.87 19.38,88.4 19.38,88.22 19.69,87.9 19.69,86.69 19.57,86.57 18.42,86.57 18.3,86.44 18.3,86.31 18.42,86.18 19.57,86.18 19.69,86.06 19.69,85.86 19.57,85.73 18.42,85.73 18.3,85.6 18.3,85.42 18.42,85.3 19.56,85.3 20.14,84.71 20.14,84.28 20.02,84.15 18.8,84.15 18.3,83.64 18.3,82.63 18.04,82.37 18.04,81.61 17.91,81.49 17.53,81.49 17.41,81.36 17.41,81.17 17.53,81.05 17.91,81.05 18.04,80.92 18.04,80.74 17.95,80.65 17.53,80.65 17.41,80.52 17.41,80.34 17.53,80.22 18.27,80.22 18.4,80.34 18.4,82.1 18.68,82.37 18.68,83.14 18.8,83.26 19.06,83.26 19.18,83.14 v1(19.18,82.65)
FX2_PD5: length 36.4
  TOP w0.149: U49.50 v1(16.85,98.76)
  L07_SIG3 w0.089: v1(16.85,98.76) 16.14,99.47 16.14,100.03 15.76,100.41 14.61,100.41 14.36,100.15 14.36,98.5 14.92,97.94 14.92,97.42 14.61,97.11 14.61,96.85 15.69,95.77 16.2,95.77 16.38,95.6 16.38,88.25 16.9,87.73 16.9,86.69 16.39,86.18 16.39,85.3 16.9,84.79 16.9,84.16 16.77,84.03 15.76,84.03 15.63,83.9 15.63,83.39 15.37,83.14 15.37,82.76 15.76,82.37 15.76,79.45 16.26,78.95 16.26,78.06 16.52,77.8 17.61,77.8 17.74,77.93 17.74,78.79 18.07,79.12 19.39,79.12 19.86,78.65 v1(20.18,78.65)
FX2_PD6: length 35.7
  TOP w0.149: U49.51 v1(16.35,97.74)
  L07_SIG3 w0.089: v1(19.18,79.65) 18.98,79.45 17.66,79.45 17.53,79.33 17.53,79.1 17.39,78.96 17.39,78.31 17.27,78.18 16.77,78.18 16.64,78.31 16.64,79.07 16.26,79.45 16.26,79.66 16.36,79.76 16.57,79.76 16.67,79.86 16.67,80 16.57,80.1 16.24,80.1 16.14,80.2 16.14,80.35 16.24,80.45 16.57,80.45 16.67,80.55 16.67,80.69 16.57,80.79 16.24,80.79 16.14,80.89 16.14,81.03 16.24,81.13 16.57,81.13 16.67,81.23 16.67,81.37 16.57,81.47 16.24,81.47 16.14,81.57 16.14,81.72 16.24,81.82 16.57,81.82 16.67,81.92 16.67,82.06 16.57,82.16 16.24,82.16 16.14,82.26 16.14,82.44 16.26,82.57 16.77,82.57 16.9,82.69 16.9,83.1 16.77,83.23 16.1,83.23 16.01,83.31 16.01,83.52 16.14,83.64 17.28,83.64 17.41,83.77 17.41,84.1 17.53,84.23 17.79,84.23 17.91,84.35 17.91,84.53 17.79,84.66 17.53,84.66 17.41,84.79 17.41,85.17 17.28,85.3 16.9,85.3 16.77,85.42 16.77,85.68 16.9,85.8 17.15,85.8 17.28,85.93 17.28,86.82 17.41,86.95 17.75,86.95 17.88,87.07 17.88,87.55 17.28,88.15 17.28,88.6 16.72,89.16 16.72,89.34 16.82,89.44 17.05,89.44 17.15,89.54 17.15,89.68 17.05,89.78 16.82,89.78 16.72,89.88 16.72,90.02 16.82,90.12 17.05,90.12 17.15,90.22 17.15,90.36 17.05,90.47 16.82,90.47 16.72,90.57 16.72,95.76 16.26,96.22 15.88,96.22 15.76,96.35 15.76,96.6 15.88,96.73 16.26,96.73 16.39,96.85 16.39,97.11 16.26,97.23 15.89,97.23 15.76,97.37 15.76,97.57 15.93,97.74 v1(16.35,97.74)
FX2_PD7: length 36.2
  TOP w0.149: U49.52 v1(15.85,98.76)
  L07_SIG3 w0.089: v1(15.85,98.76) 15.37,98.76 15.25,98.88 15.25,99.27 15.37,99.39 15.63,99.39 15.76,99.52 15.76,99.77 15.63,99.9 14.87,99.9 14.74,99.77 14.74,98.63 15.12,98.25 16.52,98.25 16.8,97.97 16.8,96.32 17.53,95.58 17.53,89.49 18.33,88.69 18.33,88.2 19.06,87.47 19.06,87.07 18.93,86.95 18.3,86.95 17.79,86.44 17.79,85.42 18.42,84.79 18.42,84.23 17.25,83.06 17.25,81.97 17.03,81.74 17.03,80.09 17.28,79.83 18.55,79.83 18.73,80.01 18.73,81.92 18.93,82.12 19.44,82.12 19.68,81.88 19.68,80.52 20.18,80.02 v1(20.18,79.65)
FX2_RESETN: length 37.4
  TOP w0.149: v1(21.67,96.7) 21.27,96.29 U49.42
  L12_SIG4 w0.089: v1(23.18,78.65) 23.68,79.15 23.68,81.85 23.98,82.15 24.37,82.15 24.68,82.46 24.68,82.95 24.98,83.25 25.46,83.25 25.66,83.46 25.66,85.68 26.17,86.18 26.17,89.61 25.79,89.99 25.79,92.53 25.53,92.79 25.03,92.79 24.65,92.41 24.26,92.41 23.35,93.33 22.36,93.33 22.05,93.63 22.05,95.02 21.47,95.61 21.47,96.5 v1(21.67,96.7)
  L16_SIG6 w0.081: v1(21.67,96.7) 18.32,96.7 17.91,97.11 17.91,97.74 17.41,98.25 17.41,98.83 17.03,99.22 v1(10.59,99.22)
FX2_SCL: length 20.9
  TOP w0.149: v1(12.45,88.09) 12.83,88.47 13.47,88.47 13.85,88.85 U49.15
  L12_SIG4 w0.089: v1(12.45,88.09) 12.88,88.52 12.88,89.65 14.75,91.52 19.69,91.52 20.28,90.93 20.28,89.03 20.71,88.6 20.71,87.96 20.58,87.84 20.58,86.69 19.78,85.89 19.78,85.05 20.18,84.65 v1(20.18,83.65)
  BOTTOM w0.149: v1(12.45,88.09) 12.71,88.34 R451.1
FX2_SDA: length 23.9
  TOP w0.149: U49.16 14.35,88.46 13.6,87.71 v1(13.22,87.71)
  L12_SIG4 w0.089: v1(13.22,87.71) 13.22,89.13 14.21,90.12 16.14,90.12 16.52,90.5 19.64,90.5 19.92,90.22 19.92,88.88 20.31,88.49 20.31,88.09 20.2,87.98 20.2,86.88 19.18,85.86 19.18,84.28 19.62,83.85 19.62,82.5 19.21,82.1 19.01,82.1 18.78,81.87 18.78,81.51 19.03,81.26 19.78,81.26 v1(20.18,81.65)
  BOTTOM w0.149: v1(13.22,87.71) 13.76,87.71 13.98,87.93 R452.1
FX2_SLRDN: length 35.8
  TOP w0.149: v1(13.2,96.73) U49.1
  L12_SIG4 w0.089: v1(13.2,96.73) 13.71,97.23 20.07,97.23 21.09,96.22 21.09,95.46 21.26,95.29 21.26,94.58 21.39,94.44 21.39,93.12 21.69,92.82 21.87,92.82 22.35,92.34 23.7,92.34 24.01,92.03 24.77,92.03 24.89,91.91 24.89,89.87 25.03,89.74 25.53,89.74 25.79,89.49 25.79,86.31 25.41,85.93 24.9,85.93 24.68,85.71 24.68,85.39 25.28,84.79 25.28,84.37 24.68,83.77 24.68,83.58 24.25,83.15 23.9,83.15 23.68,82.93 23.68,82.51 23.32,82.15 23.02,82.15 22.68,81.81 22.68,81.41 22.42,81.15 21.98,81.15 21.73,80.9 21.73,80.46 22.56,79.63 22.56,78.29 22.82,78.03 23.8,78.03 v1(24.18,77.65)
FX2_SLWRN: length 34.2
  TOP w0.149: U49.2 12.62,95.79 12.39,96.02 12.39,96.23 v1(12.11,96.51)
  L12_SIG4 w0.089: v1(20.18,82.65) 20.18,83.06 20.71,83.59 20.71,85.94 20.96,86.19 20.96,87.71 21.22,87.96 21.22,89.36 20.63,89.94 20.63,91.16 19.95,91.85 19.95,95.07 20.04,95.17 20.04,95.49 19.57,95.96 17.41,95.96 17.28,96.09 17.28,96.73 17.15,96.85 16.77,96.85 16.64,96.73 16.64,96.09 16.52,95.96 16.14,95.96 16.01,96.09 16.01,96.73 15.88,96.85 15.5,96.85 15.37,96.73 15.37,96.09 15.25,95.96 14.87,95.96 14.74,96.09 14.74,96.73 14.61,96.85 14.23,96.85 13.98,96.6 13.98,96.09 13.85,95.96 13.6,95.96 13.47,95.84 13.47,95.46 13.6,95.33 13.85,95.33 13.98,95.2 13.98,93.42 13.85,93.3 13.09,93.3 12.96,93.42 12.96,96.22 12.67,96.51 v1(12.11,96.51)
FX2_WAKEUP: length 9
  TOP w0.229: U49.44 v1(19.85,98.76)
  BOTTOM w0.254: R448.2 19.82,97.41 19.82,98.73 v1(19.85,98.76) 21.48,98.76 C491.1 22.61,97.56 R446.2
  BOTTOM w0.381: R446.2 R447.2
GFX_1ST_PERSTN: length 42.9
  L05_SIG2 w0.081: v1(53.86,97.61) 51.29,97.61 48.39,94.72 41.69,94.72 40.29,93.32 40.29,90.1 41.22,89.17 41.22,87.09 40.9,86.77 40.9,85.8 40.27,85.17 40.27,81.74 39,80.47 39,77.68 39.27,77.4 39.27,76.17 38.06,74.96 34.7,74.96 34.01,75.65 v1(33.18,75.65)
  BOTTOM w0.149: U91.2 55,97.11 54.49,97.61 v1(53.86,97.61)
GPIO0_3V3_AC0_ZL_INT_N: length 75.2
  TOP w0.149: U23.49 59.42,45.01 58.43,44.02 58.43,42.5 57.09,41.16 R258.2 58.11,41.1 R242.1 58.26,41.08 58.58,41.08 58.99,40.67 v1(58.99,38.66)
  L12_SIG4 w0.089: v1(58.99,38.66) 58.53,38.2 56.37,38.2 55.07,39.5 46.32,39.5 45.28,40.54 42.96,40.54 41.21,42.29 40.93,42.29 37.62,45.6 37.62,45.85 32.62,50.85 32.62,51.41 30.69,53.34 30.69,54.89 27.95,57.64 27.95,62.28 26.85,63.38 26.85,64.72 25.25,66.32 25.25,67.39 24.72,67.92 24.72,69.93 24.39,70.26 24.04,70.26 23.71,70.59 23.71,72.92 23.94,73.15 24.34,73.15 24.7,73.51 24.7,73.91 24.95,74.17 25.31,74.17 25.56,74.42 25.56,75.83 25.88,76.15 26.37,76.15 26.68,76.46 26.68,78.15 v1(27.18,78.65)
GPIO1_3V3_AC1_PTP_CLK_LOL: length 62.3
  TOP w0.149: R243.1 R259.2 57.79,43.88 v1(57.79,45.29) 58.23,45.73 U23.48
  L05_SIG2 w0.081: v1(26.18,81.65) 26.58,81.25 26.58,80.8 26.8,80.58 26.8,72.41 27.05,72.15 27.43,72.15 27.68,71.9 27.68,71.45 28.99,70.14 33.56,70.14 35.43,68.27 38.15,68.27 39.58,66.84 40.52,66.84 41.03,66.33 41.03,63.6 42.91,61.72 43.53,61.72 44.17,61.07 44.17,59.88 46.24,57.81 48.38,57.81 49.86,56.33 51.6,56.33 54.17,53.76 54.17,49.1 56.67,46.6 56.67,45.93 57.31,45.29 v1(57.79,45.29)
GPIO2_1V2_AC2_FPGA_HPS_ZL_HO: length 255.6
  L07_SIG3 w0.089: v1(209.75,103.08) 202.45,110.38 17.6,110.38 6.61,99.39 6.61,92.79 9.33,90.07 9.33,85.98 12.33,82.98 12.33,78.82 13.72,77.42 13.72,74.5 16.77,71.45 17.41,71.45 18.68,70.18 18.68,68.53 19.06,68.15 23.68,68.15 v1(24.18,68.65)
  BOTTOM w0.149: v1(209.75,103.08) 210.7,102.12 210.7,101.17 210.92,100.95 U88.5
GPIO2_3V3_AC2_FPGA_HPS_ZL_HO: length 251.9
  TOP w0.149: v1(53.09,44.4) 54.74,44.4 55,44.66 56.88,44.66 56.98,44.55 56.98,44.26 R260.2 57.28,44.34 57.28,45.02 R244.1 58.11,46.23 U23.47
  L03_SIG1 w0.081: v1(49.79,104.6) 51.32,106.12 58.81,106.12 59.87,107.18 59.87,107.82 61.5,109.45 72.93,109.45 73.95,110.47 172.73,110.47 174.94,108.26 208.97,108.26 211.34,105.9 v1(211.34,104.6)
  L07_SIG3 w0.089: v1(49.79,104.6) 49.41,104.22 49.41,97.36 49.66,97.11 49.66,96.09 48.98,95.41 48.98,92.46 49.1,92.34 49.1,88.15 47.64,86.7 46.16,86.7 45.28,85.82 45.28,83.04 43.19,80.94 43.19,66.5 44.2,65.48 44.2,61.47 48.25,57.42 48.25,52.66 51.1,49.81 51.1,43.73 51.95,42.88 52.71,42.88 53.09,43.26 v1(53.09,44.4)
  BOTTOM w0.149: U88.7 212.77,100.95 212.99,101.17 212.99,102.19 211.34,103.84 v1(211.34,104.6)
GPIO4_AC4: length 3.7
  TOP w0.149: R246.1 R262.2 57.59,47.72 57.59,47.35 57.87,47.07 58.3,47.07 58.46,47.23 U23.45
GXF_1V2_2ND_PERSTN: length 291.4
  L03_SIG1 w0.081: v1(223.62,18.14) 223.37,18.39 223.37,21.3 224.64,22.57 224.64,25.99 222.76,27.88 222.76,30.11 219.08,33.78 219.08,40.97 219.95,41.84 219.95,61.72 220.66,62.44 220.66,64.75 222.97,67.06 222.97,73.88 221.36,75.49 221.36,82.78 220.75,83.4 220.75,84.95 219.46,86.24 219.46,101.02 218.83,101.65 218.83,102.42 217.75,103.49 212.01,103.49 210.57,102.06 v1(209.81,102.06)
  L07_SIG3 w0.089: v1(223.62,18.14) 223.35,17.87 222.5,17.87 221.62,18.75 220.61,18.75 219.97,18.11 219.41,18.11 216.76,15.46 185.82,15.46 185.33,15.95 179.99,15.95 179.66,15.62 162.52,15.62 162.19,15.95 155.84,15.95 155.43,15.55 135.73,15.55 133.98,13.79 113.04,13.79 112.55,14.28 85.8,14.28 85.1,14.97 75.36,14.97 73.4,16.93 73.4,20.41 73.79,20.8 73.79,22.72 74.03,22.96 74.35,22.96 74.59,23.2 74.59,24.3 74.84,24.56 75.15,24.56 75.39,24.8 75.39,25.11 75.63,25.35 76.93,25.35 77.1,25.52 77.1,34.97 79.26,37.13 79.26,37.43 81.94,40.11 82.69,40.11 83.32,40.74 84.72,40.74 85.27,41.3 86.4,41.3 86.63,41.53 v1(86.63,42.15)
  BOTTOM w0.149: U88.4 210.55,100.55 210.32,100.79 210.32,101.55 v1(209.81,102.06)
