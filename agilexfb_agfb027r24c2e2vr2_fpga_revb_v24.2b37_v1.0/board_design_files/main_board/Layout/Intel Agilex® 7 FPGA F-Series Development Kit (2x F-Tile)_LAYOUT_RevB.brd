# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_QSFP_CAGE: length 18.4
  BOTTOM w1.016: B2.10 45.53,39.78 48.09,39.78 49.79,41.48 B2.12 50.05,46.41 50.05,53.1 B2.11
  vias: v3(5.09,56.72) v3(5.09,55.45) v3(6.42,56.72) v3(6.42,55.45)
GND_QSFPDD_CAGE: length 51.7
  BOTTOM w0.381: B1.2 31.24,35.11 35.92,35.11 37.29,36.48 38.49,36.48 38.91,36.06 B1.1
  BOTTOM w1.016: B1.11 B1.12 60.99,19.54 58.51,17.06 B1.6 39.72,17.06 39,16.33 35.51,16.33 B1.7
  vias: v3(6.99,34.31) v3(6.99,33.23) v3(8.33,34.31) v3(8.33,33.29)
VBUS_5V: length 2.4
  TOP w0.279: v1(5.72,97.36) 5.4,97.04 J10.1 v1(3.41,97.04)
  vias: v2(23.63,95.8)
VCCBAT:
  vias: v1(91.41,69.75) v2(169.68,75.64) v2(217.69,68.09)
VDD18_ZL30733: length 4.4
  TOP w0.254: v2(68.97,53.16) 68.53,52.73 68.44,52.73 ; v1(69,46.36) 68.88,46.23 U23.2 ; U23.37 58.2,51.23 v1(58.05,51.39) ; v1(69,45.54) 68.81,45.73 U23.1
  TOP w0.255: 68.44,52.73 U23.15
VDD33_ZL30733: length 5.6
  TOP w0.254: v1(68.69,52.14) 68.59,52.23 ; v1(58.05,50.5) 58.28,50.73 U23.38 ; U23.3 67.4,46.73 67.06,47.07 v1(67.06,47.96) ; v1(58.05,48.47) 58.28,48.23 U23.43
  TOP w0.255: 68.59,52.23 U23.14
  BOTTOM w0.254: C367.2 68.57,52.02 v1(68.69,52.14)
  BOTTOM w0.381: v1(67.06,47.96) 66.94,48.08 C362.2
VDD_ZL_OSC: length 3.4
  TOP w0.254: U24.4 58.81,57.89 58.81,58.56 R238.2
  vias: v2(57.54,57.05)
VDDIO_ZL30733: length 4.6
  TOP w0.254: v1(58.05,47.58) 58.2,47.73 U23.44
  BOTTOM w0.381: FB16.1 55.19,47.26 C363.2 57.67,47.26 C359.2
VDDO0_ZL30733: length 4.3
  TOP w0.254: v1(60.26,45.8) U23.50
  BOTTOM w0.381: FB42.1 58.43,44.4 58.43,45.74 C354.2 C355.2 C353.2
VDDO1_ZL30733: length 3.3
  TOP w0.254: v1(61.76,45.8) U23.53
  BOTTOM w0.381: FB14.1 60.97,44.4 C357.2 C356.2
VDDO2_ZL30733: length 2.8
  TOP w0.254: U23.56 63.26,45.67 v1(63.38,45.8)
  BOTTOM w0.381: C360.2 62.75,45.16 FB15.1
VDDO3_ZL30733: length 3.3
  TOP w0.254: v1(64.76,45.8) U23.59
  BOTTOM w0.381: C377.2 C378.2 65.41,44.4 FB19.1
VDDO4_ZL30733: length 3.6
  TOP w0.254: U23.62 v1(66.26,45.8)
  BOTTOM w0.381: v1(66.26,45.8) 66.32,45.86 C385.2 67.19,44.91 FB21.1
VDDO5_ZL30733: length 3.4
  TOP w0.254: U23.19 v1(66.26,53.29)
  BOTTOM w0.381: FB22.1 67.25,53.74 67.25,53.16 C394.2 C397.2
VDDO6_ZL30733: length 2.7
  TOP w0.254: U23.22 v1(64.76,53.29)
  BOTTOM w0.381: FB23.1 65.54,53.36 C399.2 65.35,53.29 v1(64.76,53.29)
VDDO7_ZL30733: length 3.1
  TOP w0.254: v1(63.38,53.29) 63.26,53.42 U23.25
  BOTTOM w0.381: C401.2 63.45,53.23 v1(63.38,53.29) 62.81,53.29 C402.2 62.75,54.31 FB24.1
VDDO8_ZL30733: length 3.1
  TOP w0.254: U23.28 v1(61.76,53.29)
  BOTTOM w0.381: FB25.1 60.97,54.05 C405.2 C404.2
VDDO9_ZL30733: length 3
  TOP w0.254: U23.31 v1(60.26,53.29)
  BOTTOM w0.381: C407.2 C408.2 59.19,54.18 FB26.1
1_PPS_SCOPE1: length 211.7
  L12_SIG4 w0.089: v1(93.8,49.05) 93.8,48.3 94,48.1 112.75,48.1 113.56,47.29 113.94,47.29 114.31,47.66 114.68,47.66 115.09,47.24 115.59,47.24 115.97,47.63 116.28,47.63 116.67,47.23 117.02,47.23 117.5,46.75 117.86,46.75 118.23,47.12 118.48,47.12 119.01,47.65 119.47,47.65 119.86,48.05 120.33,48.05 120.67,47.71 121.15,47.71 121.58,48.14 121.9,48.14 122.32,48.56 122.99,48.56 123.23,48.32 125.43,48.32 129.29,44.46 129.29,40.21 130.18,39.32 136.66,39.32 137.5,40.17 139.73,40.17 139.96,39.94 139.96,39.11 140.19,38.88 140.92,38.88 141.31,38.49 141.31,37.85 141.68,37.48 142.31,37.48 142.73,37.06 142.73,36.55 143.14,36.15 143.82,36.15 144.19,35.78 144.19,35.23 144.48,34.94 145.59,34.94 145.9,34.62 145.9,32.09 146.19,31.8 152.61,31.8 152.72,31.92 154.81,31.92 156.19,30.53 160.51,30.53 161.83,29.21 161.83,29.08 163.45,27.46 163.91,27.46 164.75,26.62 164.75,25.83 165.33,25.26 165.82,25.26 166.31,24.77 166.31,22.75 169.55,19.51 169.55,19.26 172.32,16.49 207.56,16.49 209.22,18.15 209.22,19.88 210.88,21.54 212.04,21.54 214.09,19.48 215.7,19.48 216.03,19.81 216.8,19.81 217.79,20.81 217.79,22.94 221.36,26.51 226.72,26.51 231.19,30.98 234.2,30.98 246.31,43.08 246.31,54.7 248.42,56.81 v1(248.42,61.93)
1_PPS_SCOPE2: length 185.8
  L12_SIG4 w0.089: v1(93,46.75) 94,46.75 94.37,46.37 113.94,46.37 114.31,46.74 114.68,46.74 115.09,46.32 115.59,46.32 115.97,46.71 116.28,46.71 116.67,46.31 117.15,46.31 117.59,45.87 117.91,45.87 118.37,46.32 118.68,46.32 119.16,46.81 119.51,46.81 119.9,47.2 120.29,47.2 120.68,46.8 120.97,46.8 121.38,47.2 121.93,47.2 122.39,47.67 125.49,47.67 128.79,44.37 128.79,39.32 129.23,38.88 139.46,38.88 139.9,38.44 139.9,37.97 140.37,37.49 140.82,37.49 142.69,35.62 142.69,35.24 142.97,34.96 143.84,34.96 144.33,34.47 144.33,30.94 144.53,30.74 155.2,30.74 155.71,30.23 160.15,30.23 161.44,28.95 161.44,28.77 162.6,27.61 162.6,27.23 164.24,25.58 164.24,22.38 164.93,21.69 166.25,21.69 171.84,16.11 207.83,16.11 210.16,18.44 210.16,19.3 210.91,20.05 210.91,20.28 211.52,20.89 212.03,20.89 214.04,18.87 216.62,18.87 216.95,19.21 216.95,19.57 218.27,20.89 218.27,22.2 220.36,24.29 226.42,24.29 228.29,26.16 241.33,26.16 241.54,26.37 v1(248.42,26.37)
24M_XTALIN: length 3.6
  TOP w0.149: Y2.1 10.15,94.29 10.9,94.29 C493.1 11.37,94.29 U49.5
24M_XTALOUT: length 5.2
  TOP w0.149: Y2.3 8.78,94.99 8.97,94.79 10.91,94.79 C494.1 11.35,94.79 U49.4
ADI_ALERTN: length 227.7
  TOP w0.149: U96.A2 v1(199.66,81) ; v1(38.74,76.66) 38.23,76.15 34.68,76.15 U5.A9 ; U93.A2 v1(47.1,91.91)
  L07_SIG3 w0.089: v1(38.74,76.66) 39,76.91 39,80.22 38.36,80.85 38.36,89.74 39.76,91.14 39.76,93.55 40.65,94.44 44.33,94.44 45.09,93.68 45.09,93.18 45.73,92.53 46.31,92.53 46.69,92.15 46.69,92.04 46.82,91.91 v1(47.1,91.91) 47.1,92.43 46.3,93.23 46.3,94.06 46.62,94.38 46.62,99.01 49.05,101.45 49.05,104.63 49.91,105.49 53.22,105.49 54.24,104.47 55.5,104.47 58.17,107.14 58.17,107.77 58.71,108.31 73.29,108.31 74.07,109.1 80.86,109.1 81.11,108.84 88.25,108.84 88.5,109.1 100.39,109.1 100.67,108.82 102.27,108.82 102.55,109.1 117.74,109.1 118.75,108.08 130.18,108.08 131.2,109.1 139.12,109.1 140.06,108.16 191.01,108.16 191.16,108.01 191.16,101.65 191.37,101.44 191.37,100.87 191.06,100.56 191.06,94.14 192.03,93.17 192.03,92.72 196.3,88.45 196.3,83.31 196.63,82.98 198.52,82.98 199.26,82.24 199.26,81.41 v1(199.66,81)
  BOTTOM w0.149: R6807.1 200.2,80.47 v1(199.66,81) ; v1(47.1,91.91) 47.63,92.44 R1007.1
ASEL0: length 3.2
  TOP w0.203: U61.23 183.71,53.57 184.94,53.57
  TOP w0.267: R550.1 186.19,54.82 184.94,53.57
ASEL1: length 3.4
  TOP w0.203: 184.57,53.96 U61.24
  TOP w0.267: 184.57,53.96 186.31,55.7 R551.1
AUX_HSC_ALERT_N: length 280.4
  TOP w0.149: U54.15 226.06,82.68 225.86,82.88 224.7,82.88
  TOP w0.152: 224.7,82.88 v1(223.76,83.81)
  L07_SIG3 w0.089: v1(16.9,108.54) 16.44,108.54 7.37,99.47 7.37,97.72 7.53,97.56 7.53,92.74 9.68,90.58 9.68,87.18 12.83,84.03 12.83,78.82 14.23,77.42 14.23,74.75 16.73,72.25 19.28,72.25 19.68,71.85 19.68,71.45 19.98,71.15 20.38,71.15 20.68,70.85 20.68,70.35 20.88,70.15 21.48,70.15 21.68,69.95 21.68,69.45 21.98,69.15 24.68,69.15 v1(25.18,69.65)
  L16_SIG6 w0.081: v1(16.9,108.54) 17.41,109.04 17.41,109.68 18.17,110.44 195.84,110.44 201.52,104.77 201.52,101.08 207.4,95.2 207.4,93.8 208.92,92.28 211.34,92.28 218.83,84.79 223.2,84.79 223.76,84.22 v1(223.76,83.81)
AUX_HSC_BST: length 1.6
  TOP w0.149: C625.2 227.56,76.95 U54.4
AUX_HSC_FAULTB: length 1.7
  TOP w0.149: U54.16 224.59,81.97 R474.2
AUX_HSC_ILOAD: length 2.1
  TOP w0.149: U54.2 226.56,77.85 v1(225.56,76.85)
AUX_HSC_PG: length 246.7
  TOP w0.203: U54.17 224.07,81.47 v1(223.76,81.78)
  L05_SIG2 w0.081: v1(41.54,109.55) 40.91,108.93 39.48,108.93 38.67,108.12 38.67,106.45 38.35,106.12 38.35,104.2 37.39,103.25 37.39,95.82 37.83,95.39 38.42,95.39 39.93,93.88 39.93,89.7 40.33,89.3 40.33,87.14 39.76,86.57 39.76,81.87 38.49,80.6 38.49,77.28 37.03,75.82 34.98,75.82 34.65,76.15 32.93,76.15 32.65,75.87 32.65,75.12 v1(32.18,74.65)
  L16_SIG6 w0.081: v1(223.76,81.78) 223.76,80.86 223.2,80.29 222.43,80.29 221.43,81.3 221.43,82.9 220.75,83.58 219.15,83.58 211.21,91.52 208.8,91.52 206.76,93.55 206.76,94.8 200.74,100.82 200.74,104.65 196.02,109.37 166.25,109.37 165.44,110.19 42.17,110.19 v1(41.54,109.55)
AUX_HSC_ROCP: length 1.5
  TOP w0.149: R479.2 224.01,80.97 U54.18
AUX_HSC_SMB_ID_R: length 1.5
  TOP w0.152: R477.2 223.96,79.97 U54.20
AUX_HSC_SS: length 3.3
  TOP w0.149: C628.1 226.75,76.67 226.87,76.67 227.11,76.43 227.11,76.32 C629.1
  TOP w0.152: C628.1 227.06,77.34 U54.3
AUX_VDD_1V85: length 9.1
  L03_SIG1 w0.381: v1(223.97,76.79) 223.39,76.21 222.5,76.21 222.03,76.68 222.03,82.36 222.47,82.8 v1(222.87,82.8)
BANK2C_RZQ:
  vias: v1(100.97,76.19)
BANK2D_RZQ:
  vias: v1(110.53,76.19)
BANK2F_RZQ:
  vias: v1(94.6,78.03)
BMC_BUF_TCK: length 83.4
  L07_SIG3 w0.089: v1(33.18,68.65) 33.58,68.25 34.28,68.25 34.47,68.06 34.47,49.56 38.23,45.8 38.23,45.04 39.93,43.34 41.53,43.34 43,41.87 43,39.76 42.68,39.44 42.68,37.72 43.36,37.04 43.36,32.03 43.82,31.57 43.82,27.76 43.19,27.13 43.19,23.8 43.31,23.68 47.91,23.68 49.41,22.18 50.05,22.18 50.81,21.41 50.81,19.26 51.51,18.56 52.9,18.56 53.35,18.11 53.35,16.97 53.22,16.84 52.84,16.84 52.71,16.97 52.71,17.48 52.59,17.6 52.2,17.6 52.08,17.48 52.08,16.97 51.95,16.84 51.57,16.84 51.44,16.97 51.44,17.48 51.32,17.6 50.93,17.6 50.81,17.48 50.81,15.45 50.93,15.32 51.32,15.32 51.44,15.45 51.44,15.95 51.57,16.08 51.95,16.08 52.08,15.95 52.08,15.45 52.2,15.32 52.59,15.32 52.71,15.45 52.71,15.95 52.84,16.08 53.22,16.08 53.35,15.95 53.35,15.06 52.97,14.68 50.93,14.68 50.81,14.56 50.81,14.19 v1(52.47,12.52)
BMC_BUF_TDI: length 82.7
  L07_SIG3 w0.089: v1(48.65,15.32) 49.41,15.32 49.54,15.45 49.54,16.46 49.41,16.59 49.16,16.59 49.03,16.46 49.03,16.21 48.9,16.08 48.52,16.08 48.39,16.21 48.39,17.6 48.52,17.73 48.9,17.73 49.03,17.6 49.03,17.22 49.16,17.1 49.41,17.1 49.54,17.22 49.54,18.11 49.41,18.24 48.39,18.24 48.14,18.49 48.14,19.46 48.27,19.59 48.65,19.59 48.78,19.71 48.78,19.97 48.65,20.09 48.27,20.09 48.15,20.21 48.15,20.48 48.27,20.6 48.69,20.6 48.78,20.69 48.78,20.98 48.65,21.11 48.28,21.11 48.14,21.25 48.14,22.31 47.48,22.96 46.77,22.96 46.62,22.81 46.62,22.43 46.49,22.3 46.11,22.3 45.98,22.43 45.98,22.81 45.83,22.96 42.53,22.96 42.3,23.19 42.3,27.64 42.17,27.76 42.04,27.76 41.92,27.89 41.92,28.53 42.04,28.65 42.55,28.65 42.68,28.78 42.68,29.03 42.55,29.16 42.04,29.16 41.92,29.29 41.92,29.54 42.04,29.67 42.3,29.67 42.43,29.8 42.43,29.98 42.3,30.1 42.04,30.1 41.92,30.23 41.92,32.39 42.04,32.51 42.43,32.51 42.55,32.64 42.55,32.9 42.43,33.02 42.04,33.02 41.92,33.15 41.92,33.4 42.04,33.53 42.43,33.53 42.55,33.66 42.55,33.86 42.43,33.99 42.04,33.99 41.92,34.11 41.92,34.29 42.04,34.42 42.5,34.42 42.63,34.55 42.63,36.71 41.92,37.42 41.92,38.43 41.79,38.56 41.16,38.56 41.03,38.69 41.03,39.19 41.18,39.34 41.64,39.34 42.33,40.03 42.33,41.57 41.42,42.48 39.77,42.48 33.28,48.98 33.28,54.1 32.46,54.91 32.46,59.95 32.27,60.15 32.27,62.94 32.52,63.2 32.52,67.54 31.56,68.5 31.56,69.88 31.26,70.17 30.66,70.17 v1(30.18,70.65)
BMC_BUF_TDO: length 84.9
  TOP w0.149: U5.F14 29.68,70.15 29.68,68.15 v1(30.18,67.65)
  L07_SIG3 w0.089: v1(53.6,12.27) 53.14,11.81 53.14,11.2 52.64,10.7 49.43,10.7 48.67,11.46 48.67,14.73 48.05,15.36 48.05,15.83 47.68,16.21 47.68,21.63 47.38,21.92 43.01,21.92 40.34,24.59 40.34,28.02 40.61,28.29 40.61,29.66 41.44,30.49 41.44,34.85 42.23,35.65 42.23,36.59 40.65,38.18 40.65,39.45 40.9,39.7 41.53,39.7 42,40.17 42,41.4 41.28,42.12 39.25,42.12 32.07,49.29 32.07,53.99 31.38,54.68 31.38,59.9 31.59,60.12 31.59,65.64 31.38,65.86 31.38,67.15 31.61,67.39 31.61,67.9 31.4,68.12 31.01,68.12 30.54,67.65 v1(30.18,67.65)
  BOTTOM w0.149: U28.3 54.25,13.94 53.6,13.29 v1(53.6,12.27)
BMC_BUF_TMS: length 83.4
  L07_SIG3 w0.089: v1(59.51,12.4) 54.87,12.4 54.49,12.78 53.35,12.78 52.62,12.05 51.91,12.05 50.05,13.92 50.05,18.37 49.28,19.13 49.28,21.8 47.76,23.32 42.93,23.32 42.68,23.57 42.68,27.26 43.06,27.64 43.06,30.05 42.68,30.43 42.68,31.57 42.98,31.88 42.98,36.86 42.3,37.54 42.3,39.53 42.67,39.9 42.67,41.72 41.51,42.88 39.89,42.88 37.6,45.16 37.6,45.93 33.92,49.61 33.92,54.33 33.38,54.87 33.38,59.86 33.55,60.03 33.55,67.38 32.65,68.28 32.65,68.91 32.41,69.15 32.04,69.15 31.8,69.39 31.8,70.02 30.77,71.05 29.88,71.05 29.65,70.82 29.65,70.41 29.86,70.2 29.86,69.96 v1(30.18,69.65)
BMC_JTAG_SEL: length 326.9
  L12_SIG4 w0.089: v1(251.21,52.4) 250.54,51.73 249.71,51.73 247.55,49.57 247.55,36.1 248.39,35.25 248.39,27.54 249.12,26.81 249.12,26.04 248.71,25.63 242.38,25.63 242.02,25.27 231.38,25.27 225.49,19.38 221.22,19.38 220.19,18.35 218.8,18.35 215.61,15.16 212.68,15.16 211.91,14.39 154.45,14.39 151.54,17.3 151.54,19.69 149.56,21.67 146.73,21.67 145.46,22.94 144.18,22.94 142.31,24.81 134.96,24.81 133.49,23.33 133.49,19.37 132.12,18.01 132.12,17.15 130.21,15.24 118.84,15.24 117.82,14.23 88.96,14.23 88.58,13.85 84.46,13.85 83.7,14.61 76.93,14.61 76.66,14.87 74.01,14.87 69.55,19.33 69.55,21.07 68.14,22.48 67.67,22.48 66.44,23.71 66.44,25.55 65.34,26.65 64.85,26.65 64.55,26.95 64.55,27.23 64.22,27.56 63.76,27.56 63.38,27.94 63.38,33.35 59.11,37.61 55.69,37.61 54.62,38.69 49.79,38.69 48.83,37.72 43.24,37.72 39.96,41 39.96,41.46 34.2,47.22 33.28,47.22 30.13,50.37 30.13,50.88 29.83,51.18 29.5,51.18 29.11,51.57 29.11,55.51 26.85,57.76 26.85,60.84 24.34,63.35 23.68,63.35 20.7,66.33 20.7,70.86 21,71.16 21.36,71.16 21.65,71.46 21.65,72.96 21.88,73.18 22.49,73.18 22.71,73.41 22.71,73.89 23.07,74.25 23.53,74.25 23.68,74.4 23.68,75.92 23.96,76.2 24.5,76.2 24.71,76.41 24.71,77.86 24.3,78.26 22.99,78.26 22.79,78.46 22.79,80.04 v1(22.18,80.65)
BUF1_Q0_N: length 3.1
  BOTTOM w0.102: U26.13 20.73,30.4 20.86,30.54 20.86,30.72 20.71,30.86 19.95,30.86 19.45,31.37 19.45,31.63 R289.2
BUF1_Q0_P: length 3.1
  BOTTOM w0.102: R288.2 19.68,31.63 19.68,31.46 20.05,31.09 20.81,31.09 21.09,30.81 21.09,30.56 21.23,30.42 U26.14
BUF1_Q1_N: length 2.6
  BOTTOM w0.102: U26.16 22.23,30.4 22.36,30.54 22.36,30.95 22.75,31.34 22.97,31.34 23.13,31.5 23.13,31.63 R291.2
BUF1_Q1_P: length 2.6
  BOTTOM w0.102: U26.17 22.73,30.42 22.59,30.56 22.59,30.86 22.84,31.11 23.07,31.11 23.36,31.41 23.36,31.63 R290.2
BUF2_Q0_N: length 3.1
  BOTTOM w0.102: R311.2 24.31,50.49 24.07,50.49 23.63,50.04 23.63,49.3 23.41,49.08 23.22,49.08 23.09,49.21 U27.13
BUF2_Q0_P: length 3.1
  BOTTOM w0.102: R310.2 24.31,50.26 24.17,50.26 23.86,49.95 23.86,49.2 23.5,48.85 23.22,48.85 23.08,48.71 U27.14
BUF2_Q1_N: length 2.6
  BOTTOM w0.102: R313.1 24.31,46.8 24.19,46.8 24.03,46.96 24.03,47.19 23.64,47.57 23.23,47.57 23.09,47.71 U27.16
BUF2_Q1_P: length 2.6
  BOTTOM w0.102: U27.17 23.11,47.21 23.24,47.34 23.55,47.34 23.8,47.09 23.8,46.87 24.1,46.57 24.31,46.57 R312.1
BUFF1_IMP_SEL: length 6.7
  BOTTOM w0.149: U26.19 23.73,30.45 24.21,30.94 25.47,30.94 26.17,31.64 26.17,33.29 R293.1 R295.1
BUFF1_OE0N: length 3.2
  BOTTOM w0.149: R298.1 R299.1 24.65,23.07 24.23,23.48 U26.31
BUFF1_OE1N: length 3.5
  BOTTOM w0.149: R300.1 R301.1 23.73,23.23 U26.32
BUFF1_OE2N: length 2.5
  BOTTOM w0.149: U26.36 21.73,23.26 R303.1
BUFF1_OE3N: length 2.9
  BOTTOM w0.149: U26.37 21.23,23.46 20.96,23.19 20.64,23.19 R305.1
BUFF2_IMP_SEL: length 4.8
  BOTTOM w0.149: R317.1 R315.1 23.71,44.39 23.71,45.21 23.49,45.43 23.49,45.9 23.18,46.21 U27.19
BUFF2_OE0N: length 2.7
  BOTTOM w0.149: U27.31 15.22,45.71 R320.1 R321.1
BUFF2_OE1N: length 2.9
  BOTTOM w0.149: R323.1 R322.1 15.66,46.21 U27.32
BUFF2_OE2N: length 1.9
  BOTTOM w0.149: R324.1 15.7,48.21 U27.36
BUFF2_OE3N: length 2.1
  BOTTOM w0.149: U27.37 16.21,48.71 R325.1
C_PTP_SAMPLE_CLK_250M_N: length 4
  TOP w0.102: C390.1 64.66,56.64 64.66,56.48 64.33,56.15 R748.1 64.33,56.02 64.66,55.69 64.66,55.56 64.5,55.4 64.33,55.4 63.89,54.97 63.89,54.39 63.76,54.25 U23.24
C_PTP_SAMPLE_CLK_250M_P: length 4
  TOP w0.102: U23.23 64.26,54.27 64.12,54.41 64.12,54.87 64.42,55.17 64.6,55.17 64.89,55.46 64.89,55.69 65.22,56.02 R748.2 65.22,56.15 64.89,56.48 64.89,56.64 C389.1
C_QSFP_REFCLK_N: length 4.4
  TOP w0.102: U23.21 65.26,54.25 65.39,54.39 65.39,54.76 66.08,55.45 66.57,55.45 66.69,55.58 66.69,55.69 66.36,56.02 R750.1 66.36,56.15 66.69,56.48 66.69,56.64 C396.1
C_QSFP_REFCLK_P: length 4.4
  TOP w0.102: C393.1 66.92,56.64 66.92,56.48 67.25,56.15 R750.2 67.25,56.02 66.92,55.69 66.92,55.48 66.66,55.22 66.17,55.22 65.62,54.67 65.62,54.4 65.76,54.27 U23.20
C_QSFPDD_REFCLK_N: length 4.9
  TOP w0.102: C392.1 68.73,56.64 68.73,56.48 68.4,56.15 R749.1 68.4,56.02 68.73,55.69 68.73,55.46 68.31,55.04 67.3,55.04 66.89,54.64 66.89,54.39 66.76,54.25 U23.18
C_QSFPDD_REFCLK_P: length 4.9
  TOP w0.102: U23.17 67.26,54.24 67.12,54.38 67.12,54.54 67.39,54.82 68.4,54.82 68.96,55.37 68.96,55.69 69.29,56.02 R749.2 69.29,56.15 68.96,56.48 68.96,56.64 C391.1
C_TOD_MASTER_CLK_125M_N: length 3.6
  TOP w0.102: U23.54 62.26,44.64 62.39,44.5 62.39,44.37 62.19,44.17 61.99,44.17 61.74,43.93 61.74,43.65 61.41,43.32 R747.1 61.41,43.2 61.74,42.87 61.74,42.7 C388.1
C_TOD_MASTER_CLK_125M_P: length 3.6
  TOP w0.102: C387.1 61.97,42.7 61.97,42.87 62.3,43.2 R747.2 62.3,43.32 61.97,43.65 61.97,43.83 62.08,43.94 62.29,43.94 62.62,44.28 62.62,44.53 62.76,44.67 U23.55
CFG_IMAGE0: length 32.6
  TOP w0.149: v1(33.09,64.47) 33.09,64.4 31.31,62.62 Q19.1 ; U5.C5 32.21,79.65 32.71,80.15 34.61,80.15 v1(35.19,80.72)
  L03_SIG1 w0.081: v1(33.09,64.47) 33.53,64.91 36.62,64.91 39.05,67.33 39.05,68.84 39.76,69.55 40.32,69.55 40.77,70.01 40.77,74.37 39.76,75.39 38.87,75.39 38.23,76.02 35.4,76.02 34.81,76.62 34.81,80.34 v1(35.19,80.72)
CFG_IMAGE1: length 27.7
  TOP w0.149: Q20.1 23.5,62.62 R6889.2 23.31,62.63 v1(22.61,61.93)
  L07_SIG3 w0.089: v1(33.18,80.65) 33.66,80.17 33.66,77.29 32.77,76.41 32.77,75.64 32.27,75.14 30.74,75.14 29.73,74.12 29.73,71.58 28.71,70.56 28.71,68.15 27.31,66.75 27.31,65.61 24.9,63.2 23.88,63.2 v1(22.61,61.93)
CIPRI_HIGH_REFCLK_N: length 29
  L07_SIG3 w0.081: 80.83,53.99 80.85,53.99 80.87,54.01 81.17,54.01 81.59,53.59 82.08,53.59 82.47,53.98 82.81,53.98 83.15,53.64 83.31,53.57 83.64,53.57 83.79,53.66 83.97,53.97 84.04,54.01 84.51,54.01 84.64,54.14 84.68,54.21 84.8,54.24 v1(85.04,54.11)
  L07_SIG3 w0.085: v1(62.11,57.93) 62.41,57.93 62.5,57.84 62.5,56.71 63.98,55.24 67.87,55.24 69.8,53.3 70.97,53.3 73.3,50.97 74.23,50.97 74.36,50.93 v1(74.56,50.55) 74.93,50.74 75.14,50.68 75.39,50.68 78.25,53.54 79.97,53.54 80.43,53.99 80.83,53.99
CIPRI_HIGH_REFCLK_P: length 29.1
  L07_SIG3 w0.081: v1(84.24,54.57) 84.48,54.43 84.51,54.31 84.48,54.26 84.43,54.21 83.99,54.21 83.82,54.11 83.65,53.8 83.58,53.77 83.35,53.77 83.26,53.81 82.89,54.17 82.39,54.17 82,53.78 81.67,53.78 81.25,54.21 80.87,54.21 80.85,54.22 80.83,54.22
  L07_SIG3 w0.085: v1(63.13,57.93) 62.82,57.93 62.73,57.84 62.73,56.81 62.92,56.61 63.03,56.61 63.1,56.68 63.21,56.68 63.35,56.53 63.35,56.42 63.29,56.36 63.29,56.25 64.07,55.46 67.96,55.46 69.89,53.53 71.06,53.53 73.4,51.2 74.26,51.2 74.43,51.14 v1(74.81,51.34) 75,50.96 75.17,50.9 75.29,50.9 78.15,53.77 79.07,53.77 79.17,53.87 79.17,54 79.27,54.1 79.43,54.1 79.53,54 79.53,53.87 79.63,53.77 79.88,53.77 80.33,54.22 80.83,54.22
CIPRI_LOW_REFCLK_N: length 30.5
  L07_SIG3 w0.081: v1(84.24,58.25) 84.24,57.99 84.14,57.89 83.92,57.89 83.78,57.74 83.64,57.39 83.64,57.18 83.79,56.92 83.79,56.71 83.57,56.49 83.31,56.49 83.07,56.35 82.91,56.07 82.8,56.01 82.42,56.01 82.03,55.62 81.68,55.62 81.27,56.03 80.78,56.03 80.77,56.04 80.74,56.04
  L07_SIG3 w0.085: v1(60.08,57.93) 60.38,57.93 60.47,58.02 60.47,58.81 61.02,59.36 63.35,59.36 63.81,58.9 63.81,57.69 65.04,56.47 70.1,56.47 70.54,56.91 74.68,56.91 75.45,56.14 75.65,56.14 v1(75.93,56.42) 76.69,56.42 76.97,56.14 77.48,56.14 78.01,55.6 78.92,55.6 79.12,55.79 79.32,55.79 79.51,55.6 79.81,55.6 80.25,56.04 80.74,56.04
CIPRI_LOW_REFCLK_P: length 30.4
  L07_SIG3 w0.081: 80.74,55.81 80.77,55.81 80.78,55.83 81.19,55.83 81.6,55.43 82.11,55.43 82.5,55.81 82.85,55.81 83.06,55.93 83.21,56.2 83.37,56.29 83.65,56.29 83.99,56.63 83.99,56.97 83.84,57.23 83.84,57.35 83.95,57.63 84.01,57.69 84.16,57.69 84.24,57.61 v1(84.24,57.33)
  L07_SIG3 w0.085: 80.74,55.81 80.34,55.81 79.9,55.37 77.92,55.37 77.38,55.91 76.94,55.91 76.66,55.63 v1(75.93,55.63) 75.65,55.91 75.35,55.91 74.58,56.68 70.63,56.68 70.19,56.24 64.94,56.24 63.58,57.6 63.58,58.8 63.25,59.13 62.52,59.13 62.42,59.03 62.42,58.94 62.32,58.84 62.13,58.84 62.03,58.94 62.03,59.03 61.93,59.13 61.12,59.13 60.7,58.72 60.7,58.02 60.79,57.93 v1(61.09,57.93)
CLK_100M_CXL_CONN_C_N: length 3.8
  TOP w0.102: R226.1 12.61,79.41 12.02,79.41 11.64,79.03 10.21,79.03 10.01,78.83 J9.B12
CLK_100M_CXL_CONN_C_P: length 3.8
  TOP w0.102: J9.B11 10.03,79.43 10.21,79.26 11.54,79.26 11.92,79.64 12.59,79.64 R225.1
CLK_CXL_CONN_N: length 33.9
  L03_SIG1 w0.079: v4(13.82,79.14) 13.54,79.41 12.76,79.41 12.2,78.85 12.2,78.6 12.35,78.45 12.35,78.2 12.2,78.05 12.2,77.8 12.35,77.65 12.35,77.39 12.2,77.25 12.2,76.99 12.35,76.85 12.35,76.59 12.2,76.44 12.2,74.88 13.21,73.87 13.98,72.02 13.98,68.91 13.6,68.53 13.6,61.8 14.76,60.63 15.72,60.63 18.16,58.2 18.16,55.02 v1(18.55,54.63)
  BOTTOM w0.102: v1(18.55,54.63) 18.16,54.23 18.16,52.29 18.43,52.01 18.43,51.36 18.57,51.22 U27.3
CLK_CXL_CONN_P: length 33.9
  L03_SIG1 w0.079: v1(17.53,54.63) 17.93,55.02 17.93,58.11 15.63,60.4 14.67,60.4 13.37,61.71 13.37,68.63 13.75,69.01 13.75,71.98 13.02,73.74 11.97,74.79 11.97,78.95 12.67,79.64 13.54,79.64 v4(13.82,79.92)
  BOTTOM w0.102: v1(17.53,54.63) 17.93,54.23 17.93,52.19 18.2,51.92 18.2,51.35 18.07,51.21 U27.2
CLK_CXL_EP_N: length 23.6
  L03_SIG1 w0.079: v1(6.23,53.48) 5.84,53.88 5.84,54.3 6.1,54.56 6.67,54.56 8.93,52.3 12.36,52.3 12.65,52.01 20.26,52.01 21.08,52.82 21.08,54.23 v1(21.47,54.63)
  BOTTOM w0.102: v1(21.47,54.63) 21.08,54.23 21.08,52.14 20.93,51.99 20.93,51.35 21.07,51.21 U27.8
CLK_CXL_EP_P: length 23.6
  L03_SIG1 w0.079: v1(20.45,54.63) 20.85,54.23 20.85,52.92 20.17,52.24 12.75,52.24 12.45,52.53 9.02,52.53 6.76,54.79 6.01,54.79 5.61,54.39 5.61,53.88 v1(5.21,53.48)
  BOTTOM w0.102: U27.7 20.57,51.22 20.7,51.36 20.7,52.09 20.85,52.23 20.85,54.23 v1(20.45,54.63)
CLK_FPGA_100M_N: length 52.8
  L07_SIG3 w0.085: v1(75.25,74.5) 74.51,74.5 74.18,74.17 73.44,74.17 71.19,71.92 71.19,71.53 69.29,69.63 69.29,67.08 68.17,65.95 64.23,65.95 61.45,63.17 57.61,63.17 53.48,59.05 53.48,45.77 54.03,45.22 54.03,43.49 55.22,42.31 59.25,42.31 59.71,41.85 59.71,41.52 59.61,41.42 v1(59.32,41.42)
CLK_FPGA_100M_P: length 52.8
  L07_SIG3 w0.085: v1(60.33,41.42) 60.03,41.42 59.94,41.51 59.94,41.94 59.35,42.54 55.31,42.54 54.26,43.59 54.26,45.31 53.71,45.86 53.71,58.95 57.7,62.94 61.54,62.94 64.33,65.73 68.26,65.73 69.52,66.98 69.52,69.54 71.42,71.44 71.42,71.82 72.84,73.25 72.99,73.25 73.06,73.18 73.21,73.18 73.34,73.31 73.34,73.45 73.26,73.53 73.26,73.67 73.53,73.94 74.2,73.94 74.53,73.61 v1(75.25,73.61)
CLK_REF4P: length 2.2
  TOP w0.149: R6837.2 69.35,46.81 68.93,47.23 U23.4
CPU_1V2_RESETN: length 297.2
  L03_SIG1 w0.081: v1(209.81,100.03) 209.43,100.41 209.43,102.39 209.63,102.59 210.13,102.59 211.48,103.94 218.14,103.94 220.02,102.06 220.02,86.39 221.6,84.81 221.6,75.73 224.29,73.04 224.29,67.44 221.44,64.59 221.44,61.72 220.33,60.61 220.33,41.58 219.39,40.64 219.39,33.94 223.22,30.1 223.22,28.25 225,26.47 225,22.42 223.73,21.15 223.73,19.6 224.21,19.13 224.21,17.71 v1(223.62,17.13)
  L07_SIG3 w0.089: v1(87.43,41.69) 86.78,41.04 85.42,41.04 84.87,40.49 83.45,40.49 82.35,39.4 81.72,39.4 79.58,37.25 79.58,37.09 77.45,34.96 77.45,25.08 76.92,24.55 75.64,24.55 75.39,24.29 75.39,24 74.91,23.52 74.91,22.32 74.59,22 74.59,21.12 73.79,20.32 73.79,17.11 75.49,15.41 85.44,15.41 86.04,14.81 112.66,14.81 113.34,14.13 133.74,14.13 135.53,15.92 154.91,15.92 155.33,16.33 162.82,16.33 163.13,16.03 178.8,16.03 179.1,16.33 185.83,16.33 186.25,15.92 216.54,15.92 219.13,18.52 219.74,18.52 220.35,19.13 221.65,19.13 222.46,18.32 223.02,18.32 223.35,18.65 223.78,18.65 224.09,18.34 224.09,17.59 v1(223.62,17.13)
  BOTTOM w0.149: v1(209.81,100.03) 210.08,99.75 U88.2
CPU_RESETN: length 231.6
  L07_SIG3 w0.089: v1(45.22,107.9) 44.57,107.25 43.8,107.25 41.98,105.43 38.68,105.43 37.47,104.22 37.47,95.81 38.49,94.8 38.49,91.72 36.38,89.62 36.38,88.74 34.65,87.01 34.65,76.38 32.65,74.37 32.65,70.18 v1(33.18,69.65)
  L12_SIG4 w0.089: v1(211.85,106.5) 202.32,106.5 198.62,110.21 141.11,110.21 140.93,110.39 47.96,110.39 46.11,108.54 45.85,108.54 v1(45.22,107.9)
  L16_SIG6 w0.081: v1(215.4,98) 215.02,98.38 214.87,98.38 212.81,100.43 212.81,103.13 211.85,104.08 v1(211.85,106.5)
  BOTTOM w0.149: v1(215.4,98) 215.4,99.39 215.17,99.62 213.46,99.62 213.32,99.75 U88.10 ; R777.2 R418.2
CXL_PERSTN: length 280.6
  TOP w0.149: J9.A11 v1(5.32,79.43)
  L05_SIG2 w0.081: v1(5.32,79.43) 4.38,80.37 4.38,89.16 6.46,91.24 6.46,98.2 12.83,104.57 12.83,105.23 18.07,110.47 43.59,110.47 45.68,108.38 49.11,108.38 50.05,107.44 50.43,107.44 53.02,104.85 v1(54.62,104.85)
  L07_SIG3 w0.089: v1(229.13,106.44) 226.77,106.44 226.19,105.87 223.02,105.87 221.5,107.39 218.22,107.39 215.55,104.73 215.55,100.82 v1(214.89,100.15) 214.46,100.59 208.49,100.59 208.03,100.13 203.97,100.13 201.3,102.8 201.3,105.09 198.49,107.9 194.44,107.9 193.73,108.61 140.16,108.61 139.43,109.35 130.79,109.35 130.33,108.89 118.9,108.89 118.45,109.35 102.45,109.35 102.19,109.1 100.77,109.1 100.51,109.35 87.89,109.35 87.64,109.1 81.8,109.1 81.54,109.35 73.67,109.35 73.08,108.77 56.32,108.77 55.61,108.05 55.61,105.85 v1(54.62,104.85)
  BOTTOM w0.149: R227.1 6.7,71.04 7.25,71.58 7.25,77.5 v1(5.32,79.43) ; R767.2 v1(229.13,106.44) ; U12.2 54.87,105.11 v1(54.62,104.85)
CXL_PERSTX1_N:
  vias: v1(6.6,68.63)
CXL_PRSNTX4_N: length 53.3
  TOP w0.149: v1(4.45,79.45) 5.07,78.83 J9.A12
  BOTTOM w0.149: v1(4.45,79.45) 4.96,79.96 5.98,79.96 6.92,79.02 8.57,79.02 9.36,78.23 9.36,67.62 10.04,66.94 10.04,62.03 14.7,57.37 17.75,57.37 19.51,59.13 25.92,59.13 26.8,60.02 26.8,62.63 R789.1 29.55,62.69 30.36,63.5 30.36,64.26 30.59,64.5 U22.13
CXL_RX_N0: length 90.5
  TOP w0.149: J9.A3 5.12,84.23
  L16_SIG6 w0.085: 5.12,84.23 4.92,84.43 4.65,84.43 4.4,84.68 4.4,85.39 4.52,85.68 4.76,85.91 4.98,86.01 5.18,86.01 5.49,85.88 5.79,85.68 6.58,85.68 7.29,86.17 8.07,86.31 16.11,86.31 24.4,87.96 29.01,87.96 36.09,86.55 37.96,85.88 38.86,85.32 39.32,84.85 39.58,84.23 39.58,82.61 39.9,81.83 42.59,79.15 43.06,78.44 43.29,77.89 43.29,73.81 43.36,73.62 43.71,73.28 44.05,73.14 57.92,73.14 59.5,73.79 68.17,73.79 69.36,73.55 70.63,73.03 72.02,73.03 72.83,73.36 74.6,73.36 75,73.2 76.37,71.82 76.77,71.66 78.02,71.66 78.68,71.38 arc(78.93,71.23) 79.11,71.01 79.18,70.88 arc(79.24,70.82) 79.33,70.79 79.57,70.79 arc(79.74,70.75) 79.87,70.62 79.89,70.59 arc(79.95,70.54) 80.02,70.53 U8.CD54
CXL_RX_N1: length 90.9
  TOP w0.149: J9.A6 5.12,82.43
  L16_SIG6 w0.085: 5.12,82.43 5.32,82.63 7.64,82.63 8.53,82.79 10.29,84.02 11.02,84.15 11.55,84.15 16.67,85.17 18.33,85.86 23.92,86.97 27.54,86.97 28.46,86.79 30.01,86.15 32.77,85.6 36.99,85.18 38.01,84.7 38.41,84.3 38.64,83.74 38.64,82.66 38.93,81.21 40.24,78.05 41.51,76.78 42.07,75.44 42.07,73.74 42.52,72.64 43.41,71.75 43.84,71.57 58.08,71.57 59.84,72.3 64.31,72.3 66.02,71.96 68.04,71.13 68.54,71.03 75.04,71.03 arc(75.58,70.92) 76.04,70.61 76.13,70.53 arc(76.61,70.2) 77.17,70.09 78.71,70.09 arc(78.83,70.06) 78.93,69.97 79.01,69.81 arc(79.15,69.68) 79.35,69.62 79.55,69.62 arc(79.67,69.59) 79.75,69.49 79.77,69.44 arc(79.91,69.27) 80.12,69.21 80.38,69.21 arc(80.61,69.28) 80.76,69.46 80.78,69.5 arc(80.87,69.61) 81,69.65 81.11,69.65 arc(81.24,69.61) 81.33,69.5 81.34,69.47 arc(81.53,69.25) 81.81,69.16 81.96,69.16 arc(82.15,69.22) 82.28,69.36 arc(82.28,69.37) 82.29,69.38 arc(82.34,69.42) 82.41,69.42 U8.CA51
CXL_RX_N2: length 86.3
  TOP w0.149: J9.A15 5.12,77.03
  L16_SIG6 w0.085: U8.BY54 80.02,68.69 arc(79.99,68.62) 80,68.55 80.02,68.52 arc(80.06,68.39) 80.04,68.25 79.97,68.08 arc(79.79,67.86) 79.52,67.78 79.46,67.78 arc(79.32,67.76) 79.21,67.68 79.06,67.53 arc(78.85,67.4) 78.61,67.35 75.62,67.35 74.56,66.91 71.5,66.91 67.94,65.43 61.11,65.43 54.95,62.88 27.76,62.88 25.62,63.3 21.92,63.3 15.06,66.15 14.65,66.55 14.54,66.84 14.54,68.43 13.77,70.27 13.77,72.05 13.16,73.54 11.68,75.02 10.1,75.67 9.02,76.75 7.87,77.23 5.32,77.23 5.12,77.03
CXL_RX_N3: length 87.2
  TOP w0.149: J9.A18 5.12,75.23
  L16_SIG6 w0.085: 5.12,75.23 5.32,75.43 5.63,75.43 6.14,75.22 7.44,73.92 8.65,73.41 9.04,73.03 9.38,72.21 9.38,68.49 9.88,65.66 10.97,64.1 14.12,62.46 24.92,62.46 27.09,62.03 54.92,62.03 61.12,64.59 68.9,64.59 72.22,65.97 74.58,65.97 75.7,65.51 78.61,65.51 arc(78.85,65.56) 79.06,65.69 79.21,65.84 arc(79.32,65.92) 79.46,65.94 79.52,65.94 arc(79.79,66.02) 79.97,66.24 80.04,66.41 arc(80.06,66.55) 80.02,66.68 80,66.71 arc(79.99,66.78) 80.02,66.85 U8.BT54
CXL_RX_P0: length 90.5
  TOP w0.149: J9.A2 5.12,84.83
  L16_SIG6 w0.085: U8.CC55 79.71,70.35 arc(79.74,70.41) 79.72,70.47 79.69,70.52 arc(79.64,70.57) 79.57,70.59 79.33,70.59 arc(79.14,70.64) 79.01,70.78 78.93,70.9 arc(78.79,71.08) 78.6,71.19 77.98,71.45 77.57,71.45 77.43,71.31 77.17,71.31 77.03,71.45 76.73,71.45 76.26,71.65 76.08,71.83 75.88,71.83 75.7,72.01 75.7,72.21 74.88,73.03 74.56,73.16 72.87,73.16 72.06,72.82 70.59,72.82 69.3,73.36 68.15,73.59 59.54,73.59 57.96,72.93 44.01,72.93 43.59,73.11 43.19,73.51 43.08,73.77 43.08,77.85 42.88,78.35 42.43,79.02 39.73,81.72 39.38,82.57 39.38,84.19 39.15,84.74 38.73,85.16 37.87,85.7 36.04,86.36 28.99,87.76 24.42,87.76 16.13,86.11 14.9,86.11 14.8,86.01 14.54,86.01 14.44,86.11 14.18,86.11 14.08,86.01 13.82,86.01 13.72,86.11 13.46,86.11 13.36,86.01 13.11,86.01 13.01,86.11 12.75,86.11 12.65,86.01 12.39,86.01 12.29,86.11 12.03,86.11 11.91,85.99 11.66,85.99 11.54,86.11 11.28,86.11 11.17,85.99 10.91,85.99 10.79,86.11 10.53,86.11 10.42,85.99 10.16,85.99 10.04,86.11 8.09,86.11 7.37,85.98 6.64,85.47 5.73,85.47 5.4,85.7 5.14,85.8 5.02,85.8 4.87,85.74 4.69,85.56 4.6,85.35 4.6,84.76 4.73,84.63 4.92,84.63 5.12,84.83
CXL_RX_P1: length 90.9
  TOP w0.149: J9.A5 5.12,83.03
  L16_SIG6 w0.085: U8.CB52 82.03,69.64 arc(82.1,69.56) 82.09,69.45 arc(82.04,69.39) 81.96,69.37 81.81,69.37 arc(81.64,69.42) 81.53,69.55 81.52,69.58 arc(81.35,69.78) 81.11,69.85 81,69.85 arc(80.75,69.78) 80.59,69.58 80.57,69.54 arc(80.5,69.45) 80.38,69.41 80.12,69.41 arc(80.02,69.44) 79.95,69.52 79.94,69.57 arc(79.78,69.76) 79.55,69.83 79.35,69.83 arc(79.26,69.85) 79.19,69.92 79.1,70.07 arc(78.94,70.23) 78.71,70.3 78.48,70.3 78.38,70.4 78.12,70.4 78.02,70.3 77.76,70.3 77.66,70.4 77.4,70.4 77.3,70.3 77.17,70.3 arc(76.68,70.39) 76.27,70.67 76.18,70.76 arc(75.66,71.11) 75.04,71.23 74.23,71.23 74.16,71.3 73.9,71.3 73.82,71.23 68.56,71.23 68.1,71.32 66.08,72.16 64.33,72.51 59.8,72.51 58.04,71.78 43.89,71.78 43.53,71.93 42.7,72.76 42.27,73.78 42.27,75.48 41.69,76.89 40.41,78.17 39.13,81.27 38.84,82.68 38.84,83.79 38.58,84.41 38.13,84.86 37.04,85.38 32.8,85.8 30.07,86.34 28.52,86.99 27.56,87.18 23.9,87.18 18.27,86.06 16.61,85.37 11.53,84.36 11.01,84.36 10.21,84.22 8.45,82.98 7.63,82.83 5.32,82.83 5.12,83.03
CXL_RX_P2: length 86.3
  TOP w0.149: J9.A14 5.12,77.63
  L16_SIG6 w0.085: U8.BW55 79.69,68.5 arc(79.77,68.5) 79.83,68.45 79.84,68.42 arc(79.86,68.38) 79.85,68.33 79.78,68.16 arc(79.67,68.03) 79.52,67.99 79.46,67.99 arc(79.24,67.94) 79.06,67.82 78.92,67.68 arc(78.78,67.58) 78.61,67.55 78.34,67.55 78.24,67.65 77.98,67.65 77.88,67.55 77.62,67.55 77.52,67.65 77.27,67.65 77.16,67.55 75.58,67.55 74.52,67.11 74.18,67.11 74.07,67.21 73.82,67.21 73.72,67.11 73.46,67.11 73.36,67.21 73.1,67.21 73,67.11 72.74,67.11 72.63,67.23 72.37,67.23 72.26,67.11 71.46,67.11 67.9,65.64 61.07,65.64 54.91,63.08 27.78,63.08 25.64,63.51 21.97,63.51 15.17,66.32 14.83,66.67 14.74,66.88 14.74,68.47 13.98,70.31 13.98,72.09 13.33,73.66 11.79,75.19 10.22,75.85 9.14,76.93 7.91,77.43 5.32,77.43 5.12,77.63
CXL_RX_P3: length 87.2
  TOP w0.149: J9.A17 5.12,75.83
  L16_SIG6 w0.085: U8.BR55 79.69,66.66 arc(79.77,66.66) 79.83,66.61 79.84,66.58 arc(79.86,66.54) 79.85,66.49 79.78,66.32 arc(79.67,66.19) 79.52,66.15 79.46,66.15 arc(79.24,66.1) 79.06,65.98 78.92,65.84 arc(78.78,65.74) 78.61,65.71 78.34,65.71 78.24,65.81 77.98,65.81 77.88,65.71 77.62,65.71 77.52,65.81 77.27,65.81 77.16,65.71 76.91,65.71 76.81,65.81 76.55,65.81 76.45,65.71 75.74,65.71 74.62,66.17 74.36,66.17 74.26,66.28 74,66.28 73.9,66.17 73.64,66.17 73.54,66.28 73.28,66.28 73.18,66.17 72.18,66.17 68.86,64.8 61.08,64.8 54.88,62.23 27.11,62.23 24.94,62.66 14.17,62.66 11.11,64.26 10.07,65.74 9.58,68.51 9.58,72.25 9.21,73.15 8.77,73.59 7.56,74.09 6.25,75.39 5.67,75.63 5.32,75.63 5.12,75.83
CXL_TX_C_N0: length 5.3
  TOP w0.116: J9.B3 10.05,84.23 10.23,84.41 14.47,84.41 C341.2
CXL_TX_C_N1: length 3.3
  TOP w0.116: J9.B6 10.05,82.43 10.23,82.61 12.49,82.61 C343.2
CXL_TX_C_N2: length 5.3
  TOP w0.116: J9.B15 10.05,77.03 10.23,77.21 14.47,77.21 C348.2
CXL_TX_C_N3: length 3.3
  TOP w0.116: C350.2 12.49,75.41 10.23,75.41 10.05,75.23 J9.B18
CXL_TX_C_P0: length 5.3
  TOP w0.116: C340.2 14.47,84.65 10.23,84.65 10.05,84.83 J9.B2
CXL_TX_C_P1: length 3.3
  TOP w0.116: J9.B5 10.05,83.03 10.23,82.85 12.49,82.85 C342.2
CXL_TX_C_P2: length 5.3
  TOP w0.116: J9.B14 10.05,77.63 10.23,77.45 14.47,77.45 C347.2
CXL_TX_C_P3: length 3.3
  TOP w0.116: C349.2 12.49,75.65 10.23,75.65 10.05,75.83 J9.B17
CXL_TX_N0: length 83.8
  L03_SIG1 w0.085: v4(85.04,68.83) 84.8,68.69 arc(84.76,68.64) 84.77,68.57 84.8,68.52 arc(84.84,68.39) 84.82,68.25 84.74,68.05 arc(84.57,67.85) 84.32,67.78 84.13,67.78 arc(83.93,67.83) 83.79,67.98 83.7,68.12 arc(83.64,68.39) 83.72,68.65 83.77,68.72 arc(83.81,68.83) 83.79,68.95 83.73,69.08 arc(83.69,69.31) 83.76,69.54 83.78,69.57 arc(83.82,69.72) 83.78,69.87 83.71,69.99 arc(83.66,70.2) 83.71,70.42 83.79,70.55 arc(83.82,70.67) 83.79,70.78 83.71,70.93 arc(83.68,70.97) 83.63,71 82.88,71.44 arc(82.76,71.49) 82.64,71.5 82.47,71.5 arc(82.3,71.55) 82.18,71.68 82.12,71.81 arc(82.05,71.89) 81.95,71.92 81.85,71.92 arc(81.67,71.96) 81.52,72.06 81.23,72.35 80.68,72.71 80.33,72.86 80.16,72.86 arc(80.06,72.83) 79.99,72.75 79.96,72.67 arc(79.82,72.5) 79.6,72.43 76.9,72.43 76.46,72.25 75.99,72.25 75.31,72.53 74.78,73.06 74.24,73.28 73.16,73.28 72.05,72.82 69.61,72.82 68.38,73.33 63.6,73.33 62.99,73.59 59.77,73.59 58.19,72.93 44.02,72.93 43.54,73.13 42.69,73.98 41.54,76.75 40.28,78.02 39.39,80.16 39.38,80.2 38.75,83.34 38.39,84.22 37.86,84.75 36.86,85.16 36.58,85.22 32.32,85.64 29.59,86.18 27.76,86.94 23.77,86.94 18.59,85.91 16.31,84.96 15.9,84.55 15.6,84.43 15.45,84.43 v4(15.22,84.2)
CXL_TX_N1: length 88.1
  L03_SIG1 w0.085: v4(13.23,82.4) 13.46,82.63 13.78,82.63 14.03,82.53 14.23,82.33 14.46,81.77 14.46,78.79 14.1,77.93 14.1,76.92 14.31,76.42 15.96,74.77 17.34,71.44 17.34,66.74 17.43,66.53 18.79,65.17 23.62,63.17 26.02,63.17 27.8,62.43 32.62,62.43 33.03,62.6 53.25,62.6 60.64,65.66 67.95,65.66 70.61,66.77 72.64,68.12 73.18,68.66 73.61,68.84 74.58,68.84 75.31,68.53 76.07,68.53 76.34,68.64 76.84,69.14 77.01,69.21 78.69,69.21 arc(78.87,69.25) 79.02,69.35 79.24,69.56 arc(79.31,69.61) 79.39,69.62 79.54,69.62 arc(79.66,69.59) 79.74,69.49 arc(79.91,69.29) 80.16,69.21 80.31,69.21 arc(80.45,69.17) 80.55,69.07 80.64,68.9 arc(80.76,68.78) 80.93,68.74 80.99,68.74 arc(81.15,68.71) 81.28,68.62 81.36,68.54 arc(81.42,68.42) 81.39,68.29 81.31,68.16 arc(81.25,67.95) 81.29,67.73 81.32,67.65 arc(81.52,67.41) 81.81,67.32 81.96,67.32 arc(82.13,67.37) 82.26,67.5 82.28,67.53 arc(82.34,67.58) 82.41,67.58 v4(82.65,67.45)
CXL_TX_N2: length 87.9
  L03_SIG1 w0.085: v4(85.04,66.99) 84.8,66.85 arc(84.76,66.8) 84.77,66.73 84.8,66.68 arc(84.84,66.55) 84.82,66.41 84.74,66.21 arc(84.57,66.01) 84.32,65.94 84.13,65.94 arc(83.93,65.99) 83.79,66.14 83.7,66.28 arc(83.64,66.55) 83.72,66.81 83.79,66.91 arc(83.82,67) 83.8,67.09 83.77,67.17 arc(83.67,67.3) 83.51,67.35 83.42,67.35 arc(83.19,67.41) 83.02,67.58 82.94,67.71 arc(82.89,67.9) 82.92,68.1 82.95,68.19 arc(82.99,68.39) 82.94,68.59 arc(82.88,68.8) 82.92,69.02 83,69.15 arc(83.04,69.29) 83,69.44 82.92,69.58 arc(82.87,69.77) 82.92,69.96 82.96,70.03 arc(83,70.16) 82.98,70.3 82.96,70.34 arc(82.84,70.49) 82.66,70.54 82.54,70.54 arc(82.31,70.61) 82.16,70.8 82.13,70.86 arc(82.05,70.96) 81.92,71 81.83,71 arc(81.67,71.04) 81.53,71.13 81.25,71.41 arc(81.14,71.48) 81.01,71.51 80.94,71.51 arc(80.7,71.58) 80.54,71.77 80.52,71.82 arc(80.45,71.91) 80.34,71.95 80.16,71.95 arc(80.06,71.92) 80,71.84 79.95,71.72 arc(79.82,71.57) 79.63,71.51 77.17,71.51 76,71.03 63.27,71.03 61.96,70.48 61.19,69.71 60.51,69.43 59.99,68.9 59.04,66.61 58.39,65.96 57.79,65.71 43.07,65.71 42.32,65.4 40.69,63.77 39.85,63.42 31.43,63.42 30.75,63.14 28.34,63.14 26.28,63.99 25.47,63.99 19.28,66.56 18.8,67.04 18.59,67.55 18.59,70.68 16.02,76.87 15.66,77.23 15.45,77.23 v4(15.22,77)
CXL_TX_N3: length 81.1
  L03_SIG1 w0.085: v4(82.65,65.61) 82.43,65.73 arc(82.37,65.74) 82.31,65.7 82.28,65.64 arc(82.16,65.53) 82,65.48 81.81,65.48 arc(81.51,65.57) 81.32,65.81 81.28,65.91 arc(81.25,66.11) 81.3,66.3 81.35,66.39 arc(81.39,66.58) 81.31,66.76 81.23,66.83 arc(81.15,66.89) 81.04,66.91 80.95,66.91 arc(80.77,66.96) 80.64,67.09 80.56,67.23 arc(80.46,67.33) 80.32,67.37 80.1,67.37 arc(79.91,67.42) 79.79,67.57 79.75,67.65 arc(79.67,67.75) 79.55,67.78 79.38,67.78 arc(79.31,67.77) 79.25,67.73 79.02,67.51 arc(78.87,67.41) 78.69,67.37 75.89,67.37 72.38,65.92 71.16,65.92 68.09,64.65 60.59,64.65 53.56,61.74 27.08,61.74 25.47,62.4 23.19,62.4 17.7,64.68 16.1,66.27 15.93,66.68 15.93,71.01 14.29,74.97 13.73,75.43 13.46,75.43 v4(13.23,75.2)
CXL_TX_P0: length 83.8
  L03_SIG1 w0.085: v4(15.22,84.86) 15.45,84.63 15.56,84.63 15.79,84.73 16.2,85.14 18.53,86.1 23.75,87.14 27.8,87.14 29.65,86.38 32.35,85.84 36.61,85.42 36.92,85.36 37.44,85.14 37.98,84.92 38.56,84.34 38.95,83.4 39.57,80.26 40.45,78.13 41.72,76.87 42.87,74.09 43.66,73.3 44.06,73.14 58.15,73.14 59.73,73.79 63.03,73.79 63.64,73.54 68.42,73.54 69.65,73.03 70.19,73.03 70.31,73.14 70.56,73.14 70.68,73.03 72.01,73.03 73.12,73.48 73.6,73.48 73.7,73.58 73.99,73.58 74.09,73.48 74.28,73.48 74.89,73.23 75.42,72.7 76.03,72.45 76.42,72.45 76.86,72.63 77.23,72.63 77.32,72.72 77.6,72.72 77.69,72.63 77.94,72.63 78.04,72.73 78.3,72.73 78.4,72.63 78.66,72.63 78.78,72.75 79.03,72.75 79.15,72.63 79.6,72.63 arc(79.7,72.66) 79.77,72.75 79.81,72.83 arc(79.95,73) 80.16,73.07 80.37,73.07 80.78,72.9 81.36,72.51 81.66,72.2 arc(81.75,72.15) 81.85,72.13 81.95,72.13 arc(82.16,72.06) 82.3,71.9 82.36,71.77 arc(82.41,71.72) 82.47,71.71 82.64,71.71 arc(82.81,71.68) 82.98,71.61 83.74,71.18 arc(83.82,71.11) 83.88,71.03 83.97,70.89 arc(84.02,70.67) 83.97,70.45 83.89,70.32 arc(83.86,70.2) 83.89,70.09 83.96,69.98 arc(84.02,69.72) 83.96,69.47 83.94,69.44 arc(83.9,69.3) 83.92,69.16 83.98,69.02 arc(84.01,68.81) 83.94,68.61 83.89,68.54 arc(83.84,68.38) 83.88,68.22 83.96,68.08 arc(84.03,68.01) 84.13,67.98 84.32,67.98 arc(84.46,68.02) 84.55,68.13 84.63,68.33 arc(84.64,68.38) 84.62,68.42 84.59,68.48 arc(84.54,68.51) 84.48,68.51 v4(84.24,68.37)
CXL_TX_P1: length 88.1
  L03_SIG1 w0.085: v4(13.23,83.06) 13.46,82.83 13.82,82.83 14.14,82.7 14.4,82.44 14.66,81.81 14.66,78.75 14.31,77.89 14.31,76.96 14.48,76.53 16.13,74.89 17.54,71.48 17.54,66.78 17.6,66.64 18.9,65.34 23.66,63.37 26.06,63.37 27.84,62.63 32.58,62.63 32.99,62.8 53.21,62.8 60.6,65.86 67.91,65.86 70.52,66.95 72.51,68.28 73.07,68.83 73.57,69.04 74.62,69.04 75.35,68.74 76.03,68.74 76.23,68.82 76.72,69.31 76.97,69.41 77.19,69.41 77.29,69.51 77.54,69.51 77.65,69.41 77.9,69.41 78.02,69.53 78.28,69.53 78.39,69.41 78.69,69.41 arc(78.79,69.43) 78.88,69.49 79.09,69.7 arc(79.23,69.79) 79.39,69.83 79.54,69.83 arc(79.77,69.76) 79.93,69.57 arc(80.02,69.46) 80.16,69.41 80.31,69.41 arc(80.55,69.35) 80.72,69.18 80.82,69.01 arc(80.87,68.96) 80.93,68.94 80.99,68.94 arc(81.23,68.9) 81.42,68.76 81.5,68.68 arc(81.62,68.45) 81.57,68.19 81.49,68.05 arc(81.45,67.93) 81.47,67.81 81.51,67.73 arc(81.63,67.58) 81.81,67.53 81.96,67.53 arc(82.03,67.55) 82.08,67.6 82.11,67.65 arc(82.13,67.71) 82.1,67.77 v4(81.85,67.91)
CXL_TX_P2: length 87.9
  L03_SIG1 w0.085: v4(15.22,77.66) 15.45,77.43 15.75,77.43 16.2,76.98 18.79,70.72 18.79,67.59 18.97,67.16 19.39,66.73 25.51,64.2 26.32,64.2 28.38,63.35 30.71,63.35 31.39,63.63 39.81,63.63 40.58,63.95 42.21,65.57 43.03,65.92 57.75,65.92 58.27,66.13 58.87,66.73 59.82,69.02 60.4,69.6 61.07,69.88 61.85,70.66 63.23,71.23 72.31,71.23 72.41,71.33 72.66,71.33 72.76,71.23 73.02,71.23 73.12,71.33 73.37,71.33 73.48,71.23 73.73,71.23 73.83,71.33 74.08,71.33 74.19,71.23 75.96,71.23 77.13,71.71 77.94,71.71 78.04,71.81 78.3,71.81 78.4,71.71 78.66,71.71 78.78,71.83 79.03,71.83 79.15,71.71 79.63,71.71 arc(79.71,71.74) 79.76,71.8 79.81,71.91 arc(79.95,72.09) 80.16,72.15 80.34,72.15 arc(80.56,72.08) 80.71,71.9 80.73,71.85 arc(80.81,71.75) 80.94,71.71 81.01,71.71 arc(81.22,71.67) 81.39,71.56 81.67,71.27 arc(81.75,71.22) 81.83,71.21 81.92,71.21 arc(82.16,71.13) 82.32,70.94 82.35,70.88 arc(82.43,70.78) 82.54,70.75 82.66,70.75 arc(82.95,70.66) 83.15,70.42 83.16,70.38 arc(83.2,70.15) 83.14,69.93 83.1,69.86 arc(83.07,69.77) 83.1,69.68 83.18,69.54 arc(83.24,69.29) 83.18,69.05 83.11,68.92 arc(83.08,68.8) 83.12,68.69 arc(83.19,68.4) 83.14,68.11 83.11,68.02 arc(83.09,67.92) 83.12,67.81 83.2,67.68 arc(83.29,67.58) 83.42,67.55 83.51,67.55 arc(83.78,67.47) 83.96,67.25 83.99,67.17 arc(84.02,66.98) 83.95,66.79 83.89,66.7 arc(83.84,66.54) 83.88,66.38 83.96,66.24 arc(84.03,66.17) 84.13,66.14 84.32,66.14 arc(84.46,66.18) 84.55,66.29 84.63,66.49 arc(84.64,66.54) 84.62,66.58 84.59,66.64 arc(84.54,66.67) 84.48,66.67 v4(84.24,66.53)
CXL_TX_P3: length 81.2
  L03_SIG1 w0.085: v4(13.23,75.86) 13.46,75.63 13.81,75.63 14.46,75.1 16.14,71.05 16.14,66.72 16.27,66.39 17.82,64.85 23.23,62.61 25.51,62.61 27.12,61.94 53.52,61.94 60.55,64.85 68.05,64.85 71.12,66.12 72.33,66.12 75.85,67.57 77.17,67.57 77.25,67.66 77.56,67.66 77.65,67.57 77.91,67.57 78.01,67.67 78.3,67.67 78.39,67.57 78.69,67.57 arc(78.79,67.59) 78.88,67.65 79.1,67.87 arc(79.23,67.96) 79.38,67.99 79.55,67.99 arc(79.79,67.92) 79.94,67.73 79.97,67.65 arc(80.02,67.59) 80.1,67.57 80.32,67.57 arc(80.56,67.51) 80.73,67.33 80.82,67.19 arc(80.87,67.13) 80.95,67.11 81.04,67.11 arc(81.22,67.08) 81.38,66.97 81.45,66.9 arc(81.59,66.61) 81.53,66.29 81.48,66.2 arc(81.45,66.1) 81.47,65.99 81.51,65.89 arc(81.63,65.74) 81.81,65.69 82,65.69 arc(82.06,65.7) 82.1,65.75 82.15,65.82 arc(82.15,65.87) 82.13,65.91 v4(81.85,66.07)
DDR4_2V5_DIMM1_EVENT_N:
  vias: v1(120.64,93.98)
DDR4_2V5_DIMM1_SAVE_N:
  vias: v1(127.44,99.98)
DDR4_2V5_DIMM2_EVENT_N:
  vias: v1(120.64,101.6)
DDR4_2V5_DIMM2_SAVE_N: length 0.7
  TOP w0.149: v1(127.44,107.6) J5.230
DDR4_2V5_DIMM_SCL: length 131
  L03_SIG1 w0.081: v1(174.19,101.6) 173.87,101.93 173.87,106.89 172.08,108.68 144.39,108.68 143.33,109.74 132.3,109.74 132.06,109.5 92.72,109.5 91.76,108.54 76.71,108.54 76.04,107.88 76.04,107.41 73.51,104.88 v1(73.12,104.88)
  L12_SIG4 w0.089: v1(174.19,93.98) 173.79,94.38 173.79,100.36 174.19,100.76 v1(174.19,101.6)
  BOTTOM w0.149: v1(73.12,104.88) 73.08,104.84 U39.6 70.48,104.84 70.09,104.45 70.09,97.38 70.49,96.98 U38.3 73.09,96.98 R376.1
DDR4_2V5_DIMM_SDA: length 128.3
  L03_SIG1 w0.081: v1(73.13,105.62) 73.13,105.9 74.32,107.09 74.32,107.82 75.75,109.25 91.78,109.25 92.34,109.81 131.88,109.81 132.06,109.98 143.85,109.98 144.52,109.31 172.48,109.31 v1(174.19,107.6)
  L12_SIG4 w0.089: v1(174.19,99.98) 174.6,100.38 174.6,107.2 v1(174.19,107.6)
  BOTTOM w0.149: R377.1 72.58,96.48 U38.4 70.15,96.48 69.2,97.44 69.2,104.32 70.21,105.34 U39.5 72.37,105.34 72.66,105.62 v1(73.13,105.62)
DDR4_COMP_A0: length 97.6
  TOP w0.149: U15.L3 v1(125.06,19.36) ; U19.L3 v1(76.42,19.36) ; U17.L3 v1(100.68,19.36) ; U18.L3 v1(88.49,19.36) ; U16.L3 v1(112.87,19.36)
  L03_SIG1 w0.081: v1(112.87,19.36) 112.95,19.28 113.33,19.03 113.5,18.96 124.1,18.96 v1(125.06,19.36)
  L07_SIG3 w0.089: v1(114.52,49.05) 114.17,48.7 114.17,48.44 113.85,48.12 113.58,48.12 113.3,47.83 113.3,41.42 113.55,41.16 113.55,38.6 114.15,38 114.15,31.07 114.33,30.89 114.72,30.89 114.89,31.06 114.89,32.41 115.07,32.58 115.53,32.58 115.7,32.41 115.7,31.19 115.88,31.02 116.21,31.02 116.39,31.19 116.39,32.26 116.56,32.44 117,32.44 117.18,32.26 117.18,31.06 117.35,30.89 120.52,30.89 120.77,30.64 120.77,21.63 122.64,19.76 124.66,19.76 v1(125.06,19.36) ; v1(112.87,19.36) 111.91,18.96 101.32,18.96 101.1,19.05 100.76,19.28 v1(100.68,19.36) 99.71,18.96 89.13,18.96 88.91,19.05 88.57,19.28 v1(88.49,19.36) 87.52,18.96 77.07,18.96 76.84,19.05 76.51,19.28 v1(76.42,19.36)
DDR4_COMP_A1: length 97.8
  TOP w0.149: U15.L7 v1(127.25,19.36) ; U19.L7 v1(78.35,19.36) ; U18.L7 v1(90.67,19.36) ; U16.L7 v1(115.06,19.36) ; U17.L7 v1(102.86,19.36)
  L05_SIG2 w0.081: v1(113.72,48.59) 113.43,48.3 113.43,48.01 113.07,47.64 112.77,47.64 112.27,47.14 112.27,45.88 111.72,45.32 111.72,44.02 112.34,43.4 112.34,42.51 112.81,42.04 112.81,37.01 114.18,35.64 114.18,35.26 114.46,34.98 114.97,34.98 115.3,34.65 115.3,34.04 114.99,33.73 114.99,30.18 115.12,30.05 116.43,30.05 116.57,29.91 116.57,29.43 116.43,29.29 115.31,29.29 115.12,29.1 115.12,28.82 115.36,28.58 117.13,28.58 119.26,26.44 119.26,21.47 122.57,18.16 125.9,18.16 126.17,18.43 126.17,18.79 126.34,18.96 126.85,18.96 v1(127.25,19.36)
  L14_SIG5 w0.081: v1(127.25,19.36) 127.17,19.28 126.83,19.06 126.6,18.96 116.24,18.96 115.82,19.04 v1(115.06,19.36) 114.98,19.28 114.64,19.06 114.41,18.96 104.05,18.96 103.63,19.04 v1(102.86,19.36) 102.79,19.28 102.45,19.06 102.21,18.96 91.86,18.96 91.44,19.04 v1(90.67,19.36) 90.59,19.28 90.26,19.06 90.02,18.96 79.65,18.96 79.01,19.08 v1(78.35,19.36)
DDR4_COMP_A2: length 95.8
  TOP w0.149: U18.M3 v1(88.49,18.56) ; U15.M3 v1(125.06,18.56) ; U17.M3 v1(100.68,18.56) ; U19.M3 v1(76.42,18.56) ; U16.M3 v1(112.87,18.56)
  L03_SIG1 w0.081: v1(125.06,18.56) 124.1,18.16 113.5,18.16 113.33,18.23 112.95,18.48 v1(112.87,18.56)
  L07_SIG3 w0.089: v1(112.87,18.56) 111.91,18.16 101.32,18.16 101.1,18.25 100.76,18.48 v1(100.68,18.56) 99.71,18.16 89.13,18.16 88.91,18.25 88.57,18.48 v1(88.49,18.56) 87.52,18.16 77.07,18.16 76.84,18.25 76.51,18.48 v1(76.42,18.56) ; v1(125.06,18.56) 124.66,18.16 121.88,18.16 119.68,20.36 119.68,26.78 116.99,29.48 113.2,29.48 112.48,30.2 112.48,33.42 111.71,34.19 111.71,48.77 112.01,49.06 112.3,49.06 112.77,49.53 113.18,49.53 113.62,49.97 v1(114.52,49.97)
DDR4_COMP_A3: length 95.4
  TOP w0.149: U17.K7 v1(102.86,20.16) ; U18.K7 v1(90.67,20.16) ; U16.K7 v1(115.06,20.16) ; U15.K7 v1(127.25,20.16) ; U19.K7 v1(78.35,20.16)
  L07_SIG3 w0.089: v1(113.72,50.43) 114.59,50.43 115.05,49.97 115.42,49.97 115.81,50.36 116.21,50.36 116.72,50.87 117.11,50.87 117.51,50.47 117.89,50.47 118.32,50.9 118.68,50.9 119.14,50.44 119.43,50.44 119.7,50.17 119.7,47.42 119.92,47.2 120.3,47.2 120.77,46.73 121.06,46.73 121.5,46.29 121.89,46.29 122.43,45.75 123.11,45.75 124.13,44.73 124.13,44.49 123.97,44.33 123.97,44.1 124.16,43.91 124.4,43.91 124.56,44.06 124.8,44.06 124.99,43.86 124.99,43.39 125.17,43.22 125.64,43.22 127.61,41.25 127.61,28.69 128.13,28.16 128.13,21.04 v1(127.25,20.16)
  L14_SIG5 w0.081: v1(127.25,20.16) 127.17,20.24 126.83,20.46 126.6,20.56 116.24,20.56 115.82,20.47 v1(115.06,20.16) 114.98,20.24 114.64,20.46 114.41,20.56 104.05,20.56 103.63,20.47 v1(102.86,20.16) 102.79,20.24 102.45,20.46 102.21,20.56 91.86,20.56 91.44,20.47 v1(90.67,20.16) 90.59,20.24 90.26,20.46 90.02,20.56 79.75,20.56 78.92,20.39 v1(78.35,20.16)
DDR4_COMP_A4: length 96.7
  TOP w0.149: U15.K3 v1(125.06,20.16) ; U16.K3 v1(112.87,20.16) ; U18.K3 v1(88.49,20.16) ; U19.K3 v1(76.42,20.16) ; U17.K3 v1(100.68,20.16)
  L03_SIG1 w0.081: v1(112.87,20.16) 112.95,20.08 113.33,19.83 113.5,19.76 124.1,19.76 v1(125.06,20.16)
  L05_SIG2 w0.081: v1(125.06,20.16) 124.65,20.16 124.25,20.55 123.59,20.55 123.37,20.78 123.37,21.16 123.18,21.35 122.82,21.35 122.56,21.61 122.56,22.82 122.16,23.22 122.16,24.4 121.73,24.83 121.73,27.71 121.88,27.87 122.81,27.87 122.97,28.02 122.97,28.29 122.81,28.45 121.76,28.45 121.61,28.61 121.61,28.96 121.81,29.16 122.76,29.16 122.92,29.31 122.92,29.54 122.76,29.7 121.72,29.7 121.57,29.85 121.57,30.06 121.72,30.22 122.71,30.22 122.87,30.37 122.87,30.66 122.71,30.81 121.68,30.81 121.52,30.97 121.52,31.24 121.68,31.4 122.81,31.4 122.97,31.55 122.97,31.82 122.81,31.98 121.19,31.98 121.04,32.13 121.04,34.72 117.28,38.48 116.55,38.48 114.92,40.11 114.92,47.86 115.16,48.1 115.51,48.1 115.77,48.36 115.77,48.71 v1(116.11,49.05)
  L07_SIG3 w0.089: v1(76.42,20.16) 76.51,20.08 76.84,19.85 77.07,19.76 87.52,19.76 v1(88.49,20.16) 88.57,20.08 88.91,19.85 89.13,19.76 99.71,19.76 v1(100.68,20.16) 100.76,20.08 101.1,19.85 101.32,19.76 111.91,19.76 v1(112.87,20.16)
DDR4_COMP_A5: length 96.5
  L05_SIG2 w0.081: v1(128.56,19.36) 128.81,19.36 129.19,19.74 129.5,19.74 129.76,20 129.76,20.33 130.05,20.63 130.69,21.57 131.38,23.25 131.38,31.24 123.34,50.66 122.64,51.36 122.33,51.36 121.9,51.79 121.5,51.79 121.07,51.36 119.09,51.36 118.6,50.87 118.4,50.87 117.96,50.44 117.59,50.44 117.09,49.94 116.66,49.94 116.2,49.47 115.87,49.47 115.31,48.92 v1(115.31,48.59)
  L12_SIG4 w0.089: v1(79.79,19.36) 80.17,19.1 80.52,18.96 90.65,18.96 91.35,19.1 v1(91.98,19.36) 92.36,19.1 92.71,18.96 102.84,18.96 103.55,19.1 v1(104.17,19.36) 104.56,19.1 104.9,18.96 115.03,18.96 115.74,19.1 v1(116.36,19.36) 116.75,19.1 117.09,18.96 127.22,18.96 127.93,19.1 v1(128.56,19.36)
  BOTTOM w0.149: R172.2 82.15,19.47 81.97,19.47 81.67,19.76 80.19,19.76 v1(79.79,19.36)
DDR4_COMP_A6: length 98.3
  L05_SIG2 w0.081: v1(111.56,19.36) 111.24,19.14 110.8,18.96 100.69,18.96 v1(99.37,19.36) 99.05,19.14 98.6,18.96 88.5,18.96 v1(87.18,19.36) 86.86,19.14 86.41,18.96 76.31,18.96 v1(74.99,19.36) ; v1(116.11,49.97) 115.09,49.97 114.64,49.52 114.37,49.52 114.12,49.26 114.12,46.45 113.89,46.22 113.49,46.22 113.34,46.07 113.34,43.82 113.77,43.39 113.77,39.38 115.28,37.88 115.28,36.73 115.75,36.25 117.25,36.25 117.76,35.74 117.76,34.47 117.93,34.29 119.54,34.29 119.72,34.12 119.72,32.84 119.54,32.66 117.93,32.66 117.76,32.49 117.76,32.25 117.93,32.07 118.83,32.07 119.01,31.9 119.01,31.66 118.83,31.48 117.93,31.48 117.76,31.31 117.76,31.07 117.93,30.89 118.92,30.89 119.09,30.72 119.09,30.48 118.92,30.31 117.93,30.31 117.76,30.13 117.76,29.7 117.96,29.49 118.96,29.49 119.16,29.29 119.16,28.17 120.5,26.83 120.5,21.88 122.62,19.75 123.1,19.75 123.49,19.36 v1(123.76,19.36)
  L16_SIG6 w0.081: v1(123.76,19.36) 123.3,19.05 123.07,18.96 112.91,18.96 112.18,19.1 v1(111.56,19.36)
  BOTTOM w0.149: v1(74.99,19.36) 74.59,19.76 73.99,19.76 73.7,19.46 73.41,19.46 R174.2
DDR4_COMP_A7: length 98.3
  L07_SIG3 w0.089: v1(128.56,18.56) 128.83,18.84 129.2,18.99 129.66,18.99 131.04,19.56 131.48,19.99 131.68,20.48 131.68,20.96 131.96,21.63 131.96,40.92 131.71,41.51 122.86,50.37 122.64,50.46 122.46,50.46 122.18,50.58 121.97,50.78 121.8,50.85 121.59,50.85 121.38,50.77 121.18,50.57 121.03,50.5 120.79,50.5 120.6,50.58 120.39,50.79 119.84,51.01 119.64,51.22 119.4,51.32 119.29,51.32 119.11,51.39 118.85,51.65 118.63,51.74 118.39,51.74 118.19,51.66 118.03,51.5 117.82,51.41 117.6,51.41 117.43,51.49 117.25,51.67 117,51.77 116.85,51.77 116.61,51.67 116.32,51.38 116.14,51.31 115.9,51.31 115.52,50.93 v1(115.31,50.43)
  L12_SIG4 w0.089: v1(128.56,18.56) 127.93,18.3 127.22,18.16 117.09,18.16 116.75,18.3 v1(116.36,18.56) 115.74,18.3 115.03,18.16 104.9,18.16 104.56,18.3 v1(104.17,18.56) 103.55,18.3 102.84,18.16 92.71,18.16 92.36,18.3 v1(91.98,18.56) 91.35,18.3 90.65,18.16 80.52,18.16 80.17,18.3 v1(79.79,18.56)
  BOTTOM w0.149: R175.2 80.79,16.83 80.18,17.44 80.18,18.16 v1(79.79,18.56)
