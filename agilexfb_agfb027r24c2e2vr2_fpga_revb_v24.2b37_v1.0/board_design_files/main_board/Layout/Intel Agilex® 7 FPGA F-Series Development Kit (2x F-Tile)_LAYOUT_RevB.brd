# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM2_A2: length 105.5
  L14_SIG5 w0.081: v1(110.44,107.6) 111.53,107.6 112.13,107 113.01,107 113.38,107.37 113.38,108.73 113.2,108.92 112.75,108.92 112.55,108.72 112.55,108.09 112.44,107.98 111.84,107.98 111.73,108.09 111.73,108.86 111.62,108.98 105.87,108.98 105.77,108.87 105.77,107.44 105.54,107.22 105.06,107.22 104.55,107.73 104.55,108.64 104.36,108.84 95.63,108.84 95.49,108.98 82.63,108.98 82.49,108.84 72.81,108.84 72.6,108.63 72.6,107.34 73.08,106.86 73.08,106.14 72.96,106.02 72.79,106.02 72.67,106.14 72.67,106.59 72.55,106.71 72.38,106.71 72.26,106.59 72.26,103.13 72.38,103.01 72.55,103.01 72.67,103.13 72.67,104.15 72.79,104.27 72.96,104.27 73.08,104.15 73.08,102.74 72.6,102.26 72.6,101.74 72.72,101.62 73.01,101.62 73.13,101.5 73.13,101.33 73.01,101.21 72.31,101.21 72.19,101.09 72.19,100.92 72.31,100.8 73.01,100.8 73.13,100.68 73.13,100.52 73.01,100.4 72.45,100.4 72.33,100.28 72.33,99.98 73.06,99.25 73.06,96.97 72.94,96.85 72.77,96.85 72.65,96.97 72.65,98.79 72.53,98.91 72.37,98.91 72.25,98.79 72.25,96.6 73.25,95.6 73.4,95.6 73.73,95.93 73.92,95.93 74.07,95.78 74.07,95.6 73.74,95.27 73.74,95.11 73.9,94.95 74.06,94.95 74.6,95.5 74.76,95.5 75.09,95.16 75.09,94.64 75.58,94.16 75.58,93.08 79.57,89.09 80.78,89.09 81.7,88.17 81.7,87.52 81.96,87.27 82.4,87.27 84.01,85.66 86.37,85.66 87.8,84.24 88.92,84.24 90.62,82.54 91.24,82.54 92.08,81.7 92.35,81.7 92.74,81.31 92.74,81.05 v1(93,80.79)
DDR4_DIMM2_A3: length 105.6
  L16_SIG6 w0.081: v1(109.59,101.6) 109.23,101.6 109.11,101.72 108.76,101.72 108.66,101.82 108.66,102.18 108.34,102.49 108.34,103.95 108.47,104.08 109.26,104.08 109.33,104.15 109.33,104.33 109.23,104.43 107.07,104.43 106.98,104.53 106.98,104.66 107.07,104.76 109,104.76 109.1,104.86 109.1,105 109,105.1 107.54,105.1 107.44,105.2 107.44,105.34 107.54,105.43 109.08,105.43 109.18,105.53 109.18,105.67 109.08,105.77 107.38,105.77 107.28,105.87 107.28,106.02 107.38,106.12 109.13,106.12 109.23,106.22 109.23,106.36 109.13,106.46 107.54,106.46 107.44,106.56 107.44,106.73 107.54,106.83 108.74,106.83 108.84,106.92 109.54,106.92 109.66,107.04 109.66,107.18 109.56,107.29 109.23,107.29 109.13,107.39 109.13,107.53 109.23,107.63 109.96,107.63 110.07,107.73 110.07,107.88 109.96,107.98 108.56,107.98 108.28,107.7 108.28,107.34 108.17,107.22 107.04,107.22 106.94,107.32 106.94,107.54 107.04,107.64 107.35,107.64 107.45,107.74 107.45,108.38 107.35,108.49 106.68,108.49 106.59,108.4 106.59,108.07 106.49,107.97 106.06,107.97 105.87,108.17 105.69,108.17 105.6,108.09 105.6,107.91 105.81,107.7 105.81,107.34 105.71,107.23 105.45,107.23 105.27,107.06 105.27,105.87 105.37,105.78 105.51,105.78 105.6,105.87 105.6,106.69 105.7,106.79 105.84,106.79 105.94,106.69 105.94,105.93 106.04,105.83 106.18,105.83 106.28,105.93 106.28,107.14 106.37,107.24 106.51,107.24 106.61,107.14 106.61,104.43 106.51,104.33 106.37,104.33 106.28,104.43 106.28,105.28 106.18,105.38 106.04,105.38 105.94,105.28 105.94,104.2 105.84,104.1 105.7,104.1 105.6,104.2 105.6,105.28 105.51,105.38 105.37,105.38 105.27,105.28 105.27,104.04 105.11,103.88 105.11,102.55 104.73,102.16 104.73,101.95 104.85,101.83 105,101.83 105.14,101.97 105.35,101.97 105.45,102.07 105.45,103.59 105.55,103.69 105.68,103.69 105.78,103.59 105.78,101.49 105.52,101.23 104.77,101.23 104.65,101.1 104.04,101.1 103.9,101.25 103.36,101.25 103.22,101.11 103.22,100.68 103.01,100.46 102.49,100.46 102.4,100.38 102.4,99.88 102.31,99.78 102.14,99.78 102.05,99.88 102.05,100.73 101.95,100.83 100.89,100.83 100.35,100.29 100.35,99.93 100.19,99.77 99.8,99.77 99.72,99.7 99.72,99.28 99.62,99.18 99.45,99.18 99.35,99.28 99.35,99.48 99.26,99.57 99.07,99.57 98.98,99.48 98.98,99.24 98.88,99.14 98.73,99.14 98.64,99.24 98.64,99.46 98.54,99.56 98.39,99.56 98.3,99.46 98.3,99.24 98.2,99.14 98.05,99.14 97.96,99.24 97.96,99.5 97.86,99.6 97.71,99.6 97.61,99.5 97.61,98.36 97.39,98.13 97.39,97.66 95.78,96.05 94.99,96.05 94.89,95.95 94.89,95.73 94.99,95.63 96.51,95.63 96.6,95.53 96.6,95.39 96.51,95.29 94.86,95.29 94.77,95.2 94.77,95.06 94.86,94.96 95.44,94.96 95.54,94.86 95.54,94.72 95.44,94.62 94.77,94.62 94.68,94.53 94.68,93.65 94.56,93.54 94.32,93.54 94.22,93.63 94.22,94.18 94.13,94.28 93.99,94.28 93.89,94.18 93.89,93.65 93.79,93.55 93.55,93.55 93.34,93.34 93.34,89.42 93.24,89.32 93.09,89.32 92.99,89.42 92.99,93.49 92.89,93.6 92.74,93.6 92.63,93.49 92.63,88.77 92.02,88.17 92.02,86.4 91.35,85.73 91.35,82.37 91.8,81.92 91.8,80.73 v1(92.21,80.33)
DDR4_DIMM2_A4: length 102.2
  L14_SIG5 w0.081: v1(94.6,81.71) 94.6,82.49 93.97,83.12 93.23,83.12 92.78,83.57 92.25,83.57 91.15,84.67 90.44,84.67 89.48,85.64 89.02,85.64 88.03,86.63 88.03,87.04 87.8,87.26 87.21,87.26 86.93,87.54 86.93,87.96 86.66,88.23 84.57,88.23 81.29,91.52 80.39,91.52 78.61,93.29 78.61,95.07 77.74,95.94 77.74,98.55 77.62,98.67 77.45,98.67 77.33,98.55 77.33,96.32 77.21,96.2 77.04,96.2 76.93,96.32 76.93,98.72 77.74,99.54 77.74,100.59 77.62,100.71 77.35,100.71 77.23,100.83 77.23,101 77.35,101.12 77.62,101.12 77.74,101.24 77.74,103.36 77.62,103.48 77.45,103.48 77.33,103.36 77.33,102.25 77.21,102.13 77.04,102.13 76.93,102.25 76.93,105.99 77.04,106.11 77.21,106.11 77.33,105.99 77.33,104.18 77.45,104.06 77.62,104.06 77.74,104.18 77.74,106.57 78.01,106.84 80.4,106.84 80.52,106.72 80.52,106.55 80.4,106.43 78.49,106.43 78.37,106.31 78.37,106.14 78.49,106.02 82.37,106.02 82.49,106.14 82.49,106.31 82.37,106.43 81.09,106.43 80.97,106.55 80.97,106.72 81.09,106.84 82.65,106.84 83.04,106.44 83.41,106.44 84.09,107.12 91.46,107.12 91.56,107.23 94.45,107.23 94.56,107.34 95.24,107.34 95.84,106.74 97.65,106.74 97.98,106.41 99.31,106.41 99.7,106.01 101.4,106.01 101.64,106.25 102.25,106.25 102.49,106.01 103.3,106.01 103.59,105.71 103.59,105.38 104.23,104.74 104.88,104.74 105.01,104.87 106.64,104.87 106.85,104.65 107.59,104.65 108.24,105.3 108.98,105.3 109.18,105.5 109.18,105.93 109.3,106.05 109.95,106.05 110.56,105.44 112.93,105.44 113.09,105.59 113.09,105.8 112.92,105.97 110.94,105.97 109.31,107.6 v1(108.74,107.6)
DDR4_DIMM2_A5: length 102.1
  L14_SIG5 w0.081: v1(93.8,82.17) 93.52,82.45 92.95,82.45 92.5,82.9 91.98,82.9 90.87,84 90.14,84 89.22,84.92 88.46,84.92 88.34,85.04 88.34,85.27 88.22,85.39 88.06,85.39 87.93,85.26 87.76,85.26 87.64,85.38 87.64,85.55 87.77,85.68 87.77,85.84 87.65,85.96 87.48,85.96 87.35,85.83 87.18,85.83 86.62,86.4 85.36,86.4 82.4,89.35 81.86,89.35 81.07,90.14 80.18,90.14 76.87,93.46 76.87,94.23 76.99,94.36 77.2,94.36 77.65,94.81 77.65,94.97 77.54,95.08 77.38,95.08 77.03,94.74 76.87,94.74 76.76,94.85 76.76,95.01 76.9,95.15 76.9,95.31 76.79,95.42 76.63,95.42 76.37,95.16 76.21,95.16 76.09,95.28 76.09,95.44 76.36,95.7 76.36,95.86 76.25,95.97 76.09,95.97 75.92,95.81 75.74,95.81 75.5,96.05 75.5,99.49 75.59,99.58 75.81,99.58 76.09,99.86 76.42,99.86 76.52,99.96 76.52,100.29 76.41,100.41 74.04,100.41 73.92,100.53 73.92,100.71 74.15,100.94 74.15,101.18 74.26,101.3 74.43,101.3 74.55,101.18 74.55,100.94 74.67,100.82 76.36,100.82 76.48,100.94 76.48,101.11 76.36,101.22 75.25,101.22 75.13,101.34 75.13,101.51 75.25,101.63 75.9,101.63 76.02,101.75 76.02,102.86 75.55,103.33 75.55,106.19 75.66,106.3 75.94,106.3 76.05,106.42 76.05,106.58 75.94,106.69 75.66,106.69 75.55,106.8 75.55,107.08 75.45,107.18 74.48,107.18 74.29,107.37 74.29,107.91 74.42,108.03 75.85,108.03 76.04,107.85 76.04,107.23 76.32,106.95 76.64,106.95 76.87,107.18 76.87,107.89 77.01,108.03 82.63,108.03 82.91,108.31 94.81,108.31 95.06,108.06 97.8,108.06 98.08,107.77 98.08,107.34 98.34,107.09 99.7,107.09 99.97,107.37 100.46,107.37 100.64,107.19 100.64,106.87 100.72,106.8 100.91,106.8 101.01,106.89 101.01,107.96 101.12,108.07 101.28,108.07 101.4,107.96 101.4,107.48 101.51,107.37 101.67,107.37 101.78,107.48 101.78,107.95 101.9,108.06 102.06,108.06 102.17,107.95 102.17,107.48 102.28,107.37 102.47,107.37 102.62,107.21 103.19,107.21 103.44,106.96 103.6,106.96 103.84,107.2 104,107.2 104.11,107.08 104.11,106.92 103.87,106.69 103.87,106.53 104.38,106.02 104.91,106.02 105.02,106.14 105.02,106.35 105.14,106.47 105.3,106.47 105.41,106.35 105.41,105.69 105.52,105.58 105.68,105.58 105.8,105.69 105.8,106.35 105.91,106.47 106.07,106.47 106.18,106.35 106.18,105.69 106.3,105.58 106.46,105.58 106.57,105.69 106.57,105.91 106.68,106.02 108.31,106.02 108.43,106.15 108.43,106.62 108.07,106.99 106.77,106.99 106.65,107.1 106.65,107.25 106.77,107.37 107.18,107.37 107.29,107.47 107.29,107.61 107.18,107.72 106.77,107.72 106.65,107.84 106.65,108.38 106.77,108.5 107.36,108.5 107.51,108.35 107.51,107.99 v1(107.89,107.6)
DDR4_DIMM2_A6: length 104.3
  L14_SIG5 w0.081: v1(107.89,101.6) 108.9,101.6 109.33,102.03 110.84,102.03 111.15,101.73 111.57,101.73 111.87,102.03 113.28,102.03 113.61,101.7 114.12,101.7 114.61,102.2 116.57,102.2 117.25,102.88 117.25,104.69 116.99,104.95 108.39,104.95 107.75,104.31 106.69,104.31 106.48,104.53 105.21,104.53 105.06,104.37 104.13,104.37 102.83,105.67 102.35,105.67 102.11,105.92 101.78,105.92 101.54,105.67 99.56,105.67 99.17,106.07 97.84,106.07 97.51,106.4 95.11,106.4 94.62,106.89 91.7,106.89 91.59,106.79 84.56,106.79 83.61,105.84 83.45,105.84 83.27,106.03 83.11,106.03 82.98,105.9 82.98,105.74 83.16,105.55 83.16,105.4 82.99,105.23 82.24,105.23 82.02,105.44 81.73,105.44 81.51,105.23 81.08,105.23 80.64,105.66 78.32,105.66 78.2,105.55 78.2,105.38 78.32,105.26 80.36,105.26 80.47,105.14 80.47,104.97 80.36,104.85 79.5,104.85 79.37,104.72 79.37,102.67 79.25,102.55 79.08,102.55 78.96,102.67 78.96,104.71 78.84,104.83 78.68,104.83 78.56,104.71 78.56,101.13 78.68,101.01 78.84,101.01 78.96,101.13 78.96,101.61 79.08,101.73 79.25,101.73 79.37,101.61 79.37,100.88 78.56,100.07 78.56,97.97 78.68,97.85 78.84,97.85 78.96,97.97 78.96,99.26 79.08,99.38 79.25,99.38 79.37,99.26 79.37,97.83 78.56,97.02 78.56,95.78 79.38,94.96 79.38,93.15 80.38,92.15 81.49,92.15 84.98,88.66 87.03,88.66 88.42,87.27 88.42,86.79 89.22,85.99 89.62,85.99 90.52,85.1 91.2,85.1 92.39,83.91 92.91,83.91 93.37,83.45 94.13,83.45 95,82.58 95,81.19 v1(94.6,80.79)
DDR4_DIMM2_A7: length 104.4
  L14_SIG5 w0.081: v1(93.8,80.33) 93.41,80.72 93.41,81.92 93.22,82.11 92.8,82.11 92.35,82.56 91.8,82.56 90.81,83.55 90.08,83.55 89.06,84.57 87.97,84.57 86.5,86.04 85.12,86.04 83.87,87.28 83.19,87.28 82.89,87.58 82.89,88.07 82.39,88.58 81.93,88.58 80.94,89.58 79.97,89.58 75.97,93.58 75.97,94.31 76.15,94.49 76.15,94.72 75.11,95.76 75.11,99.16 74.99,99.28 74.82,99.28 74.7,99.16 74.7,96.25 74.58,96.13 74.42,96.13 74.3,96.25 74.3,99.13 74.18,99.25 74.01,99.25 73.89,99.13 73.89,96.6 73.77,96.48 73.6,96.48 73.48,96.6 73.48,103.43 73.6,103.55 73.77,103.55 73.89,103.43 73.89,102.24 74.01,102.12 74.18,102.12 74.3,102.24 74.3,103.59 74.42,103.71 74.58,103.71 74.7,103.59 74.7,102.24 74.82,102.12 74.99,102.12 75.11,102.24 75.11,106.51 74.99,106.63 74.82,106.63 74.7,106.51 74.7,104.35 74.58,104.23 74.42,104.23 74.3,104.35 74.3,106.51 74.18,106.63 74.01,106.63 73.89,106.51 73.89,104.43 73.77,104.31 73.63,104.31 73.51,104.43 73.51,108.06 73.89,108.43 82.56,108.43 82.77,108.64 95.16,108.64 95.3,108.5 98.52,108.5 99.05,107.97 99.83,107.97 99.95,107.86 100.41,107.86 101,108.45 102.18,108.45 102.66,107.97 103.82,107.97 104.93,106.86 105.82,106.86 106.19,107.23 v1(106.19,107.6)
DDR4_DIMM2_A8: length 101.7
  L14_SIG5 w0.081: v1(96.19,81.71) 96.19,82.4 94.46,84.12 93.64,84.12 93.18,84.58 92.66,84.58 91.43,85.81 90.75,85.81 89.98,86.59 89.98,86.99 89.66,87.3 89.37,87.3 87.11,89.56 85.06,89.56 81.55,93.07 81.55,93.41 81.13,93.83 81.13,94.78 79.95,95.96 79.95,97.09 80.25,97.39 80.25,100.24 80.85,100.84 80.85,101.07 81.12,101.35 81.12,101.84 80.95,102.01 80.53,102.01 80.36,102.18 80.36,102.38 80.45,102.47 82.41,102.47 83.96,104.01 83.96,104.18 83.84,104.3 83.67,104.3 82.77,103.4 82.6,103.4 82.48,103.52 82.48,103.69 84.87,106.07 85.04,106.07 85.15,105.95 85.15,105.78 84.15,104.78 84.15,104.61 84.27,104.49 84.44,104.49 86.06,106.12 91.87,106.12 91.98,106.22 94.31,106.22 94.82,105.72 97.21,105.72 98.05,104.87 98.98,104.87 99.09,104.76 101.6,104.76 101.87,104.49 102.04,104.49 102.44,104.9 102.61,104.9 103.35,104.15 103.35,103.99 103.24,103.87 103.07,103.87 102.62,104.31 102.45,104.31 102.34,104.19 102.34,104.02 103.08,103.28 104.41,103.28 104.53,103.16 104.53,102.49 104.65,102.37 104.82,102.37 104.94,102.49 104.94,103.34 105.06,103.45 105.23,103.45 105.35,103.34 105.35,102.6 105.46,102.48 105.63,102.48 105.75,102.6 105.75,103.16 105.87,103.28 106.38,103.28 106.74,103.63 108.07,103.63 108.58,104.15 108.88,104.15 109.04,103.99 109.25,103.99 109.41,104.15 114.17,104.15 114.35,103.98 114.35,103.16 114.22,103.04 114.04,103.04 113.92,103.16 113.92,103.64 113.8,103.76 113.64,103.76 113.52,103.64 113.52,103.16 113.4,103.04 113.23,103.04 113.11,103.16 113.11,103.64 112.99,103.76 112.82,103.76 112.7,103.64 112.7,103.16 112.58,103.04 112.42,103.04 112.3,103.16 112.3,103.64 112.18,103.76 112.01,103.76 111.89,103.64 111.89,103.16 111.77,103.04 111.6,103.04 111.48,103.16 111.48,103.64 111.37,103.76 111.2,103.76 111.08,103.64 111.08,103.16 110.96,103.04 110.79,103.04 110.67,103.16 110.67,103.64 110.55,103.76 110.38,103.76 110.27,103.64 110.27,103.16 110.15,103.04 109.34,103.04 109.18,103.2 107.17,103.2 107.04,103.07 107.04,102.93 107.16,102.81 108.04,102.81 108.16,102.69 108.16,102.52 108.04,102.41 107.34,102.41 107.01,102.08 105.92,102.08 105.78,101.94 105.78,101.73 105.91,101.6 v1(107.04,101.6)
DDR4_DIMM2_A9: length 101.8
  L14_SIG5 w0.081: v1(95.39,82.17) 95.39,82.68 94.29,83.79 93.51,83.79 93.05,84.24 92.53,84.24 91.32,85.44 90.64,85.44 89.75,86.34 89.38,86.34 89.08,86.63 89.08,87.09 86.98,89.19 84.93,89.19 81.4,92.73 81.23,92.73 81.02,92.52 80.85,92.52 80.73,92.64 80.73,92.8 81.09,93.16 81.09,93.33 80.97,93.45 80.8,93.45 80.35,92.99 80.18,92.99 80.06,93.11 80.06,93.28 80.31,93.53 80.31,94.89 79.53,95.67 79.53,97.22 79.83,97.52 79.83,99.42 79.45,99.8 79.45,100.16 80.22,100.93 80.22,101.84 79.75,102.32 79.75,102.73 79.85,102.83 82.15,102.83 82.27,102.95 82.27,103.12 82.15,103.24 79.96,103.24 79.84,103.36 79.84,103.53 79.96,103.64 81.32,103.64 81.44,103.76 81.44,103.93 81.32,104.05 79.93,104.05 79.81,104.17 79.81,104.34 79.93,104.46 81.44,104.46 81.56,104.58 81.56,104.75 81.68,104.87 82.29,104.87 82.41,104.75 82.41,104.58 82.53,104.46 82.75,104.46 84.74,106.45 91.73,106.45 91.84,106.56 94.49,106.56 94.98,106.07 97.33,106.07 98.17,105.23 99.14,105.23 99.17,105.2 101.64,105.2 101.79,105.05 102.1,105.05 102.38,105.33 102.67,105.33 104.12,103.87 105.2,103.87 105.47,104.14 106.38,104.14 106.55,103.97 107.9,103.97 108.42,104.49 114.9,104.49 115,104.39 115,103.31 115.12,103.19 115.29,103.19 115.4,103.31 115.4,104.37 115.52,104.49 115.77,104.49 115.88,104.37 115.88,103.31 116,103.19 116.17,103.19 116.29,103.31 116.29,104.45 116.41,104.57 116.7,104.57 116.82,104.45 116.82,103 116.37,102.55 114.3,102.55 114.16,102.69 113.52,102.69 113.22,102.39 111.96,102.39 111.66,102.69 111,102.69 110.77,102.46 110.37,102.46 110.14,102.69 109.5,102.69 108.85,102.04 107.69,102.04 107.46,101.82 107.46,101.26 107.24,101.05 106.76,101.05 106.57,101.24 105.7,101.24 v1(105.34,101.6)
DDR4_DIMM2_A10: length 104
  L14_SIG5 w0.081: v1(96.19,80.79) 95.32,80.79 94.88,80.34 94.44,80.34 94.22,80.57 94.22,82.35 93.78,82.78 93.09,82.78 92.64,83.23 92.11,83.23 91.01,84.33 90.28,84.33 89.35,85.27 88.84,85.27 87.72,86.38 87.18,86.38 86.32,87.24 85.02,87.24 81.41,90.86 80.33,90.86 77.69,93.5 77.69,94.19 78.11,94.61 78.11,95.07 77.43,95.75 76.98,95.75 76.58,96.15 76.58,97.85 76.48,97.95 76.35,97.95 76.25,97.85 76.25,97.03 76.15,96.93 76.01,96.93 75.91,97.03 75.91,98.36 76.87,99.31 76.87,101.8 76.59,102.08 76.59,104.67 76.49,104.77 76.35,104.77 76.25,104.67 76.25,103.67 76.15,103.57 76.02,103.57 75.92,103.67 75.92,105.65 77.44,107.18 82.62,107.18 82.81,107.37 82.81,107.74 83.05,107.97 94.56,107.97 94.83,107.7 95.37,107.7 95.99,107.07 97.79,107.07 98.12,106.74 99.57,106.74 99.87,106.44 101.17,106.44 101.78,107.05 102.11,107.05 102.62,106.54 103.25,106.54 104.01,105.77 104.01,105.44 104.35,105.1 104.71,105.1 104.84,105.23 106.76,105.23 106.97,105.02 107.41,105.02 108.06,105.67 108.61,105.67 108.82,105.87 108.82,106.25 109.16,106.58 109.16,106.94 109.04,107.05 108.5,107.05 108.34,107.21 108.34,107.77 108.54,107.98 109.49,107.98 110.28,107.18 111.43,107.18 112.09,106.53 113.07,106.53 114.11,105.49 116.75,105.49 118.01,106.75 120.19,106.75 120.56,106.37 120.56,104.69 120.71,104.54 120.91,104.54 121.03,104.66 121.03,105.74 121.25,105.96 122.02,105.96 122.29,106.24 122.29,106.69 v1(123.19,107.6)
DDR4_DIMM2_A11: length 103.5
  L14_SIG5 w0.081: v1(95.39,80.33) 95.39,80.05 94.77,79.43 94.44,79.43 94.04,79.83 93.68,79.83 93.23,80.29 92.87,80.29 92.41,80.75 92.09,80.75 91.6,81.23 91.3,81.23 90.83,81.7 90.56,81.7 90.06,82.2 90.06,82.5 88.68,83.89 87.66,83.89 86.22,85.32 83.76,85.32 82.66,86.43 82.49,86.43 82.37,86.31 82.37,86.14 82.9,85.62 82.9,85.45 82.78,85.33 82.61,85.33 81.35,86.59 81.35,87.74 80.35,88.74 80.18,88.74 80.06,88.62 80.06,88.45 80.9,87.61 80.9,87.45 80.78,87.33 80.61,87.33 75.19,92.75 75.19,94.07 74.78,94.48 73.71,94.48 72.96,95.23 72.62,95.23 70.99,96.86 70.99,99.32 71.11,99.44 71.27,99.44 71.39,99.32 71.39,97.18 71.51,97.06 71.68,97.06 71.8,97.18 71.8,100.32 71.68,100.44 71.11,100.44 70.99,100.56 70.99,101.1 71.11,101.22 71.27,101.22 71.39,101.1 71.39,100.96 71.51,100.84 71.68,100.84 71.8,100.96 71.8,104.6 71.68,104.72 71.51,104.72 71.39,104.6 71.39,102.2 71.27,102.08 71.11,102.08 70.99,102.2 70.99,107.08 71.11,107.2 71.27,107.2 71.39,107.08 71.39,105.36 71.51,105.25 71.68,105.25 71.8,105.36 71.8,108.97 72.01,109.17 82.35,109.17 82.49,109.31 95.62,109.31 95.77,109.17 104.64,109.17 104.91,108.9 104.91,108.03 v1(105.34,107.6)
DDR4_DIMM2_A12: length 102.9
  L16_SIG6 w0.081: v1(93.8,78.49) 92.89,78.49 92.46,78.06 91.95,78.06 91.8,78.2 91.8,80.14 91.57,80.37 91.17,80.37 91.02,80.52 91.02,85.9 91.58,86.47 91.58,88.21 92.29,88.91 92.29,90.73 92.19,90.83 92.05,90.83 91.95,90.73 91.95,89.06 91.85,88.96 91.72,88.96 91.62,89.06 91.62,90.73 91.52,90.83 91.38,90.83 91.28,90.73 91.28,88.82 91.18,88.72 91.04,88.72 90.95,88.82 90.95,93.13 91.04,93.23 91.18,93.23 91.28,93.13 91.28,91.4 91.38,91.3 91.52,91.3 91.62,91.4 91.62,93.28 91.72,93.38 91.85,93.38 91.95,93.28 91.95,91.4 92.05,91.3 92.19,91.3 92.29,91.4 92.29,93.67 92.18,93.78 91.96,93.78 91.85,93.9 91.85,94.14 92.09,94.38 92.77,94.38 92.86,94.29 93.21,94.29 93.3,94.38 93.61,94.38 93.71,94.48 93.71,94.62 93.61,94.72 93.13,94.72 93.03,94.82 93.03,95.1 93.13,95.2 93.97,95.2 94.06,95.29 94.06,95.43 93.97,95.53 93.13,95.53 93.03,95.63 93.03,95.83 92.94,95.93 92.8,95.93 92.7,95.83 92.7,94.85 92.6,94.75 92.46,94.75 92.36,94.85 92.36,96.48 92.27,96.58 92.13,96.58 92.03,96.48 92.03,95.08 91.93,94.99 91.79,94.99 91.69,95.08 91.69,98.27 91.79,98.37 91.93,98.37 92.03,98.27 92.03,97.08 92.13,96.98 92.27,96.98 92.36,97.08 92.36,98.58 92.46,98.67 92.6,98.67 92.7,98.58 92.7,97.95 92.9,97.75 93.13,97.75 93.23,97.65 93.23,97.51 93.13,97.42 92.83,97.42 92.73,97.32 92.73,97.18 92.83,97.08 93.59,97.08 93.69,96.98 93.69,96.84 93.59,96.75 92.83,96.75 92.73,96.65 92.73,96.51 92.83,96.41 93.82,96.41 93.92,96.31 93.92,95.99 94.02,95.89 94.16,95.89 94.26,95.99 94.26,96.31 94.36,96.41 95.56,96.41 95.66,96.51 95.66,96.65 95.56,96.75 94.17,96.75 94.07,96.84 94.07,96.98 94.17,97.08 96.18,97.08 96.28,97.18 96.28,97.32 96.18,97.42 93.87,97.42 93.77,97.51 93.77,97.65 93.87,97.75 96.39,97.75 96.49,97.85 96.49,97.99 96.39,98.09 93.93,98.09 93.62,98.4 93.28,98.4 93.16,98.52 93.16,98.89 93.39,99.12 93.39,99.51 93.49,99.61 93.63,99.61 93.73,99.51 93.73,98.82 93.83,98.72 93.96,98.72 94.06,98.82 94.06,99.49 94.16,99.59 94.3,99.59 94.4,99.49 94.4,98.61 94.5,98.51 95.03,98.51 95.15,98.63 95.15,98.88 95.08,98.96 94.9,98.96 94.73,99.12 94.73,99.41 94.91,99.58 95.42,99.58 95.53,99.47 95.53,98.61 95.63,98.51 95.77,98.51 95.87,98.61 95.87,99.47 95.97,99.57 96.13,99.57 96.23,99.47 96.23,98.63 96.33,98.53 96.46,98.53 96.56,98.63 96.56,99.47 96.66,99.57 96.8,99.57 96.9,99.47 96.9,98.49 97,98.39 97.17,98.39 97.27,98.49 97.27,100.22 97.47,100.42 99.51,100.42 99.74,100.18 99.87,100.18 99.99,100.3 99.99,100.44 99.83,100.59 99.83,101.01 100.04,101.21 100.47,101.21 100.65,101.39 101.03,101.39 101.21,101.21 102.28,101.21 102.4,101.34 102.4,101.78 102.64,102.02 103.05,102.02 103.15,101.92 103.15,101.72 103.27,101.6 v1(104.49,101.6)
DDR4_DIMM2_A13: length 104.7
  L16_SIG6 w0.081: v1(129.14,107.6) 129.54,107.6 129.67,107.73 129.67,108.28 129.8,108.4 130.04,108.4 130.17,108.28 130.17,107.73 130.73,107.17 131.79,107.17 132.12,107.5 132.95,107.5 133.63,106.81 136.05,106.81 136.41,107.17 137.4,107.17 137.81,107.58 140.26,107.58 140.64,107.2 141.73,107.2 141.94,106.99 141.94,105.68 141.82,105.56 141.19,105.56 141.07,105.68 141.07,106.58 140.94,106.71 140.73,106.71 140.6,106.58 140.6,105.7 140.48,105.57 140.27,105.57 140.14,105.7 140.14,106.81 140.01,106.94 139.81,106.94 139.68,106.81 139.68,105.64 139.55,105.52 139.34,105.52 139.22,105.64 139.22,106.58 139.09,106.71 138.88,106.71 138.75,106.58 138.75,105.67 138.63,105.54 138.42,105.54 138.29,105.67 138.29,106.58 138.16,106.71 137.96,106.71 137.83,106.58 137.83,105.68 137.7,105.55 137.49,105.55 137.37,105.68 137.37,106.58 137.24,106.71 137.03,106.71 136.91,106.58 136.91,105.63 136.78,105.5 136.57,105.5 136.44,105.63 136.44,106.3 136.32,106.43 136.11,106.43 135.98,106.3 135.98,105.98 135.85,105.86 135.68,105.86 135.47,106.07 135.47,106.3 135.3,106.46 133.94,106.46 132.3,104.83 128.52,104.83 127.17,103.48 127.17,102.66 126.54,102.02 126.54,101.79 126.18,101.43 126.18,99.48 126.08,99.37 125.41,99.37 125.3,99.48 125.3,100.01 125.2,100.11 125.01,100.11 124.91,100.01 124.91,99.12 125.02,99.01 126.08,99.01 126.18,98.91 126.18,98.76 126.08,98.65 125.02,98.65 124.91,98.55 124.91,98.4 125.02,98.29 126.08,98.29 126.18,98.19 126.18,98.04 126.08,97.93 125.2,97.93 125.1,97.83 125.1,97.68 125.2,97.58 125.91,97.58 126.01,97.48 126.01,97.34 125.91,97.24 124.68,97.24 124.58,97.13 124.58,96.95 124.68,96.85 125.18,96.85 125.28,96.75 125.28,96.59 125.18,96.48 124.7,96.48 124.48,96.27 124.48,95.96 124.38,95.86 122.86,95.86 122.76,95.96 122.76,96.32 122.57,96.51 121.92,96.51 121.77,96.37 121.77,95.8 121.63,95.65 120.32,95.65 118.99,94.32 115.98,94.32 115.84,94.46 114.48,94.46 114.29,94.27 113.72,94.27 113.23,94.76 111.9,94.76 111.44,94.3 111.14,94.3 110.71,94.73 109.25,94.73 109.05,94.53 108.53,94.53 108.33,94.73 106.66,94.73 106.48,94.56 106.29,94.56 106.22,94.62 106.08,94.62 105.97,94.51 105.97,94.38 106.07,94.28 106.07,94.15 105.97,94.04 105.83,94.04 105.48,94.4 105.17,94.4 104.91,94.13 104.91,93.74 104.73,93.56 104.29,93.56 104.04,93.31 104.04,92.52 101.04,89.51 100.31,89.51 99.17,88.37 99.17,86.2 96.58,83.6 96.58,80.25 v1(96.19,79.87)
DDR4_DIMM2_A14: length 104.6
  L16_SIG6 w0.081: v1(95.39,79.41) 95,79.8 95,83.15 97.65,85.8 97.65,86.47 97.48,86.65 97.48,86.98 97.58,87.08 97.58,87.36 97.73,87.51 98.14,87.51 98.35,87.71 98.35,88.65 99.97,90.27 100.68,90.27 103.22,92.8 103.22,93.78 104.05,94.61 104.05,95.24 105.28,96.47 106.51,96.47 106.6,96.38 106.6,95.96 106.7,95.86 106.84,95.86 106.94,95.96 106.94,96.38 107.04,96.47 107.18,96.47 107.27,96.38 107.27,96.03 107.37,95.93 107.51,95.93 107.61,96.03 107.61,96.38 107.71,96.47 107.85,96.47 107.95,96.38 107.95,96.03 108.04,95.93 108.18,95.93 108.28,96.03 108.28,96.38 108.38,96.47 109.83,96.47 110.1,96.2 113.86,96.2 115.43,97.77 116.11,97.77 116.61,98.27 116.61,98.76 116.89,99.03 116.89,99.52 117.16,99.79 120.23,99.79 120.45,99.58 121.06,99.58 121.28,99.35 121.77,99.35 121.93,99.2 121.93,98.76 122.03,98.66 122.18,98.66 122.28,98.77 122.28,99.5 122.39,99.6 123.09,99.6 123.19,99.5 123.19,99.24 123.09,99.14 122.75,99.14 122.64,99.03 122.64,98.77 122.75,98.66 122.97,98.66 123.08,98.56 123.08,98.37 122.97,98.27 122.03,98.27 121.93,98.17 121.93,98.03 122.05,97.9 123.33,97.9 123.6,98.18 123.6,101.76 123.85,102.01 125.22,102.01 125.33,102.11 125.33,102.82 125.11,103.04 125.11,103.27 125.33,103.49 125.33,103.95 125.43,104.06 125.67,104.06 125.81,103.92 125.81,102.04 125.91,101.94 126.05,101.94 126.15,102.04 126.15,105.12 126.25,105.22 126.48,105.22 126.58,105.12 126.58,104.25 126.69,104.15 126.84,104.15 126.94,104.25 126.94,105.13 127.05,105.23 127.26,105.23 127.36,105.13 127.36,104.58 127.47,104.48 127.67,104.48 127.88,104.69 127.88,105.97 128,106.08 128.57,106.08 128.68,105.98 128.68,105.28 128.78,105.18 128.93,105.18 129.04,105.28 129.04,106.56 129.14,106.67 129.29,106.67 129.4,106.56 129.4,105.28 129.51,105.18 129.65,105.18 129.76,105.28 129.76,105.98 129.87,106.08 130.02,106.08 130.12,105.98 130.12,105.28 130.23,105.18 130.38,105.18 130.48,105.28 130.48,105.98 130.59,106.08 130.74,106.08 130.84,105.98 130.84,105.28 130.95,105.18 131.5,105.18 131.6,105.28 131.6,105.7 131.7,105.8 131.85,105.8 131.95,105.7 131.95,105.4 132.05,105.3 132.27,105.3 132.47,105.5 132.47,105.65 132.27,105.86 132.27,106 132.37,106.1 132.51,106.1 132.71,105.9 132.86,105.9 133.31,106.34 133.31,106.65 132.86,107.1 132.25,107.1 131.86,106.72 131.68,106.72 131.57,106.61 131.57,106.19 131.47,106.09 131.32,106.09 131.21,106.19 131.21,106.61 131.11,106.72 130.56,106.72 130.2,107.07 128.45,107.07 128.35,107.17 128.35,107.81 128.45,107.91 128.63,107.91 128.73,108.01 128.73,108.34 128.63,108.44 127.99,108.44 127.89,108.34 127.89,107.18 127.79,107.07 127.5,107.07 127.39,106.97 127.39,106.82 127.5,106.71 127.79,106.71 127.89,106.61 127.89,106.46 127.77,106.34 127.56,106.34 127.09,105.88 126.95,105.88 126.81,106.01 126.81,106.16 127.05,106.39 127.05,108.34 126.95,108.44 126.25,108.44 126.15,108.34 126.15,108.1 126.25,107.99 126.56,107.99 126.65,107.9 126.65,107.15 126.55,107.06 126.41,107.06 126.32,107.15 126.32,107.5 126.22,107.6 v1(125.74,107.6)
DDR4_DIMM2_A15: length 103.1
  L16_SIG6 w0.081: v1(96.19,78.03) 96.19,78.41 96.73,78.95 97.11,78.95 97.37,79.2 97.37,83.43 100.46,86.53 100.46,88.24 100.95,88.73 101.4,88.73 104.94,92.27 105.28,92.27 106.62,93.6 113.18,93.6 113.67,93.11 115.97,93.11 116.46,93.6 119.24,93.6 120.37,94.73 121.85,94.73 122.03,94.54 122.4,94.54 122.78,94.92 124.21,94.92 124.55,94.59 125.04,94.59 125.58,95.13 125.58,95.42 125.82,95.66 125.82,96.02 126.62,96.82 126.77,96.82 127.02,96.56 127.18,96.56 127.3,96.67 127.3,96.83 127.03,97.1 127.03,97.26 127.14,97.38 127.3,97.38 127.57,97.11 127.73,97.11 127.84,97.22 127.84,97.38 127.71,97.51 127.71,97.67 127.89,97.85 127.89,101.8 128.53,102.44 128.53,102.91 128.88,103.26 132.49,103.26 133.39,104.16 144.53,104.16 144.79,104.42 144.79,104.83 145.03,105.07 146.21,105.07 146.76,105.62 148.42,105.62 148.52,105.72 148.52,105.93 148.42,106.03 144.7,106.03 144.57,105.9 144.57,105.14 144.44,105.01 144.28,105.01 144.15,105.14 144.15,105.9 144.03,106.03 143.84,106.03 143.72,105.9 143.72,104.67 143.59,104.54 143.4,104.54 143.28,104.67 143.28,106.14 143.15,106.27 142.89,106.27 142.79,106.17 142.79,104.75 142.65,104.61 135.34,104.61 134.78,105.17 133.89,105.17 132.81,104.09 128.77,104.09 128.08,103.4 128.08,102.5 127.44,101.87 v1(127.44,101.6)
DDR4_DIMM2_A16: length 102.7
  L16_SIG6 w0.081: v1(124.04,101.6) 125.2,101.6 125.3,101.5 125.3,101.31 125.2,101.2 124.77,101.2 124.67,101.1 124.67,100.96 124.77,100.85 125.16,100.85 125.26,100.75 125.26,100.59 125.16,100.49 124.13,100.49 124.03,100.38 124.03,100.23 124.13,100.13 124.43,100.13 124.54,100.02 124.54,99.87 124.43,99.77 124.13,99.77 124.03,99.66 124.03,99.51 124.13,99.41 124.43,99.41 124.54,99.3 124.54,97.82 124.18,97.46 124.18,96.51 124.07,96.41 123.92,96.41 123.82,96.51 123.82,97.55 123.71,97.66 123.56,97.66 123.46,97.55 123.46,96.31 123.35,96.2 123.2,96.2 123.1,96.31 123.1,96.88 122.99,96.99 122.87,96.99 122.76,97.09 122.76,97.46 122.66,97.57 122.51,97.57 122.4,97.46 122.4,97.09 122.3,96.99 122.15,96.99 122.04,97.09 122.04,97.46 121.94,97.57 121.79,97.57 121.68,97.46 121.68,96.83 121.43,96.57 121.43,96.18 121.33,96.08 121.16,96.08 121.06,96.18 121.06,96.4 120.95,96.51 120.63,96.51 120.52,96.61 120.52,96.76 120.63,96.87 121.22,96.87 121.33,96.97 121.33,97.12 121.22,97.23 120.63,97.23 120.52,97.34 120.52,97.48 120.63,97.59 120.95,97.59 121.06,97.7 121.06,99.04 120.93,99.16 120.79,99.16 120.69,99.06 120.69,98.31 120.59,98.21 120.45,98.21 120.36,98.31 120.36,99.16 120.09,99.42 119.75,99.42 119.65,99.32 119.65,99.02 119.55,98.92 119.41,98.92 119.32,99.02 119.32,99.32 119.22,99.42 119.08,99.42 118.98,99.32 118.98,99.02 118.88,98.92 118.74,98.92 118.65,99.02 118.65,99.32 118.55,99.42 118.41,99.42 118.31,99.32 118.31,99.02 118.21,98.92 118.07,98.92 117.98,99.02 117.98,99.32 117.88,99.42 117.45,99.42 117.34,99.32 117.34,95.16 117.45,95.06 118.59,95.06 118.7,94.96 118.7,94.77 118.59,94.66 117.03,94.66 116.93,94.76 116.93,97.77 116.83,97.87 116.69,97.87 116.59,97.77 116.59,94.79 116.49,94.69 116.35,94.69 116.26,94.79 116.26,97.22 116.16,97.32 116.02,97.32 115.92,97.22 115.92,95.88 115.82,95.78 115.68,95.78 115.59,95.88 115.59,97.02 115.49,97.12 115.35,97.12 115.25,97.02 115.25,96.89 115.14,96.78 114.92,96.78 114.82,96.68 114.82,96.53 114.92,96.42 115.14,96.42 115.25,96.32 115.25,96.17 115.14,96.06 114.3,96.06 114.2,95.95 114.2,95.81 114.3,95.7 115.14,95.7 115.25,95.59 115.25,94.97 115.11,94.83 114.37,94.83 114.09,95.11 113.93,95.11 113.83,95.2 113.83,95.74 113.73,95.83 110,95.83 109.9,95.74 109.9,95.6 110,95.5 113.2,95.5 113.3,95.4 113.3,95.26 113.2,95.16 109.45,95.16 109.36,95.26 109.36,95.63 109.25,95.74 109,95.74 108.84,95.57 108.36,95.57 108.26,95.47 108.26,95.18 108.17,95.08 108.03,95.08 107.93,95.18 107.93,95.47 107.83,95.57 107.69,95.57 107.59,95.47 107.59,95.18 107.5,95.08 107.36,95.08 107.26,95.18 107.26,95.47 107.16,95.57 107.02,95.57 106.92,95.47 106.92,95.18 106.82,95.08 106.69,95.08 106.59,95.18 106.59,95.47 106.49,95.57 105.93,95.57 105.79,95.72 105.79,95.99 105.64,96.13 105.45,96.13 105.21,95.89 105.21,95.75 105.75,95.2 105.75,95.06 105.66,94.96 105.52,94.96 104.97,95.51 104.83,95.51 104.73,95.41 104.73,95.27 105.09,94.92 105.09,94.78 104.99,94.68 104.85,94.68 104.62,94.91 104.48,94.91 104.39,94.81 104.39,94.67 104.45,94.61 104.45,94.47 103.61,93.63 103.61,92.58 100.91,89.89 100.14,89.89 98.75,88.5 98.75,87.59 98.37,87.21 98.37,86.64 98.04,86.31 98.04,85.59 95.79,83.34 95.79,78.88 v1(95.39,78.49)
DDR4_DIMM2_A17: length 105
  L16_SIG6 w0.081: v1(130.84,107.6) 131.24,108 136.1,108 136.48,108.38 154.48,108.38 155.09,107.77 155.09,105.64 153.58,104.13 153.26,104.13 153.12,104.27 153.12,104.72 152.99,104.86 152.8,104.86 152.66,104.72 152.66,104.27 152.52,104.13 152.33,104.13 152.2,104.27 152.2,104.72 152.06,104.86 151.87,104.86 151.74,104.72 151.74,104.27 151.6,104.13 151.41,104.13 151.27,104.27 151.27,104.72 151.14,104.86 150.95,104.86 150.81,104.72 150.81,104.45 150.63,104.27 150.11,104.27 149.93,104.09 149.93,103.62 149.04,102.72 137.28,102.72 136.94,102.38 136.94,101.69 136.47,101.23 133.19,101.23 132.78,101.65 132.37,101.65 131.95,102.06 129.81,102.06 129.54,101.79 129.54,101.07 129.78,100.83 129.78,99.81 129.23,99.27 129.23,97.5 127.01,95.27 127.01,94.92 126.2,94.1 126.2,93.86 125.9,93.56 120.4,93.56 119.74,92.9 116.7,92.9 116.14,92.33 106.46,92.33 105.54,91.42 105.09,91.42 101.76,88.08 101.76,86.61 98.2,83.05 98.2,80.29 v1(97.79,79.87)
DDR4_DIMM2_ACT_N: length 102.7
  L16_SIG6 w0.081: v1(89.02,78.49) 88.65,78.86 88.65,79.12 88.39,79.38 88.13,79.38 87.84,79.67 87.84,84.64 87.94,84.73 88.08,84.73 88.18,84.64 88.18,83 88.27,82.9 88.41,82.9 88.51,83 88.51,87.36 88.41,87.45 88.27,87.45 88.18,87.36 88.18,85.21 88.08,85.11 87.94,85.11 87.84,85.21 87.84,88.01 87.7,88.15 87.32,88.15 87.22,88.26 87.22,90.24 87.32,90.34 87.47,90.34 87.58,90.24 87.58,88.62 87.68,88.52 87.83,88.52 87.94,88.62 87.94,90.19 88.04,90.29 88.18,90.29 88.27,90.19 88.27,87.95 88.37,87.85 88.51,87.85 88.61,87.95 88.61,93.01 88.51,93.11 88.37,93.11 88.27,93.01 88.27,90.8 88.18,90.7 87.34,90.7 87.22,90.83 87.22,93.45 87.32,93.55 87.47,93.55 87.58,93.45 87.58,91.17 87.68,91.07 87.83,91.07 87.94,91.17 87.94,93.39 88.11,93.56 88.59,93.56 88.77,93.74 88.77,94.09 88.51,94.36 87.68,94.36 87.58,94.46 87.58,94.6 87.68,94.71 88.2,94.71 88.33,94.83 88.33,96.39 90.05,98.11 90.05,98.26 89.95,98.36 89.8,98.36 88.35,96.92 88.2,96.92 88.1,97.02 88.1,97.24 88.28,97.43 88.28,97.58 88.02,97.84 88.02,97.99 88.12,98.1 88.27,98.1 88.54,97.83 88.69,97.83 88.79,97.94 88.79,98.09 88.68,98.2 88.68,98.35 88.78,98.46 88.93,98.46 89.05,98.34 89.2,98.34 90.01,99.15 90.01,99.34 90.48,99.81 90.48,100.16 90.27,100.36 90.09,100.36 90,100.45 90,101.11 90.11,101.21 90.31,101.21 90.48,101.38 90.48,101.72 90.16,102.04 90.16,103.31 90.03,103.44 89.47,103.44 89.34,103.57 89.34,103.71 89.43,103.81 89.61,103.81 89.71,103.91 89.71,104.05 89.61,104.15 89.43,104.15 89.34,104.24 89.34,105.81 90.02,106.5 90.02,107.03 90.44,107.44 90.44,107.76 90.69,108.02 95.16,108.02 95.36,107.82 95.66,107.82 95.86,108.02 97.04,108.02 97.18,107.87 97.41,107.87 97.55,108.02 98.66,108.02 98.95,107.73 98.95,107.42 99.18,107.19 99.63,107.19 99.95,107.51 102.04,107.51 102.17,107.64 102.17,107.82 102.04,107.95 100.83,107.95 100.7,108.08 100.7,108.26 100.83,108.39 102.18,108.39 102.58,107.99 104.41,107.99 104.56,108.14 104.56,108.35 104.69,108.48 104.82,108.48 104.94,108.35 104.94,107.55 104.84,107.46 104.09,107.46 103.99,107.36 103.99,107.22 104.09,107.12 104.7,107.12 104.92,106.91 104.92,105.25 104.78,105.11 104.78,102.72 104.07,102.01 103.56,102.01 103.2,102.37 102.5,102.37 101.99,101.87 v1(101.99,101.6)
DDR4_DIMM2_ALERT_N: length 106.4
  L12_SIG4 w0.089: v1(100.97,81.71) 100.57,82.11 100.57,82.47 100.3,82.74 98.97,82.74 98.69,83.02 98.69,87.16 98.59,87.26 98.16,87.26 98.06,87.36 98.06,87.51 98.16,87.61 98.59,87.61 98.69,87.71 98.69,88.06 98.59,88.16 98.31,88.16 98.21,88.26 98.21,88.41 98.31,88.51 98.59,88.51 98.69,88.61 98.69,90.46 98.59,90.56 98.45,90.56 98.35,90.46 98.35,89.2 98.25,89.1 98.11,89.1 98.01,89.2 98.01,92.38 98.11,92.48 98.25,92.48 98.35,92.38 98.35,91.09 98.45,90.99 98.59,90.99 98.69,91.09 98.69,92.48 98.79,92.59 100.46,92.59 100.77,92.89 100.77,94.63 100.61,94.78 100.61,95.47 100.51,95.57 100.33,95.57 100.23,95.47 100.23,94.78 100.13,94.68 99.92,94.68 99.82,94.78 99.82,95.47 99.72,95.57 99.1,95.57 99,95.47 99,94.53 98.9,94.43 98.74,94.43 98.64,94.53 98.64,95.48 98.54,95.58 98.39,95.58 98.29,95.48 98.29,94.53 98.19,94.43 98.05,94.43 97.95,94.53 97.95,95.48 97.85,95.58 97.71,95.58 97.61,95.48 97.61,94.53 97.51,94.43 97.36,94.43 97.26,94.53 97.26,97.42 97.36,97.52 97.5,97.52 97.6,97.42 97.6,96.07 97.7,95.97 97.85,95.97 97.95,96.07 97.95,97.42 98.05,97.52 98.19,97.52 98.29,97.42 98.29,96.07 98.39,95.97 98.53,95.97 98.63,96.07 98.63,97.54 98.73,97.64 98.88,97.64 98.98,97.54 98.98,96.07 99.08,95.97 99.22,95.97 99.32,96.07 99.32,97.51 99.42,97.61 99.56,97.61 99.66,97.51 99.66,96.07 99.76,95.97 99.9,95.97 100,96.07 100,96.94 100.1,97.04 100.25,97.04 100.35,96.94 100.35,96.07 100.45,95.97 100.59,95.97 100.69,96.07 100.69,97.22 99.79,98.12 99.79,98.33 99.69,98.43 98.03,98.43 97.93,98.53 97.93,98.67 98.03,98.77 99.69,98.77 99.79,98.87 99.79,99.02 99.69,99.12 98.1,99.12 98,99.22 98,99.36 98.1,99.46 99.69,99.46 99.79,99.56 99.79,102.89 99.11,103.58 99.11,105.09 99.21,105.19 99.35,105.19 99.45,105.09 99.45,103.85 99.52,103.77 99.71,103.77 99.79,103.85 99.79,105.36 100.76,106.33 100.76,108.37 100.86,108.47 102.29,108.47 102.39,108.37 102.39,108.23 102.29,108.13 101.2,108.13 101.1,108.03 101.1,107.88 101.2,107.78 102.29,107.78 102.39,107.68 102.39,107.54 102.29,107.44 101.47,107.44 101.37,107.34 101.37,107.2 101.47,107.1 111.35,107.1 111.55,107.3 111.55,107.81 111.38,107.98 110.09,107.98 109.99,107.88 109.99,107.64 109.89,107.54 109.57,107.54 109.47,107.64 109.47,107.89 109.37,107.99 107.35,107.99 107.22,108.12 107.22,108.55 107.09,108.67 106.88,108.67 106.75,108.55 106.75,108.11 106.62,107.98 104.99,107.98 104.86,108.11 104.86,108.55 104.73,108.67 104.52,108.67 104.39,108.55 104.39,108.15 104.26,108.03 103.75,108.03 103.64,107.92 v1(103.64,107.6)
DDR4_DIMM2_BA0: length 104.5
  L14_SIG5 w0.081: v1(123.19,101.6) 123.19,104.53 123.76,105.09 128.31,105.09 128.63,104.77 128.63,103.39 128.86,103.16 129.72,103.16 129.97,103.41 129.97,105.74 129.62,106.08 123.69,106.08 119.75,102.14 117.71,102.14 116.32,100.75 114.41,100.75 113.26,99.59 111.94,99.59 111.65,99.89 111.13,99.89 110.79,99.54 110.25,99.54 109.96,99.83 109.33,99.83 108.97,99.47 107.76,99.47 107.37,99.86 106.81,99.86 106.5,99.54 105.19,99.54 104.5,100.23 104.5,100.54 103.61,101.43 103.61,101.79 101.3,104.09 100.93,104.09 100.64,103.8 100.32,103.8 100.05,104.07 98.84,104.07 98.7,104.2 97.77,104.2 97.08,104.9 94.33,104.9 94.11,105.12 92.38,105.12 92.16,104.9 90.28,104.9 89.92,104.55 89.81,104.5 89.57,104.5 89.32,104.75 89.32,104.98 88.89,105.41 87.89,105.41 87.32,104.84 85.95,104.84 84.31,103.21 84.31,103.04 84.65,102.71 84.65,102.54 84.53,102.42 84.36,102.42 84.03,102.75 83.86,102.75 83.74,102.63 83.74,102.46 83.99,102.21 83.99,102.05 83.87,101.93 83.7,101.93 83.45,102.18 83.28,102.18 82.85,101.74 82.85,101.51 81.95,100.61 81.95,99.63 81.19,98.86 81.19,96.05 81.88,95.36 81.88,94.66 82.46,94.08 82.46,93.54 85.71,90.28 87.43,90.28 89.03,88.68 90.01,88.68 90.38,88.32 90.38,87.66 90.72,87.32 90.99,87.32 91.24,87.07 91.24,86.95 92.9,85.29 93.43,85.29 93.92,84.79 94.91,84.79 97.37,82.33 97.37,80.11 96.99,79.74 v1(96.99,79.41)
DDR4_DIMM2_BA1: length 104.1
  L16_SIG6 w0.081: v1(122.34,107.6) 121.31,107.6 121.16,107.75 121.16,108.33 121.26,108.44 121.55,108.44 121.65,108.33 121.65,108.16 121.76,108.06 123.46,108.06 123.56,108.16 123.56,108.34 123.67,108.45 123.94,108.45 124.05,108.34 124.05,107.97 124.16,107.87 124.44,107.87 124.55,107.97 124.55,108.34 124.65,108.45 124.83,108.45 124.94,108.34 124.94,108.04 125.04,107.93 125.23,107.93 125.36,107.8 125.36,107.57 125.26,107.47 124.04,107.47 123.93,107.36 123.93,107.21 124.04,107.11 124.35,107.11 124.45,107 124.45,106.45 124.56,106.34 124.73,106.34 124.82,106.44 124.82,106.89 124.92,106.99 125.13,106.99 125.23,106.89 125.23,106.57 125.33,106.47 125.61,106.47 125.71,106.57 125.71,106.79 125.81,106.89 125.99,106.89 126.1,106.79 126.1,106.09 125.99,105.98 125.21,105.98 125.11,105.88 125.11,105.68 125.21,105.57 125.69,105.57 125.79,105.46 125.79,105.31 125.69,105.21 125.21,105.21 125.11,105.1 125.11,104.95 125.21,104.85 125.69,104.85 125.79,104.74 125.79,104.59 125.69,104.49 125.21,104.49 125.11,104.38 125.11,104.22 125,104.12 124.85,104.12 124.75,104.22 124.75,105.88 124.64,105.98 123.75,105.98 123.56,106.17 123.56,107.12 123.46,107.22 123.27,107.22 123.17,107.12 123.17,106.89 123.06,106.78 122.93,106.78 122.82,106.89 122.82,107.19 122.72,107.3 122.57,107.3 122.46,107.19 122.46,106.89 122.36,106.78 122.19,106.78 122.08,106.67 122.08,106.53 122.19,106.42 122.85,106.42 122.96,106.31 122.96,104.22 123.05,104.13 123.19,104.13 123.29,104.22 123.29,105.53 123.36,105.59 123.57,105.59 123.67,105.49 123.67,104.22 123.77,104.12 123.91,104.12 124.01,104.22 124.01,105.02 124.11,105.12 124.31,105.12 124.4,105.03 124.4,103.91 124.25,103.76 122.86,103.76 122.76,103.66 122.76,103.53 122.86,103.43 124.34,103.43 124.44,103.33 124.44,103.19 124.34,103.09 122.86,103.09 122.76,102.99 122.76,102.86 122.86,102.76 124.36,102.76 124.46,102.66 124.46,102.51 124.34,102.39 123.17,102.39 123.05,102.28 122.37,102.28 122.27,102.17 122.27,101.99 122.37,101.89 122.7,101.89 122.8,101.79 122.8,101.65 122.7,101.56 122.44,101.56 122.32,101.44 122.32,101.32 122.42,101.22 122.67,101.22 122.76,101.14 122.76,100.69 122.51,100.44 122.21,100.44 121.82,100.05 121.17,100.05 120.87,100.35 120.44,100.35 119.97,100.83 117.92,100.83 117.82,100.73 117.82,100.59 117.92,100.49 119.75,100.49 119.84,100.39 119.84,100.25 119.75,100.15 116.98,100.15 116.51,99.69 116.51,99.16 116.25,98.9 116.25,98.48 115.91,98.14 115.28,98.14 113.68,96.55 110.24,96.55 109.98,96.81 105.13,96.81 103.98,95.66 103.44,95.66 103.34,95.56 103.34,95.24 103.23,95.13 102.73,95.13 102.65,95.06 102.65,94.81 102.76,94.71 103.18,94.71 103.28,94.61 103.28,94.47 103.18,94.36 102.59,94.36 102.18,94.78 102.03,94.78 101.93,94.68 101.93,94.53 102.35,94.12 102.35,92.58 100.4,90.63 99.76,90.63 98.32,89.19 97.79,89.19 97.22,88.63 97.22,87.2 97.09,87.07 97.09,86.54 97.22,86.4 97.22,85.87 94.22,82.86 94.22,78.77 94.52,78.46 94.8,78.46 95.23,78.03 95.56,78.03 96.04,77.55 96.4,77.55 96.88,78.03 v1(97.79,78.03)
DDR4_DIMM2_BG0: length 104.2
  L14_SIG5 w0.081: v1(96.99,78.49) 96.99,78.81 97.6,79.42 97.92,79.42 98.2,79.71 98.2,82.02 95.09,85.13 94.06,85.13 93.54,85.65 93.01,85.65 91.62,87.04 91.62,87.62 90.17,89.08 89.19,89.08 87.64,90.62 86.18,90.62 86.05,90.75 86.05,90.93 86.44,91.31 86.44,91.48 86.32,91.6 86.15,91.6 85.64,91.09 85.47,91.09 85.35,91.21 85.35,91.38 85.9,91.93 85.9,92.1 85.78,92.21 85.61,92.21 85.07,91.67 84.9,91.67 84.78,91.78 84.78,91.95 85.28,92.45 85.28,92.62 85.16,92.74 84.99,92.74 84.49,92.24 84.32,92.24 84.2,92.36 84.2,92.53 84.71,93.04 84.71,93.2 84.59,93.32 84.42,93.32 83.92,92.82 83.75,92.82 83.63,92.93 83.63,93.1 83.93,93.4 83.93,93.57 83.81,93.69 83.64,93.69 83.34,93.39 83.17,93.39 82.84,93.72 82.84,94.28 82.96,94.4 84.03,94.4 84.14,94.52 84.14,94.69 84.03,94.8 82.96,94.8 82.84,94.92 82.84,95.09 82.96,95.21 84.38,95.21 84.5,95.33 84.5,95.5 84.38,95.62 82.26,95.62 81.99,95.88 81.99,96.36 82.11,96.47 83.56,96.47 83.88,96.15 84.41,96.15 84.55,96.3 84.55,96.76 84.43,96.88 82.21,96.88 82.09,97 82.09,97.17 82.21,97.29 84.43,97.29 84.55,97.41 84.55,97.57 84.43,97.69 81.71,97.69 81.59,97.81 81.59,97.98 81.71,98.1 84.43,98.1 84.55,98.22 84.55,98.84 84.43,98.96 84.21,98.96 84.09,98.84 84.09,98.63 83.97,98.51 81.86,98.51 81.73,98.64 81.73,98.76 81.86,98.89 83.48,98.89 83.7,99.11 83.7,99.37 83.51,99.56 82.98,99.56 82.66,99.25 82.49,99.25 82.42,99.32 82.42,99.48 82.86,99.92 82.86,100.27 82.78,100.35 82.54,100.35 82.47,100.42 82.47,100.61 82.54,100.69 82.76,100.69 82.86,100.78 82.86,101.02 83.01,101.17 83.15,101.17 83.25,101.07 83.25,100.82 83.34,100.72 83.48,100.72 83.58,100.82 83.58,101.12 83.68,101.22 83.82,101.22 83.92,101.12 83.92,100.82 84.02,100.72 84.15,100.72 84.25,100.82 84.25,101.12 84.35,101.22 84.49,101.22 84.59,101.12 84.59,100.82 84.69,100.72 84.82,100.72 84.92,100.82 84.92,101.12 85.02,101.22 85.31,101.22 85.41,101.32 85.41,101.84 85.27,101.98 85.05,101.98 84.96,102.07 84.96,102.32 85.03,102.38 85.53,102.38 85.67,102.52 85.67,102.69 85.13,103.23 85.13,103.4 85.26,103.53 85.42,103.53 85.97,102.99 86.14,102.99 86.26,103.11 86.26,103.28 85.72,103.83 85.72,103.99 85.85,104.12 86.02,104.12 86.89,103.24 87.06,103.24 87.18,103.36 87.18,103.53 86.52,104.19 86.52,104.36 86.64,104.48 86.8,104.48 87.45,103.84 87.67,103.84 87.79,103.95 87.79,104.8 87.9,104.91 88.06,104.91 88.17,104.8 88.17,103.95 88.29,103.84 88.45,103.84 88.56,103.95 88.56,104.84 88.67,104.95 88.83,104.95 88.94,104.84 88.94,103.95 89.06,103.84 89.58,103.84 89.91,104.16 90.09,104.24 90.42,104.56 92.36,104.56 92.57,104.77 93.98,104.77 94.19,104.56 96.94,104.56 97.63,103.87 98.57,103.87 98.7,103.73 99.92,103.73 100.47,103.18 101.23,103.18 101.38,103.32 101.55,103.32 101.83,103.04 101.83,102.87 101.4,102.45 101.4,102.28 101.52,102.16 101.69,102.16 102.12,102.59 102.29,102.59 102.79,102.08 v1(102.79,101.6)
DDR4_DIMM2_BG1: length 102.2
  L16_SIG6 w0.081: v1(102.79,107.6) 103.1,107.6 103.23,107.47 103.23,107.23 103.11,107.11 102.46,107.11 102.36,107.01 102.36,106.87 102.46,106.77 103.98,106.77 104.08,106.67 104.08,106.53 103.98,106.44 102.32,106.44 102.22,106.34 102.22,106.2 102.32,106.1 104.11,106.1 104.21,106 104.21,105.86 104.11,105.77 102.46,105.77 102.36,105.67 102.36,105.53 102.46,105.43 104.04,105.43 104.14,105.33 104.14,105.19 104.04,105.1 100.88,105.1 100.78,105.19 100.78,105.33 100.88,105.43 101.44,105.43 101.53,105.53 101.53,105.67 101.44,105.77 100.85,105.77 100.76,105.86 100.76,106 100.85,106.1 101.57,106.1 101.67,106.2 101.67,106.34 101.57,106.44 101.11,106.44 101.02,106.53 101.02,106.67 101.11,106.77 101.49,106.77 101.59,106.87 101.59,107.01 101.49,107.11 100.74,107.11 100.64,107.01 100.64,106.53 100.55,106.44 100.12,106.44 99.72,106.84 99.55,106.84 99.44,106.73 99.44,106.6 99.56,106.48 99.56,106.2 99.66,106.1 100.27,106.1 100.37,106 100.37,105.86 100.27,105.77 99.65,105.77 99.55,105.67 99.55,105.53 99.65,105.43 100.29,105.43 100.39,105.33 100.39,105.19 100.29,105.1 99.12,105.1 99.02,104.99 99.02,101.52 98.66,101.15 98.23,101.15 98.08,101.31 98.08,104.63 97.98,104.73 97.84,104.73 97.74,104.63 97.74,102.18 97.65,102.08 97.51,102.08 97.41,102.18 97.41,105.14 97.32,105.22 97.16,105.22 97.07,105.13 97.07,104.12 96.97,104.02 96.83,104.02 96.73,104.12 96.73,105.13 96.63,105.22 96.49,105.22 96.4,105.13 96.4,104.12 96.3,104.02 96.16,104.02 96.06,104.12 96.06,105.13 95.96,105.22 95.82,105.22 95.73,105.13 95.73,104.12 95.63,104.02 95.49,104.02 95.39,104.12 95.39,105.16 95.29,105.26 95.15,105.26 95.05,105.16 95.05,104.12 94.96,104.02 94.82,104.02 94.72,104.12 94.72,105.19 94.62,105.29 94.48,105.29 94.38,105.19 94.38,104.12 94.29,104.02 94.15,104.02 94.05,104.12 94.05,105.13 93.95,105.22 93.81,105.22 93.71,105.13 93.71,104.12 93.62,104.02 93.48,104.02 93.38,104.12 93.38,105.04 93.28,105.14 93.14,105.14 93.04,105.04 93.04,104.12 92.94,104.02 92.81,104.02 92.71,104.12 92.71,104.97 92.61,105.07 91.25,105.07 91.15,104.97 91.15,104.83 91.25,104.73 92.25,104.73 92.35,104.63 92.35,104.49 92.25,104.39 91.92,104.39 91.82,104.29 91.82,104.15 91.92,104.05 92.24,104.05 92.34,103.95 92.34,103.76 92.43,103.66 92.86,103.66 92.96,103.57 92.96,103.43 92.86,103.33 91.9,103.33 91.81,103.23 91.81,103.09 91.9,102.99 92.91,102.99 93.01,102.89 93.01,102.76 92.91,102.66 92.26,102.66 92.17,102.56 92.17,102.42 92.26,102.32 92.91,102.32 93.01,102.22 93.01,102.09 92.91,101.99 92.11,101.99 91.82,101.69 91.82,100.46 92.13,100.15 92.13,99.82 91,98.69 91,97.7 90.78,97.49 90.78,94.68 90.69,94.58 90.55,94.58 90.45,94.68 90.45,96.19 90.35,96.29 90.21,96.29 90.11,96.19 90.11,94.45 90.47,94.09 90.47,93.88 90.24,93.65 90.24,87.61 90.14,87.51 89.89,87.51 89.79,87.41 89.79,87.22 89.89,87.12 90.14,87.12 90.24,87.02 90.24,82.94 89.42,82.11 89.42,80.27 v1(89.82,79.87)
DDR4_DIMM2_C0: length 106
  L16_SIG6 w0.081: v1(97.79,81.71) 97.79,83.25 100.8,86.27 100.8,88.05 101.12,88.37 101.53,88.37 104.98,91.82 105.39,91.82 106.26,92.69 116.02,92.69 116.56,93.23 119.37,93.23 120.49,94.36 121.67,94.36 121.91,94.12 122.55,94.12 122.89,94.47 124.16,94.47 124.45,94.18 125.37,94.18 126,94.82 126,95.29 126.33,95.62 126.81,95.62 128.73,97.54 128.73,101.63 129.54,102.44 132.28,102.44 132.47,102.25 133.03,102.25 134.06,103.28 134.72,103.28 135.22,103.78 144.7,103.78 144.96,104.04 146.34,104.04 146.58,104.27 146.58,104.79 146.69,104.91 146.85,104.91 146.96,104.79 146.96,103.68 147.08,103.57 147.24,103.57 147.35,103.68 147.35,105.1 147.46,105.21 147.62,105.21 147.74,105.1 147.74,103.77 147.85,103.65 148.01,103.65 148.12,103.77 148.12,105.1 148.24,105.21 148.4,105.21 148.51,105.1 148.51,104.01 148.62,103.9 148.84,103.9 148.94,104 148.94,105.84 149.05,105.95 152.57,105.95 152.78,106.16 152.78,106.74 152.88,106.84 153.16,106.84 153.26,106.74 153.26,106.31 153.36,106.21 153.62,106.21 153.72,106.31 153.72,106.78 153.82,106.88 154.1,106.88 154.2,106.78 154.2,105.9 153.76,105.46 150.96,105.46 150.29,104.79 149.63,104.79 149.43,104.59 149.43,103.66 148.87,103.1 135.76,103.1 134.74,102.09 133.88,102.09 v1(133.39,101.6)
DDR4_DIMM2_C1: length 106.2
  L16_SIG6 w0.081: v1(133.39,107.6) 133.8,107.19 135.82,107.19 136.62,107.99 152.33,107.99 152.51,107.82 152.51,107.39 152.31,107.19 152.31,106.51 152.19,106.38 151.98,106.38 151.85,106.51 151.85,106.97 151.72,107.1 151.52,107.1 151.39,106.97 151.39,106.51 151.26,106.38 151.05,106.38 150.93,106.51 150.93,106.97 150.8,107.1 150.59,107.1 150.46,106.97 150.46,106.51 150.34,106.38 150.13,106.38 150,106.51 150,106.97 149.87,107.1 149.67,107.1 149.54,106.97 149.54,106.51 149.41,106.38 149.2,106.38 149.08,106.51 149.08,106.97 148.95,107.1 148.74,107.1 148.61,106.97 148.61,106.51 148.49,106.38 148.28,106.38 148.15,106.51 148.15,106.97 148.03,107.1 147.82,107.1 147.69,106.97 147.69,106.51 147.56,106.38 147.35,106.38 147.23,106.51 147.23,106.97 147.1,107.1 146.89,107.1 146.77,106.97 146.77,106.51 146.64,106.38 146.43,106.38 146.3,106.51 146.3,106.97 146.18,107.1 145.97,107.1 145.84,106.97 145.84,106.51 145.71,106.38 145.51,106.38 145.38,106.51 145.38,106.97 145.25,107.1 145.04,107.1 144.92,106.97 144.92,106.51 144.79,106.38 144.58,106.38 144.45,106.51 144.45,106.97 144.33,107.1 144.12,107.1 143.99,106.97 143.99,106.51 143.86,106.38 143.66,106.38 143.53,106.51 143.53,106.97 143.4,107.1 142.61,107.1 142.45,106.94 142.45,105.29 142.2,105.05 135.82,105.05 134.82,106.05 134.06,106.05 132.46,104.45 128.62,104.45 127.62,103.45 127.62,102.63 126.89,101.9 126.89,99.87 127.01,99.74 127.01,97.74 125.45,96.18 125.45,95.9 125.04,95.48 122.19,95.48 121.84,95.13 120.28,95.13 119.12,93.97 116.29,93.97 115.77,93.45 114.07,93.45 113.13,94.38 112.02,94.38 111.57,93.94 111.02,93.94 110.57,94.39 109.44,94.39 109.17,94.13 108.37,94.13 108.1,94.39 106.85,94.39 106,93.55 105.22,93.55 104.92,93.25 104.92,92.9 101.17,89.14 100.66,89.14 99.51,88 99.51,86.06 96.99,83.53 v1(96.99,82.17)
DDR4_DIMM2_CK_N0: length 105.1
  L16_SIG6 w0.076: 92.52,82.88 92.52,82.87 92.52,82.87 92.52,82.5 92.58,82.35 92.58,82.07 92.49,81.91 arc(92.43,81.67) 92.49,81.44 92.54,81.36 arc(92.57,81.22) 92.54,81.09 92.48,80.98 arc(92.43,80.76) 92.5,80.55 92.57,80.46 arc(92.6,80.34) 92.57,80.21 92.46,80.03 arc(92.42,79.88) 92.46,79.73 92.49,79.68 92.45,79.55 v1(92.21,79.41)
  L16_SIG6 w0.081: v1(112.99,101.6) 112.66,101.94 112.66,102.07 112.78,102.19 112.99,102.19 113.25,102.45 113.25,102.82 113.01,103.06 111.13,103.06 110.46,102.39 109.5,102.39 109.35,102.53 109.35,102.92 109.53,103.1 110.05,103.1 110.6,103.65 112.93,103.65 113.21,103.93 113.21,104.32 112.93,104.6 110.12,104.6 109.95,104.78 109.95,105.02 110.12,105.19 112.99,105.19 113.27,105.47 113.27,105.89 113.06,106.1 110.49,106.1 110.39,106.2 110.39,106.83 110.51,106.96 110.79,106.96 111.03,107.2 111.03,107.73 111.13,107.83 111.47,107.83 111.57,107.73 111.57,106.99 111.78,106.78 113.35,106.78 113.56,106.99 113.56,108.11 113.66,108.21 114.01,108.21 114.11,108.11 114.11,106.89 114.31,106.68 115.07,106.68 115.28,106.89 115.28,108.11 115.38,108.21 116.23,108.21 116.35,108.08 116.35,107.72 116.1,107.46 116.1,105.95 115.99,105.85 114.15,105.85 113.87,105.57 113.87,105.17 114.15,104.89 116.51,104.89 116.68,104.72 116.68,104.48 116.51,104.3 114.07,104.3 113.79,104.02 113.79,103.63 114.07,103.35 116.02,103.35 116.12,103.25 116.12,102.65 116,102.53 115.33,102.53 115.13,102.33 114.43,102.33 113.45,101.35 113.45,99.69 113.33,99.57 112.92,99.57 112.69,99.33 112.69,98.7 111.99,98 111.83,98 111.61,98.21 111.61,98.36 111.97,98.72 111.97,99.61 111.74,99.84 110.9,99.84 110.69,99.63 110.69,98.47 110.54,98.32 110.35,98.32 110.18,98.49 110.18,99.66 109.9,99.94 109.27,99.94 108.99,99.66 108.99,98.38 108.82,98.21 108.36,98.21 108.19,98.38 108.19,99.32 107.91,99.6 107.64,99.6 107.48,99.75 107.48,101.01 107.29,101.21 106.82,101.21 106.62,101 106.62,99.46 106.46,99.3 106.46,98.34 106.36,98.24 106.1,98.24 106,98.34 106,98.74 105.79,98.95 105.37,98.95 105.16,98.74 105.16,98.43 105.06,98.33 104.92,98.33 104.77,98.48 104.32,98.48 103.99,98.81 102.46,98.81 102.13,98.48 101.2,98.48 100.96,98.23 99.9,98.23 99.22,97.55 98.76,97.55 98.38,97.17 98.38,95.08 99.05,94.41 99.05,92.67 97.52,91.15 96.5,91.15 94.1,88.74 94.1,85.35 93.62,84.88 93.48,84.88 93.42,84.94 93.29,84.94 93.19,84.84 93.19,84.7 93.25,84.64 93.25,84.5 92.52,83.77 92.52,82.88
