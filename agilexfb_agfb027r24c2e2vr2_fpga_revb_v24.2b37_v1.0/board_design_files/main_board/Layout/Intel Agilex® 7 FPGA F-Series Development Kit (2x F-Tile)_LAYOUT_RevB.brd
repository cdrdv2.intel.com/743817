# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM1_DQ10: length 78.5
  L07_SIG3 w0.089: v1(68.79,93.98) 68.79,94.17 69.94,95.31 69.94,98.31 68.38,99.86 68.38,100.1 68,100.49 65.4,100.49 64.7,100.2 64.27,99.77 63.82,99.13 63.05,97.89 62.96,97.69 62.96,95.83 63.12,95.5 63.84,94.9 64.07,94.67 64.07,93.17 64,93.09 64,91.54 64.93,90.61 65.09,90.61 65.63,90.07 65.63,88.18 66.26,87.55 66.26,85.59 66.89,84.96 66.89,84.67 69.06,82.5 71.66,82.5 73,83.05 79.13,89.18 86.61,89.18 87.22,89.79 95.54,89.79 96.03,89.3 96.03,88.81 96.53,88.31 97.22,88.31 97.94,87.59 99.11,87.59 99.78,88.26 101.4,88.26 102.05,87.61 102.05,86.23 103.57,84.71 104.8,84.71 106.94,82.57 106.94,82.11 v1(107.35,81.71)
DDR4_DIMM1_DQ11: length 78
  L07_SIG3 w0.089: v1(106.55,80.33) 106.22,80.66 106.22,80.97 105.93,81.25 105.66,81.25 105.34,81.57 105.34,82.31 104.92,82.73 104.64,82.73 103.87,83.51 103.3,83.51 100.9,85.9 97.69,85.9 97.08,86.51 97.08,87 96.79,87.28 95.94,87.28 94.94,88.29 87.54,88.29 87.39,88.14 81.97,88.14 81.67,87.84 79.24,87.84 73.38,81.97 72.01,81.4 70.48,81.4 69.84,80.76 69.3,80.76 65.73,84.34 65.73,84.67 64.79,85.6 64.79,86.51 64.02,87.29 64.02,89.09 61.27,91.83 61.27,92.48 60.71,93.04 60.71,97.25 61.23,97.78 61.23,98.36 62.47,99.6 62.47,100.14 64.28,101.94 65.74,102.55 68.4,102.55 69.18,101.77 69.18,101.45 69.64,100.98 v1(69.64,99.98)
DDR4_DIMM1_DQ12: length 78.3
  L07_SIG3 w0.089: v1(61.14,93.98) 61.14,96.49 61.66,97 61.66,98.13 63.25,99.72 63.25,100.31 63.62,100.67 63.81,100.67 64.17,100.32 64.31,100.32 64.41,100.42 64.41,100.56 64.06,100.9 64.06,101.05 64.16,101.15 64.31,101.15 64.65,100.8 64.79,100.8 64.89,100.9 65,100.9 65.1,101 65.1,101.13 65.2,101.23 65.34,101.23 65.44,101.13 65.44,101 65.54,100.9 65.69,100.9 65.79,101 65.79,101.69 65.89,101.79 66.03,101.79 66.13,101.69 66.13,101 66.23,100.9 66.37,100.9 66.47,101 66.47,101.32 66.57,101.42 66.71,101.42 66.82,101.32 66.82,101 66.92,100.9 67.06,100.9 67.54,101.38 67.54,101.98 67.65,102.09 68.25,102.09 68.41,101.93 68.41,101.36 68.26,101.21 68.26,101 68.5,100.76 68.5,100.48 68.6,100.38 68.78,100.38 68.88,100.48 68.88,100.88 68.98,100.98 69.12,100.98 69.22,100.88 69.22,99.81 70.37,98.66 70.37,95.25 69.22,94.1 69.22,93.78 69.47,93.54 69.83,93.54 70.29,93.08 72.52,93.08 73.24,92.35 76.64,92.35 77.45,93.16 80.53,93.16 81,92.69 81.17,92.69 82.17,91.69 85.53,91.69 86.18,92.33 101.64,92.33 105.08,88.9 105.43,88.9 106.39,87.93 106.39,87.29 106.93,86.75 106.93,86.41 110.03,83.3 110.03,82.46 110.12,82.37 110.12,81.2 v1(110.53,80.79)
DDR4_DIMM1_DQ13: length 78.2
  L07_SIG3 w0.089: v1(110.53,81.71) 110.46,81.78 110.46,82.63 110.38,82.71 110.38,83.44 107.27,86.55 107.27,86.89 106.73,87.43 106.73,88.19 105.64,89.28 105.23,89.28 101.83,92.68 85.99,92.68 85.35,92.03 82.32,92.03 81.31,93.04 81.14,93.04 80.67,93.51 77.31,93.51 76.49,92.7 73.38,92.7 72.66,93.42 70.47,93.42 70.06,93.83 70.06,94.42 70.73,95.09 70.73,99.05 70.06,99.72 70.06,101.88 69.03,102.92 66.92,102.92 66.79,103.04 66.79,103.23 66.92,103.36 69.18,103.36 69.34,103.52 69.34,103.84 69.18,104 63.27,104 63.1,103.83 63.1,103.53 63.27,103.36 64.97,103.36 65.1,103.23 65.1,103.04 64.97,102.92 63.14,102.92 62.42,102.2 62.42,100.92 62.08,100.59 62.08,100.07 v1(61.99,99.98)
DDR4_DIMM1_DQ14: length 78.4
  L07_SIG3 w0.089: v1(109.74,80.33) 109.74,80.71 109.33,81.12 109.33,82.93 105.72,86.55 105.72,87 105.33,87.38 104.95,87.38 104.83,87.26 104.83,86.68 104.74,86.59 104.55,86.59 104.46,86.68 104.46,87.06 104.28,87.25 104.28,87.42 104.55,87.69 104.77,87.69 104.86,87.78 104.86,87.94 104.77,88.03 104.62,88.03 104.46,88.19 104.46,88.41 104.36,88.51 104.16,88.51 104.08,88.59 104.08,88.8 101.23,91.64 86.49,91.64 85.83,90.98 74.51,90.98 73.82,91.67 72.96,91.67 72.41,92.21 68.74,92.21 68.65,92.3 68.65,92.46 68.74,92.55 69.02,92.55 69.13,92.66 69.13,92.83 69.04,92.92 68.42,92.92 67.82,93.52 67.53,93.52 67.44,93.6 67.44,93.79 67.54,93.88 67.88,93.88 67.97,93.97 67.97,94.15 67.88,94.24 67.69,94.24 67.56,94.36 67.56,94.98 67.69,95.11 68.63,95.11 68.95,95.43 68.95,98.29 68.04,99.2 67.92,99.2 67.53,99.59 67.53,100.04 67.42,100.15 66.89,100.15 66.8,100.05 66.8,99.72 66.7,99.63 66.56,99.63 66.45,99.52 66.45,98.9 66.55,98.8 67.93,98.8 68.6,98.13 68.6,97.2 68.31,96.91 67.64,96.91 67.56,96.83 67.56,96.64 67.66,96.54 68.32,96.54 68.42,96.44 68.42,96.3 68.31,96.19 67.21,96.19 67.1,96.3 67.1,96.72 67.01,96.8 66.84,96.8 66.76,96.72 66.76,95.94 66.86,95.84 68.29,95.84 68.38,95.75 68.38,95.6 68.24,95.46 67.35,95.46 67.22,95.33 67.22,94.11 v1(67.09,93.98)
DDR4_DIMM1_DQ15: length 77.9
  L07_SIG3 w0.089: v1(67.94,99.98) 67.94,99.79 69.58,98.15 69.58,97.7 69.38,97.5 69.38,97.18 69.58,96.97 69.58,96.63 69.31,96.36 69.31,96.08 69.58,95.81 69.58,95.45 68.87,94.74 68.48,94.74 68.36,94.62 68.36,93.85 68.23,93.73 68.23,93.59 68.54,93.28 68.67,93.28 68.88,93.49 69,93.49 69.32,93.17 69.63,93.17 69.73,93.07 69.73,92.97 69.56,92.79 69.56,92.66 69.64,92.57 69.95,92.57 70.1,92.72 70.44,92.72 70.59,92.57 70.76,92.57 70.9,92.71 71.24,92.71 71.38,92.57 71.72,92.57 71.86,92.71 72.2,92.71 72.34,92.57 72.54,92.57 73.1,92.01 73.98,92.01 74.67,91.32 80.79,91.32 80.88,91.41 80.88,91.59 80.8,91.67 74.8,91.67 74.71,91.76 74.71,91.9 74.83,92.01 77.1,92.01 77.2,92.11 77.2,92.4 77.31,92.5 77.45,92.5 77.55,92.4 77.55,92.11 77.65,92.01 77.79,92.01 77.89,92.11 77.89,92.7 77.99,92.8 78.13,92.8 78.23,92.7 78.23,92.11 78.33,92.01 78.48,92.01 78.58,92.11 78.58,92.7 78.68,92.8 78.82,92.8 78.92,92.7 78.92,92.11 79.02,92.01 79.16,92.01 79.26,92.11 79.26,92.7 79.36,92.8 79.5,92.8 79.61,92.7 79.61,92.11 79.71,92.01 79.85,92.01 79.95,92.11 79.95,92.7 80.05,92.8 80.19,92.8 80.29,92.7 80.29,92.11 80.39,92.01 80.53,92.01 80.63,92.11 80.63,92.26 80.73,92.36 80.88,92.36 80.98,92.26 80.98,92.11 81.08,92.01 81.31,92.01 81.44,91.88 81.44,91.73 81.27,91.55 81.27,91.43 81.37,91.33 81.55,91.33 81.72,91.49 81.88,91.49 82.04,91.33 85.69,91.33 86.34,91.98 101.46,91.98 104.87,88.57 104.87,88.42 104.99,88.31 105.1,88.31 105.2,88.41 105.42,88.41 105.87,87.96 105.87,87.73 105.75,87.61 105.75,87.44 106.06,87.14 106.06,86.77 106.16,86.67 106.43,86.67 106.55,86.55 106.55,86.27 109.69,83.13 109.69,82.21 v1(109.74,82.17)
DDR4_DIMM1_DQ16: length 84.4
  L07_SIG3 w0.089: v1(116.91,80.79) 116.49,81.2 116.49,82.55 117.22,83.27 117.22,85.59 116.17,86.64 116.17,89.27 113.5,91.94 113.5,94.01 113.09,94.42 113.09,95.35 113.35,95.61 113.35,97.66 112.53,98.48 111.08,98.48 110.01,99.55 110.01,101.96 109.81,102.16 109.38,102.16 109.07,101.85 108.35,101.85 107.86,102.34 107.86,102.87 107.56,103.18 106.13,103.18 105.6,103.7 104.29,103.7 103.77,103.18 101.01,103.18 100.45,103.73 97.6,103.73 97.05,103.18 96.69,103.18 96.17,103.7 94.38,103.7 93.76,103.08 91.4,103.08 91.01,102.69 89.31,102.69 88.59,103.41 82.63,103.41 82.17,102.94 79.17,102.94 78.59,102.36 78.59,101.47 78.16,101.04 78.16,100.02 78.59,99.59 78.59,99.14 78.24,98.79 77.5,98.79 76.65,97.94 75.78,97.94 75.71,97.86 75.71,97.61 75.81,97.51 76.49,97.51 76.59,97.41 76.59,97.19 76.48,97.08 75.65,97.08 75.55,96.99 75.55,96.78 75.64,96.69 76.62,96.69 76.71,96.6 76.71,96.41 76.62,96.32 75.82,96.32 75.73,96.24 75.73,96.03 75.82,95.94 76.71,95.94 76.81,95.85 76.81,95.62 76.73,95.54 75.84,95.54 75.75,95.45 75.75,95.24 75.83,95.16 76.63,95.16 76.72,95.07 76.72,94.88 76.63,94.8 76.08,94.8 75.98,94.7 75.98,94.53 76.06,94.45 76.67,94.45 76.87,94.26 76.87,93.86 76.27,93.25 73.6,93.25 72.87,93.98 v1(72.19,93.98)
DDR4_DIMM1_DQ17: length 82.4
  L07_SIG3 w0.089: v1(73.04,99.98) 73.35,99.98 74.23,99.1 74.23,98.29 74.13,98.19 73.32,98.19 73.21,98.08 73.21,97.93 73.32,97.82 74.59,97.82 74.7,97.71 74.7,97.56 74.59,97.45 73.27,97.45 73.16,97.34 73.16,97.19 73.27,97.08 74.61,97.08 74.72,96.97 74.72,96.82 74.61,96.71 73.26,96.71 73.15,96.61 73.15,96.45 73.26,96.34 75.04,96.34 75.15,96.45 75.15,97.89 75.81,98.55 76.61,98.55 77.71,99.65 77.71,102.03 78.99,103.32 82.03,103.32 82.46,103.75 88.73,103.75 89.44,103.04 90.58,103.04 91.66,104.11 106.39,104.11 106.66,103.84 107.66,103.84 107.89,103.61 107.89,103.37 108.23,103.03 108.23,102.57 108.6,102.2 108.87,102.2 109.19,102.52 110.1,102.52 110.42,102.2 110.61,102.2 110.83,101.98 110.83,100.06 111.88,99.02 112.54,99.02 113.69,97.87 113.69,95.42 113.44,95.17 113.44,94.55 114.51,93.48 114.51,92.81 115.2,92.12 115.2,91.96 115.09,91.84 114.93,91.84 114.31,92.46 114.14,92.46 114.03,92.35 114.03,92.18 117.11,89.09 117.11,86.27 117.58,85.8 117.58,83.1 116.91,82.43 v1(116.91,81.71)
DDR4_DIMM1_DQ18: length 84.5
  L07_SIG3 w0.089: v1(78.14,93.98) 77.58,94.54 77.58,94.75 77.48,94.85 77.29,94.85 77.18,94.95 77.18,95.09 77.29,95.19 77.68,95.19 77.79,95.3 77.79,95.44 77.7,95.53 77.29,95.53 77.18,95.63 77.18,95.78 77.29,95.88 77.68,95.88 77.79,95.99 77.79,96.13 77.7,96.22 77.29,96.22 77.18,96.32 77.18,96.46 77.29,96.56 77.48,96.56 77.58,96.66 77.58,96.84 77.46,96.95 77.09,96.95 77,97.04 77,97.21 77.09,97.3 77.39,97.3 77.47,97.37 77.47,97.58 77.39,97.65 77.26,97.65 77.17,97.74 77.17,97.91 77.26,98 77.74,98 77.81,97.92 77.81,97.48 77.93,97.36 78.16,97.36 78.26,97.46 78.26,97.76 78.36,97.86 78.5,97.86 78.6,97.76 78.6,97.46 78.7,97.36 78.85,97.36 78.95,97.46 78.95,97.76 79.05,97.86 79.19,97.86 79.39,97.66 80.27,97.66 80.37,97.76 80.37,98.07 80.23,98.21 78.58,98.21 78.47,98.32 78.47,98.46 78.57,98.56 80.23,98.56 80.33,98.66 80.33,98.8 80.23,98.9 79.28,98.9 79.18,99 79.18,99.14 79.28,99.24 80.28,99.24 80.4,99.36 80.4,99.49 80.3,99.6 79.53,99.6 79.43,99.7 79.43,100.15 79.66,100.38 79.95,100.38 80.04,100.47 80.04,100.63 79.95,100.72 79.53,100.72 79.44,100.81 79.44,100.98 79.53,101.06 80.11,101.06 80.25,100.92 80.4,100.92 80.52,101.05 80.52,101.19 80.22,101.5 80.22,101.83 80.45,102.06 82.3,102.06 82.96,102.72 88.3,102.72 89.04,101.98 91.32,101.98 91.47,101.83 91.47,101.63 91.56,101.54 91.97,101.54 92.06,101.63 92.06,101.83 92.47,102.24 93.53,102.24 94.09,101.68 94.42,101.68 94.73,102 98.73,102 99.53,101.2 100.97,101.2 101.85,102.07 102.94,102.07 103.23,101.79 103.23,101.37 103.32,101.28 103.85,101.28 103.95,101.37 103.95,101.66 104.26,101.97 104.79,101.97 104.93,101.84 104.93,101.45 105.16,101.22 106.56,101.22 106.79,100.99 106.79,100.72 107.28,100.24 107.28,100.06 108.1,99.24 108.88,99.24 109.14,98.98 109.14,98.73 109.42,98.45 109.81,98.45 110.74,97.53 110.74,95.56 110.45,95.26 110.45,94.51 110.86,94.1 110.86,93.09 114.78,89.16 114.78,88.85 114.91,88.73 115.27,88.73 115.4,88.61 115.4,88.46 115.27,88.34 114.96,88.34 114.78,88.16 114.78,86.54 115.87,85.46 115.87,85.07 115.99,84.95 116.35,84.95 116.48,84.82 116.48,84.6 116.35,84.48 115.99,84.48 115.87,84.35 115.87,84.13 115.99,84.01 116.35,84.01 116.48,83.88 116.48,83.66 116.35,83.54 115.99,83.54 115.87,83.41 115.87,83.05 115.73,82.92 115.73,80.7 v1(116.11,80.33)
DDR4_DIMM1_DQ19: length 82.3
  L07_SIG3 w0.089: v1(78.99,99.98) 78.99,100.43 78.69,100.73 78.69,100.99 78.99,101.29 78.99,101.59 79.16,101.76 79.4,101.76 79.59,101.95 79.59,102.07 79.47,102.19 79.47,102.39 79.68,102.59 79.8,102.59 80.05,102.34 80.19,102.34 80.41,102.56 82.29,102.56 82.8,103.06 88.45,103.06 89.17,102.33 91.16,102.33 91.56,102.73 94.36,102.73 94.58,102.95 94.58,103.1 94.7,103.22 94.89,103.22 95.02,103.1 95.02,102.48 95.15,102.35 95.34,102.35 95.47,102.48 95.47,102.95 95.59,103.08 95.78,103.08 95.91,102.95 95.91,102.51 96.04,102.39 97.41,102.39 97.54,102.51 97.54,103.05 97.67,103.18 97.86,103.18 97.99,103.05 97.99,102.52 98.11,102.4 98.3,102.4 98.43,102.52 98.43,103.23 98.56,103.35 98.75,103.35 98.88,103.23 98.88,102.56 99.44,102 99.78,102 99.91,102.13 99.91,103.17 100.03,103.3 100.22,103.3 100.35,103.17 100.35,102.13 100.48,102 101.1,102 101.63,102.53 103.08,102.53 103.48,102.13 103.82,102.13 104.28,102.59 104.28,102.98 104.4,103.1 104.59,103.1 104.72,102.98 104.72,102.57 104.85,102.44 105.04,102.44 105.17,102.57 105.17,103.17 105.29,103.29 105.52,103.29 105.65,103.17 105.65,102.38 105.75,102.27 106.2,102.27 106.3,102.17 106.3,102.03 106.2,101.93 105.85,101.93 105.75,101.83 105.75,101.67 105.85,101.57 106.53,101.57 106.67,101.71 106.67,102.65 106.82,102.8 107.27,102.8 107.47,102.6 107.47,100.67 107.7,100.43 108.18,100.43 108.32,100.57 108.32,101.15 108.51,101.35 109.03,101.35 109.18,101.2 109.18,100.29 109.32,100.15 109.32,99.75 111.19,97.88 111.19,95.25 111.31,95.13 111.51,95.13 111.63,95.25 111.63,97.45 111.76,97.57 111.95,97.57 112.08,97.45 112.08,96.18 112.2,96.06 112.39,96.06 112.52,96.18 112.52,97.45 112.65,97.57 112.84,97.57 112.97,97.45 112.97,95.85 112.53,95.41 112.53,94.57 112.43,94.47 111.97,94.47 111.65,94.15 111.65,92.94 114.06,90.54 114.32,90.54 115.77,89.09 115.77,86.23 116.86,85.13 116.86,83.43 116.11,82.67 v1(116.11,82.17)
DDR4_DIMM1_DQ20: length 83.5
  L07_SIG3 w0.089: v1(70.49,93.98) 71.3,94.78 71.3,99.33 70.92,99.7 70.92,101.69 71.16,102.38 75.67,106.89 76.04,107.09 76.59,107.21 76.8,107.42 76.96,107.81 77.17,108.02 97.39,108.02 97.53,108.15 98.86,108.15 99.03,107.98 99.82,107.98 99.95,107.85 100.62,107.85 100.75,107.98 110.95,107.98 113.75,105.97 116.82,102.9 117.53,101.19 117.53,95.76 119.25,94.04 119.25,92.9 122.23,89.92 122.23,81.66 121.69,81.11 v1(121.69,80.79)
DDR4_DIMM1_DQ21: length 83.4
  L07_SIG3 w0.089: v1(120.89,80.33) 121.29,80.72 121.29,81.86 121.86,82.43 121.86,83.17 121.73,83.29 121.5,83.29 121.37,83.42 121.37,83.61 121.5,83.74 121.73,83.74 121.86,83.87 121.86,84.06 121.73,84.18 121.5,84.18 121.37,84.31 121.37,84.5 121.5,84.63 121.73,84.63 121.86,84.75 121.86,89.66 118.67,92.85 118.67,94.06 117.16,95.56 117.16,100.81 116.29,102.93 115.21,104.01 114.54,104.01 111.34,107.21 110.88,107.21 110.76,107.08 110.76,106.5 110.63,106.37 110.44,106.37 110.31,106.5 110.31,107.08 110.19,107.21 109.89,107.21 109.79,107.31 109.79,107.52 109.69,107.62 109.42,107.62 109.32,107.52 109.32,107.31 109.22,107.21 107.71,107.21 107.44,107.48 106.7,107.48 106.43,107.21 105.18,107.21 104.89,107.5 104.09,107.5 103.8,107.21 102.63,107.21 102.35,107.49 99.83,107.49 99.4,107.06 96,107.06 95.4,107.66 94.88,107.66 94.29,107.06 77.15,107.06 76.72,106.63 76.03,106.63 75.88,106.48 75.88,106.3 76.07,106.12 76.07,105.94 75.93,105.8 75.75,105.8 75.57,105.99 75.39,105.99 75.25,105.85 75.25,105.67 75.44,105.49 75.44,105.31 75.3,105.17 75.12,105.17 74.94,105.36 74.76,105.36 74.63,105.22 74.63,105.04 74.81,104.86 74.81,104.68 74.67,104.55 74.49,104.55 74.31,104.73 74.13,104.73 73.37,103.97 73.37,103.79 73.55,103.6 73.55,103.42 73.42,103.29 73.24,103.29 73.05,103.47 72.87,103.47 71.77,102.37 71.77,101.23 71.34,100.8 v1(71.34,99.98)
DDR4_DIMM1_DQ22: length 84.7
  L07_SIG3 w0.089: v1(76.44,93.97) 76.07,93.6 73.74,93.6 73.45,93.89 73.45,94.63 73.21,94.87 72.66,94.87 71.76,95.77 71.76,100.53 72.64,101.41 72.64,102.3 73.03,102.7 73.44,102.7 77.46,106.72 94.43,106.72 94.67,106.48 95.42,106.48 95.66,106.72 99.67,106.72 99.91,106.48 100.51,106.48 101.09,107.06 102.25,107.06 102.58,106.72 103.88,106.72 104.09,106.94 104.84,106.94 105.06,106.72 106.59,106.72 106.81,106.94 107.39,106.94 107.61,106.72 108.56,106.72 108.96,106.55 109.4,106.12 110.02,105.86 111.54,105.86 112.4,105.51 114.47,103.43 114.76,103.43 115.15,103.05 115.15,102.96 116.31,101.8 116.81,100.59 116.81,95.38 118.27,93.92 118.27,92.6 120.93,89.94 120.93,82.88 120.5,82.44 120.5,81.19 v1(120.09,80.79)
DDR4_DIMM1_DQ23: length 84.4
  L07_SIG3 w0.089: v1(119.3,80.33) 118.77,79.8 117.52,79.8 117.3,80.01 117.3,82.31 117.94,82.95 117.94,86.13 117.55,86.53 117.55,89.17 115.55,91.17 115.55,91.35 115.69,91.49 115.87,91.49 117.93,89.43 118.11,89.43 118.24,89.56 118.24,89.74 115.2,92.78 115.2,94.25 114.04,95.42 114.04,95.81 114.16,95.94 114.47,95.94 114.6,96.07 114.6,96.26 114.47,96.39 114.16,96.39 114.04,96.51 114.04,96.7 114.16,96.83 114.47,96.83 114.6,96.96 114.6,97.15 114.47,97.27 114.16,97.27 114.04,97.4 114.04,97.59 114.16,97.72 114.47,97.72 114.6,97.85 114.6,98.04 114.47,98.16 114.16,98.16 113.87,98.46 113.67,98.46 112.63,99.5 112,99.5 111.76,99.73 111.76,100.37 111.85,100.45 112.48,100.45 112.58,100.56 112.58,101.12 112.48,101.22 111.57,101.22 111.39,101.4 111.39,101.79 111.64,102.04 112.4,102.04 112.48,102.13 112.48,102.38 112.14,102.72 110.47,102.72 110.36,102.83 110.36,102.99 110.47,103.11 111.41,103.11 111.52,103.22 111.52,103.39 111.41,103.5 110.04,103.5 109.74,103.2 108.62,103.2 108.34,103.49 108.34,103.96 108,104.29 106.74,104.29 106.57,104.46 91.49,104.46 90.44,103.41 89.61,103.41 88.93,104.09 82.26,104.09 81.91,103.74 78.77,103.74 76.84,101.81 76.84,101.46 76.47,101.08 76.47,100.92 76.59,100.8 76.72,100.8 77.1,101.18 77.21,101.18 77.34,101.05 77.34,100.91 76.97,100.54 76.97,100.3 v1(77.29,99.98)
DDR4_DIMM1_DQ24: length 56
  L07_SIG3 w0.089: v1(81.54,93.98) 81.16,94.36 81.16,94.64 80.96,94.85 80.96,96.17 80.79,96.34 78.9,96.34 78.82,96.26 78.82,96.09 78.91,96 80.53,96 80.61,95.91 80.61,95.75 80.53,95.66 78.92,95.66 78.83,95.57 78.83,95.41 78.93,95.31 80.52,95.31 80.61,95.22 80.61,95.05 80.53,94.97 79.43,94.97 79.34,94.88 79.34,94.72 79.43,94.63 80.19,94.63 80.3,94.52 80.3,94.35 80.54,94.1 80.87,94.1 81.37,93.6 81.53,93.6 82.56,92.58 85.09,92.58 85.76,93.25 92.87,93.25 93.15,93.52 93.49,93.52 93.77,93.25 96.79,93.25 97.06,93.51 97.34,93.51 97.61,93.25 97.83,93.25 98.16,93.57 98.68,93.57 99.01,93.25 99.8,93.25 100.1,93.54 100.45,93.54 100.75,93.24 101.37,93.24 101.67,93.54 102.04,93.54 102.22,93.72 102.43,93.72 102.61,93.54 103.14,93.54 103.3,93.38 103.3,92.88 102.98,92.55 102.98,92.33 105.34,89.97 105.77,89.97 107.28,88.46 107.28,87.66 107.61,87.33 107.93,87.33 108.16,87.1 108.16,86.53 110.93,83.76 110.93,80.73 v1(111.33,80.33)
DDR4_DIMM1_DQ25: length 56.3
  L07_SIG3 w0.089: v1(112.13,80.79) 111.71,81.21 111.71,84.03 109.84,85.9 109.84,88.16 107.11,90.89 106.08,90.89 104.08,92.89 104.08,94.12 104.21,94.25 104.21,94.4 104.04,94.57 103.92,94.57 103.77,94.41 103.49,94.41 103.07,94.84 101.57,94.84 101.33,94.59 100.94,94.59 100.64,94.89 100.64,95.1 100.51,95.23 99.93,95.23 99.8,95.1 99.8,94.85 99.64,94.69 99.12,94.69 98.97,94.84 98.97,95.1 98.84,95.22 91.5,95.22 91.26,94.99 91.26,94.5 91.17,94.41 87.08,94.41 86.88,94.22 86.88,94.05 87.05,93.88 87.05,93.72 86.96,93.63 86.38,93.63 86.29,93.72 86.29,94.44 86.01,94.72 85.5,94.72 85.35,94.57 85.35,94.08 84.53,93.26 82.89,93.26 82.39,93.76 82.39,94.15 81.97,94.57 81.97,95.12 82.1,95.25 82.47,95.25 82.57,95.35 82.57,95.49 82.47,95.59 81.87,95.59 81.72,95.75 81.72,96.07 81.83,96.19 82,96.19 82.12,96.3 82.12,96.45 82.37,96.7 82.37,96.84 82.27,96.94 82.15,96.94 82.05,97.04 82.05,97.18 82.15,97.28 82.27,97.28 82.39,97.41 82.39,97.55 82.29,97.65 81.84,97.65 81.74,97.75 81.74,97.9 81.83,97.99 82.29,97.99 82.39,98.1 82.39,98.24 82.29,98.34 81.84,98.34 81.74,98.44 81.74,98.58 81.83,98.68 82.29,98.68 82.39,98.78 82.39,98.95 82.29,99.05 82.1,99.05 82,99.15 82,99.29 82.1,99.39 82.63,99.39 82.85,99.61 82.85,99.91 82.78,99.98 v1(82.39,99.98)
DDR4_DIMM1_DQ26: length 55.3
  L07_SIG3 w0.089: v1(111.33,82.17) 111.33,83.84 109.35,85.82 109.35,86.24 109.23,86.36 108.81,86.36 108.54,86.63 108.54,87.23 108.67,87.35 109.28,87.35 109.48,87.56 109.48,87.94 109,88.42 108.85,88.42 108.34,87.9 108.19,87.9 108.09,88 108.09,88.15 108.56,88.61 108.56,88.75 108.46,88.85 108.32,88.85 107.9,88.44 107.76,88.44 107.66,88.54 107.66,88.68 108.08,89.1 108.08,89.34 107.98,89.44 107.81,89.44 107.39,89.03 107.25,89.03 107.15,89.13 107.15,89.27 107.57,89.68 107.57,89.83 107.46,89.93 107.27,89.93 106.88,89.54 106.74,89.54 106.64,89.64 106.64,89.78 107.07,90.21 107.07,90.35 106.94,90.48 106.76,90.48 106.43,90.15 106.23,90.15 105.68,90.7 105.54,90.7 105.4,90.56 105.26,90.56 105.16,90.66 105.16,90.8 105.3,90.94 105.3,91.09 105.2,91.19 105.05,91.19 104.91,91.05 104.77,91.05 104.67,91.15 104.67,91.29 104.81,91.43 104.81,91.57 104.71,91.67 104.57,91.67 104.43,91.53 104.29,91.53 104.19,91.63 104.19,91.77 104.33,91.91 104.33,92.06 104.23,92.16 104.08,92.16 103.94,92.02 103.8,92.02 103.7,92.12 103.7,92.26 103.84,92.4 103.84,92.54 103.69,92.69 103.69,93.85 103.54,94.01 103.36,94.01 102.9,94.47 102.72,94.47 102.57,94.31 102.17,94.31 102.01,94.47 101.71,94.47 101.48,94.24 101.48,93.84 101.3,93.65 100.85,93.65 100.64,93.86 100.64,94.37 100.37,94.64 100.13,94.64 99.8,94.31 99.8,93.88 99.65,93.73 99.14,93.73 98.97,93.91 98.97,94.26 98.83,94.4 98.49,94.4 98.39,94.5 98.39,94.77 98.29,94.87 98.15,94.87 98.05,94.77 98.05,94.45 97.95,94.35 97.8,94.35 97.7,94.45 97.7,94.77 97.6,94.87 97.46,94.87 97.36,94.77 97.36,94.4 97.26,94.3 97.12,94.3 97.02,94.4 97.02,94.77 96.92,94.87 96.68,94.87 96.5,94.69 96.5,93.72 96.39,93.6 96.25,93.6 96.16,93.69 96.16,94.01 96.07,94.1 95.9,94.1 95.82,94.01 95.82,93.68 95.73,93.59 95.54,93.59 95.47,93.65 95.47,94.31 95.61,94.45 95.61,94.72 95.48,94.85 94.83,94.85 94.74,94.75 94.74,94.25 94.62,94.14 94.62,93.83 94.42,93.63 94,93.63 93.87,93.76 93.87,93.97 94,94.09 94,94.24 93.87,94.36 93.87,94.67 93.74,94.8 93.6,94.8 93.5,94.7 93.5,94.46 93.4,94.36 93.26,94.36 93.16,94.46 93.16,94.7 93.06,94.8 92.92,94.8 92.82,94.7 92.82,94.46 92.72,94.36 92.57,94.36 92.47,94.46 92.47,94.7 92.37,94.8 92.23,94.8 92.13,94.7 92.13,93.72 92.02,93.6 91.79,93.6 91.69,93.7 91.69,94.1 91.59,94.2 91.45,94.2 91.35,94.1 91.35,93.7 91.25,93.6 90.69,93.6 90.53,93.75 90.35,93.75 90.2,93.6 89.03,93.6 88.91,93.73 88.73,93.73 88.6,93.6 88.2,93.6 88.07,93.73 87.89,93.73 87.76,93.6 87.62,93.6 87.49,93.73 v1(87.49,93.98)
DDR4_DIMM1_DQ27: length 55
  L07_SIG3 w0.089: v1(112.13,81.71) 112.05,81.79 112.05,84.26 110.24,86.06 110.24,88.25 107.21,91.29 106.3,91.29 104.93,92.66 104.93,94.22 103.94,95.2 103.94,95.48 103.82,95.61 103.18,95.61 102.8,95.23 101.63,95.23 101.28,95.58 93.2,95.58 92.89,95.89 92.59,95.89 92.29,95.58 91.98,95.58 91.7,95.86 91.52,95.86 91.26,95.61 90.79,95.61 90.63,95.46 90.63,95.25 90.8,95.09 90.8,94.96 90.61,94.77 87.33,94.77 87,95.1 84.8,95.1 84.5,94.8 84.5,94.39 84.75,94.13 84.75,93.99 84.37,93.61 83.06,93.61 82.81,93.86 82.81,94.24 82.92,94.35 82.92,97.3 82.74,97.49 82.74,98.88 83.63,99.78 83.63,100.06 84.06,100.49 85.35,100.49 85.48,100.36 85.48,99.97 85.61,99.85 86.04,99.85 86.16,99.97 86.16,100.38 86.27,100.49 87.84,100.49 v1(88.34,99.98)
DDR4_DIMM1_DQ28: length 59.7
  L07_SIG3 w0.089: v1(79.84,93.98) 79.59,94.23 79.35,94.23 79.18,94.07 78.84,94.07 78.43,94.48 78.43,96.38 78.8,96.76 80.26,96.76 80.97,97.46 80.97,99.69 81.08,99.8 81.08,100.28 81.58,100.78 83.37,100.78 83.79,101.2 88.4,101.2 88.76,100.84 89.79,100.84 90.44,100.19 90.44,99.89 90.76,99.58 92.08,99.58 92.37,99.87 92.8,99.87 93.31,99.36 94.43,99.36 94.65,99.57 99.64,99.57 99.84,99.76 100.56,99.76 100.83,100.03 102.19,100.03 102.64,99.58 103.89,99.58 104.18,99.87 104.85,99.87 105.14,99.58 105.65,99.58 106.83,98.4 107.4,98.4 109.19,96.61 109.19,92.91 109.44,92.66 109.76,92.66 113.83,88.59 113.83,86.02 114.8,85.05 114.8,82.48 114.92,82.36 114.92,81.18 v1(115.31,80.79)
DDR4_DIMM1_DQ29: length 57.6
  L07_SIG3 w0.089: v1(115.31,81.71) 115.26,81.76 115.26,82.54 115.15,82.64 115.15,85.28 114.23,86.2 114.23,88.72 110.02,92.94 110.02,94.15 109.7,94.47 109.7,95.53 110.02,95.85 110.02,96.72 108.25,98.49 108.06,98.49 106.73,99.81 106.73,100.01 106.32,100.42 100.64,100.42 100.42,100.19 100,100.19 99.82,100.37 99.18,100.37 98.48,101.07 97.78,101.07 97.68,100.97 97.68,100.48 97.58,100.38 97.44,100.38 97.34,100.48 97.34,100.97 97.24,101.07 97.1,101.07 97,100.97 97,100.48 96.9,100.38 96.76,100.38 96.65,100.48 96.65,100.97 96.55,101.07 96.41,101.07 96.31,100.97 96.31,100.48 96.21,100.38 96.07,100.38 95.97,100.48 95.97,100.97 95.87,101.07 95.73,101.07 95.63,100.97 95.63,100.48 95.53,100.38 95.38,100.38 95.28,100.48 95.28,100.97 95.18,101.07 95.04,101.07 94.94,100.97 94.94,100.48 94.84,100.38 94.7,100.38 94.6,100.48 94.6,100.97 94.5,101.07 94.35,101.07 94.25,100.97 94.25,100.48 94.15,100.38 90.87,100.38 90.03,101.22 89.03,101.22 88.69,101.57 88.28,101.57 87.84,102.01 87.18,102.01 86.89,101.72 86.37,101.72 85.95,102.15 85.52,102.15 85.36,101.99 84.43,101.99 84.29,102.13 83.18,102.13 82.83,101.79 82.83,101.42 82.58,101.17 81.44,101.17 80.69,100.42 v1(80.69,99.98)
DDR4_DIMM1_DQ30: length 57.8
  L07_SIG3 w0.089: v1(85.79,93.98) 84.73,92.92 82.71,92.92 81.97,93.66 81.97,94.09 81.58,94.48 81.58,94.76 81.36,94.97 81.36,99.26 82,99.9 82,100.13 82.28,100.41 83.49,100.41 83.92,100.84 88.02,100.84 88.44,100.42 89.47,100.42 89.67,100.22 89.67,99.78 90.24,99.21 92.12,99.21 92.37,98.96 95.41,98.96 95.66,99.22 99.62,99.22 99.97,98.86 100.9,98.86 101.47,99.44 102.12,99.44 102.37,99.19 104.07,99.19 104.19,99.32 104.72,99.32 105.02,99.01 105.35,99.01 108.29,96.08 108.29,94.59 108.75,94.13 108.75,92.85 109.3,92.3 109.59,92.3 113.45,88.44 113.45,85.92 114.45,84.92 114.45,82.24 v1(114.52,82.17)
DDR4_DIMM1_DQ31: length 59.2
  L07_SIG3 w0.089: v1(114.52,80.33) 114.1,80.74 114.1,84.76 113.1,85.76 113.1,85.96 113,86.07 112.81,86.07 112.71,86.17 112.71,86.31 112.81,86.41 112.95,86.41 113.1,86.56 113.1,87.99 112.56,88.54 112.56,88.77 112.43,88.9 112.2,88.9 112.07,89.03 112.07,89.26 111.95,89.38 111.71,89.38 111.59,89.51 111.59,89.74 111.46,89.87 111.23,89.87 111.1,90 111.1,90.23 110.98,90.35 110.74,90.35 110.62,90.48 110.62,90.71 110.49,90.84 110.26,90.84 110.13,90.97 110.13,91.2 110.01,91.32 109.77,91.32 109.65,91.45 109.65,91.68 109.52,91.81 109.29,91.81 108.36,92.73 108.36,93.42 108.19,93.6 107.8,93.6 107.54,93.33 107.41,93.33 107.3,93.45 107.3,93.63 107.49,93.82 107.49,94.27 107.59,94.37 107.83,94.37 107.93,94.47 107.93,94.61 107.83,94.71 107.44,94.71 107.34,94.81 107.34,94.95 107.44,95.05 107.83,95.05 107.93,95.15 107.93,95.3 107.83,95.4 107.44,95.4 107.34,95.5 107.34,95.64 107.44,95.74 107.73,95.74 107.83,95.84 107.83,95.98 107.73,96.08 107.59,96.08 107.49,96.18 107.49,96.38 105.52,98.36 105.42,98.36 105.32,98.25 105.32,98.05 105.21,97.95 105.02,97.95 104.91,98.06 104.91,98.24 104.97,98.3 104.97,98.43 104.87,98.54 104.69,98.54 104.51,98.36 104.16,98.36 104.06,98.46 104.06,98.73 103.96,98.83 103.82,98.83 103.72,98.73 103.72,98.46 103.62,98.36 103.47,98.36 103.37,98.46 103.37,98.73 103.27,98.83 103.13,98.83 103.03,98.73 103.03,98.46 102.93,98.36 102.79,98.36 102.69,98.46 102.69,98.73 102.59,98.83 102.44,98.83 102.34,98.73 102.34,98.46 102.24,98.36 102.03,98.36 101.73,98.66 101.51,98.66 101.35,98.5 101.35,98.38 101.51,98.22 101.51,98.04 101.38,97.92 101.07,97.92 100.97,98.02 100.97,98.33 100.87,98.43 100.73,98.43 100.63,98.33 100.63,98.02 100.53,97.92 100.36,97.92 100.26,98.02 100.26,98.33 100.16,98.43 99.85,98.43 99.42,98.86 98.09,98.86 98,98.77 98,98.52 98.09,98.43 99.32,98.43 99.7,98.05 99.7,97.64 99.52,97.46 97.95,97.46 97.59,97.82 97.44,97.82 97.37,97.89 97.37,98.12 97.57,98.33 97.57,98.76 97.47,98.86 97.33,98.86 97.23,98.76 97.23,98.53 97.13,98.43 96.98,98.43 96.88,98.53 96.88,98.76 96.78,98.86 96.64,98.86 96.54,98.76 96.54,98.53 96.44,98.43 96.3,98.43 96.2,98.53 96.2,98.76 96.1,98.86 95.95,98.86 95.85,98.76 95.85,98.53 95.75,98.43 95.46,98.43 95.28,98.61 95.11,98.61 94.94,98.43 94.77,98.43 94.59,98.61 94.43,98.61 94.25,98.43 93.8,98.43 93.62,98.61 92.14,98.61 91.89,98.86 88.94,98.86 88.21,99.59 86.77,99.59 86.64,99.72 v1(86.64,99.98)
DDR4_DIMM1_DQ32: length 56.2
  L16_SIG6 w0.081: v1(102.57,81.71) 102.57,83.37 105.92,86.73 105.92,88.28 107.64,89.99 116.93,89.99 117.62,90.68 127.58,90.68 129.19,92.3 130.84,92.3 130.96,92.42 130.96,92.68 131.08,92.8 132.2,92.8 132.32,92.68 132.32,92.45 132.42,92.35 132.57,92.35 132.96,92.74 132.96,93.42 132.86,93.51 132.25,93.51 132.15,93.61 132.15,93.92 132.25,94.02 132.86,94.02 133.34,94.5 133.34,94.85 133.47,94.98 133.7,94.98 133.82,94.87 133.82,93.71 133.93,93.6 134.51,93.6 134.67,93.76 134.67,94.11 134.43,94.35 134.43,94.63 134.67,94.87 134.67,95.53 134.79,95.65 135.43,95.65 135.55,95.77 135.55,96.54 135.67,96.65 135.84,96.65 135.95,96.54 135.95,95.77 136.07,95.65 136.24,95.65 136.36,95.77 136.36,97.15 136.48,97.27 136.65,97.27 136.77,97.15 136.77,95.77 136.89,95.65 137.39,95.65 137.51,95.53 137.51,95.37 137.39,95.25 136.91,95.25 136.79,95.13 136.79,94.96 136.91,94.84 137.13,94.84 137.25,94.72 137.25,94.55 137.13,94.43 136.91,94.43 136.79,94.32 v1(136.79,93.98)
DDR4_DIMM1_DQ33: length 56.6
  L16_SIG6 w0.081: v1(137.64,99.98) 137.64,100.44 138.43,101.23 140.4,101.23 140.63,101.45 140.63,101.89 140.52,101.99 138.26,101.99 136.39,100.13 136.39,99.05 134.72,97.38 134.11,97.38 133.67,96.94 133.09,96.94 130.55,94.4 129.72,94.4 127.01,91.69 117.2,91.69 116.64,91.13 107.25,91.13 105.74,89.61 105.19,89.61 103.59,88.01 103.59,86.31 101.38,84.11 101.38,80.72 v1(101.77,80.33)
DDR4_DIMM1_DQ34: length 56.8
  L16_SIG6 w0.081: v1(142.74,93.98) 141.41,100.14 141.09,100.46 139.24,100.46 138.91,100.13 138.91,99.79 137.94,98.82 137.2,98.82 134.56,96.18 133.33,95.38 132.81,94.86 131.65,94.41 130.73,93.49 130.73,93.34 130.14,92.75 129.12,92.75 127.39,91.02 117.48,91.02 116.89,90.43 107.55,90.43 105.66,88.54 105.36,88.54 104.81,87.98 104.81,86.29 102.17,83.65 102.17,81.19 v1(102.57,80.79)
DDR4_DIMM1_DQ35: length 56.5
  L16_SIG6 w0.081: v1(143.59,99.98) 144.87,101.26 144.87,101.73 144.49,102.11 142.64,102.11 142.32,101.79 142.32,101.19 142.01,100.87 138.75,100.87 138.11,100.23 138.11,99.55 137.74,99.18 137.07,99.18 134.41,96.52 133.24,96.52 130.32,93.6 129.77,93.6 129.35,93.18 129.01,93.18 127.19,91.35 117.34,91.35 116.78,90.79 107.43,90.79 105.69,89.05 105.35,89.05 104.47,88.17 104.47,86.56 101.77,83.87 v1(101.77,82.17)
DDR4_DIMM1_DQ36: length 56.5
  L16_SIG6 w0.081: v1(135.09,93.98) 135.4,93.98 135.58,94.16 135.58,94.4 135.42,94.56 135.19,94.56 135.09,94.66 135.09,95.21 135.19,95.31 136.29,95.31 136.39,95.2 136.39,94.07 135.96,93.64 135.52,93.64 135.25,93.37 134.87,93.37 134.63,93.14 134.25,93.14 133.93,92.82 133.59,92.82 132.7,91.93 132.16,91.93 132.06,91.83 132.06,91.18 131.97,91.08 131.83,91.08 131.73,91.18 131.73,92.35 131.63,92.45 131.49,92.45 131.39,92.35 131.39,91.18 131.29,91.08 131.16,91.08 131.06,91.18 131.06,91.83 130.96,91.93 130.82,91.93 130.72,91.83 130.72,91.18 130.62,91.08 130.49,91.08 130.39,91.18 130.39,91.83 130.29,91.93 130.15,91.93 130.05,91.83 130.05,91.17 129.95,91.07 129.81,91.07 129.72,91.17 129.72,91.83 129.62,91.93 129.33,91.93 129.22,91.82 129.22,91.25 129.12,91.15 128.55,91.15 127.75,90.35 117.76,90.35 117.02,89.61 107.84,89.61 106.54,88.31 106.54,86.76 102.97,83.19 102.97,80 103.59,79.38 104.33,79.38 104.96,80 v1(104.96,80.33)
DDR4_DIMM1_DQ37: length 56.8
  L16_SIG6 w0.081: v1(105.75,80.79) 105.75,80.41 105.36,80.02 105.36,79.15 105.11,78.9 104.75,78.9 104.41,78.56 103.58,78.56 102.7,79.43 102.34,79.43 101.89,79.89 101.58,79.89 101.12,80.35 100.82,80.35 100.59,80.58 100.59,82.17 100.95,82.52 100.95,84.32 103,86.37 103,87.9 105.29,90.19 105.72,90.19 106.99,91.46 116.5,91.46 117.06,92.02 126.86,92.02 130.52,95.69 131.22,95.69 132.83,97.3 133.38,97.3 133.68,97.6 133.68,97.84 133.43,98.1 133.43,98.54 133.76,98.87 134.04,98.87 134.74,98.17 134.98,98.17 135.18,98.37 135.18,98.51 134.92,98.77 134.92,98.9 135.22,99.2 135.36,99.2 135.62,98.95 135.75,98.95 135.94,99.14 v1(135.94,99.98)
DDR4_DIMM1_DQ38: length 56.6
  L16_SIG6 w0.081: v1(141.04,93.98) 141.35,94.29 141.35,98.27 141.22,98.41 141.07,98.41 140.95,98.29 140.95,94.8 140.84,94.68 140.67,94.68 140.55,94.8 140.55,97.36 140.43,97.48 140.24,97.48 140.12,97.36 140.12,95.28 139.81,94.97 139.81,93.43 139.5,93.12 134.54,91.07 132.7,89.23 129.53,89.23 127.66,87.36 125.22,87.36 124.65,86.78 123.34,86.78 122.76,87.36 121.34,87.36 120.79,86.8 120.26,86.8 119.71,87.36 115.19,87.36 114.6,86.76 113.35,86.76 112.76,87.36 111.22,87.36 110.62,86.75 109.54,86.75 v1(104.96,82.17)
DDR4_DIMM1_DQ39: length 56.5
  L16_SIG6 w0.081: v1(141.89,99.98) 142.36,99.51 143.08,99.51 143.18,99.41 143.18,97.6 143.3,97.48 143.46,97.48 143.58,97.6 143.58,99.03 143.7,99.15 143.87,99.15 143.99,99.03 143.99,94.84 143.87,94.72 143.7,94.72 143.58,94.84 143.58,96.06 143.46,96.17 143.3,96.17 143.18,96.06 143.18,93.89 142.9,93.61 141.64,93.61 134.78,90.77 132.85,88.84 129.72,88.84 127.23,86.36 109.92,86.36 105.75,82.19 v1(105.75,81.71)
DDR4_DIMM1_DQ40: length 71.9
  L16_SIG6 w0.081: v1(146.14,93.98) 146.14,96.48 146,96.62 145.8,96.62 145.65,96.47 145.65,95.13 145.51,94.99 145.31,94.99 145.17,95.13 145.17,99.37 145.02,99.52 144.82,99.52 144.68,99.37 144.68,94.51 144.89,94.29 144.89,93.58 144,92.69 144,92.06 143.65,91.71 139.41,91.71 135.46,90.07 133.93,88.54 133.93,85.01 133.61,84.69 131.59,84.69 131.47,84.81 131.47,84.98 131.59,85.1 133.36,85.1 133.48,85.21 133.48,85.38 133.36,85.5 129.37,85.5 129.25,85.38 129.25,85.21 129.37,85.1 130.82,85.1 130.94,84.98 130.94,84.81 130.82,84.69 128.9,84.69 128.37,85.22 110.28,85.22 107.74,82.68 107.74,79.81 v1(108.14,79.41)
DDR4_DIMM1_DQ41: length 71.7
  L16_SIG6 w0.081: v1(146.99,99.98) 146.58,99.56 146.58,99.23 146.44,99.09 145.79,99.09 145.65,98.96 145.65,97.24 145.79,97.11 145.98,97.11 146.11,97.24 146.11,98.32 146.25,98.46 146.44,98.46 146.58,98.32 146.58,97.5 146.7,97.38 146.92,97.38 147.06,97.52 147.06,99.24 147.21,99.38 147.41,99.38 147.55,99.24 147.55,99.06 147.69,98.93 148.15,98.93 148.29,98.79 148.29,98.6 148.15,98.47 147.69,98.47 147.55,98.33 147.55,98.14 147.69,98 148.15,98 148.29,97.87 148.29,97.68 148.15,97.54 147.69,97.54 147.55,97.41 147.55,97.22 147.69,97.08 148.15,97.08 148.29,96.94 148.29,96.75 148.15,96.62 147.69,96.62 147.55,96.48 147.55,96.29 147.69,96.16 148.15,96.16 148.29,96.02 148.29,95.63 148.15,95.5 147.21,95.5 147.06,95.64 147.06,96.72 146.92,96.86 146.72,96.86 146.58,96.72 146.58,93.78 146.29,93.49 145.31,93.49 144.45,92.64 144.45,91.98 143.74,91.27 139.31,91.27 135.73,89.78 134.28,88.33 134.28,84.67 133.89,84.28 128.73,84.28 128.3,84.71 110.34,84.71 108.54,82.91 108.54,79.97 108.64,79.87 v1(108.94,79.87)
DDR4_DIMM1_DQ42: length 71
  L16_SIG6 w0.081: v1(108.94,78.03) 109.64,78.03 110,77.88 110.33,77.55 110.62,77.55 111.11,78.03 111.49,78.03 111.96,78.5 112.33,78.5 112.8,78.97 113.09,78.97 113.46,79.34 113.81,79.34 114.34,79.87 114.69,79.87 115.15,79.41 115.5,79.41 115.96,79.87 116.27,79.87 116.73,80.33 117.03,80.33 117.49,79.87 121.06,79.87 121.52,80.33 121.89,80.33 122.35,79.87 122.79,79.87 123.86,78.8 124.28,78.8 126.19,76.89 128.57,76.89 128.71,77.03 128.71,77.24 128.57,77.38 126.66,77.38 126.52,77.52 126.52,77.72 126.66,77.87 131.79,77.87 131.93,77.72 131.93,77.52 131.79,77.38 129.75,77.38 129.6,77.24 129.6,77.03 129.75,76.89 144.08,76.89 144.46,77.27 145.06,77.27 145.4,77.61 145.4,78.31 145.74,78.65 145.74,79.64 146.04,79.94 146.04,86.38 146.51,86.85 146.83,86.85 147.38,87.4 147.38,88.37 147.91,88.9 148.98,88.9 150.19,90.11 150.9,90.11 152.09,91.31 v1(152.09,93.98)
DDR4_DIMM1_DQ43: length 71
  L16_SIG6 w0.081: v1(152.94,99.98) 153.4,99.52 153.4,93.85 152.45,92.9 152.45,90.91 150.1,88.55 148.06,88.55 147.72,88.2 147.72,87.26 146.97,86.51 146.63,86.51 146.37,86.24 146.37,79.77 146.08,79.48 146.08,78.34 145.87,78.12 145.87,77.57 145.13,76.84 144.81,76.84 144.2,76.23 144.2,76.09 143.8,75.68 134.75,75.68 134.29,76.14 125.92,76.14 123.06,79 122.24,79 121.92,79.32 116.67,79.32 116.26,78.91 115.86,78.91 115.45,78.5 115.18,78.5 114.27,77.6 112.88,77.6 111.47,76.19 111.15,76.19 110.77,75.81 109.98,75.81 109.18,76.61 108.77,76.61 108.29,77.09 108.05,77.09 107.75,77.39 107.75,78.1 v1(108.14,78.49)
DDR4_DIMM1_DQ44: length 73.3
  L16_SIG6 w0.081: v1(112.13,78.03) 112.13,77.78 111.46,77.12 111.13,77.12 110.67,76.66 110.37,76.66 109.91,77.12 109.58,77.12 109.13,77.57 108.82,77.57 108.54,77.85 108.54,78.67 108.24,78.97 108.01,78.97 107.58,79.4 107.14,79.4 106.94,79.61 106.94,82.4 110.19,85.65 127.54,85.65 127.75,85.85 130.51,85.85 130.63,85.97 130.63,86.14 130.51,86.26 128.97,86.26 128.85,86.38 128.85,86.55 128.97,86.67 130.65,86.67 130.77,86.79 130.77,86.95 130.65,87.07 129.64,87.07 129.52,87.19 129.52,87.36 129.64,87.48 130.74,87.48 130.86,87.6 130.86,87.77 130.74,87.89 130.33,87.89 130.21,88.01 130.21,88.17 130.33,88.29 132.77,88.29 132.89,88.17 132.89,88.01 132.77,87.89 131.6,87.89 131.48,87.77 131.48,87.6 131.6,87.48 132.97,87.48 133.09,87.36 133.09,87.19 132.97,87.07 131.62,87.07 131.5,86.95 131.5,86.79 131.62,86.67 132.97,86.67 133.09,86.55 133.09,86.38 132.97,86.26 131.62,86.26 131.5,86.14 131.5,85.97 131.62,85.85 133.17,85.85 133.57,86.26 133.57,88.75 135.14,90.32 141.57,92.98 143.45,92.98 v1(144.44,93.98)
DDR4_DIMM1_DQ45: length 73.9
  L16_SIG6 w0.081: v1(111.33,78.49) 111.72,78.87 111.72,80.09 111.95,80.33 112.29,80.33 112.75,80.79 113.11,80.79 113.57,81.25 113.89,81.25 114.3,81.66 114.71,81.66 115.12,81.25 115.51,81.25 115.97,81.71 116.31,81.71 116.68,82.08 117.16,82.08 117.53,81.71 117.88,81.71 118.25,82.09 118.79,82.09 119.09,81.78 119.53,81.78 119.84,82.09 120.43,82.09 120.77,81.75 121.16,81.75 121.49,82.08 122.52,82.08 125.83,78.76 132.5,78.76 132.86,78.4 143.76,78.4 144.23,78.87 144.71,78.87 145.02,79.18 145.02,79.94 145.37,80.29 145.37,86.67 146.1,87.4 146.1,88.26 148.11,90.27 149.12,90.27 149.62,90.77 149.62,91.09 150.02,91.49 150.83,91.49 151.2,91.85 151.2,93.37 150.84,93.73 150.84,94.37 151.26,94.8 151.9,94.8 152.69,95.58 152.69,99.01 152.32,99.38 151.1,99.38 150.66,99.82 150.66,100.23 149.95,100.94 149.58,100.94 149.11,101.42 149.11,101.78 148.87,102.02 147.65,102.02 147.19,101.57 146.88,101.57 146.31,101 145.78,101 145.29,100.51 v1(145.29,99.98)
DDR4_DIMM1_DQ46: length 76
  L16_SIG6 w0.081: v1(150.39,93.98) 150.39,93.45 150.86,92.99 150.86,92.07 150.66,91.87 149.77,91.87 149.39,91.49 148.16,91.49 147.69,91.02 147.69,90.56 147.11,89.97 146.36,89.97 146.03,89.64 146.03,88.83 145.75,88.55 145.75,87.53 145.03,86.81 145.03,80.43 144.63,80.04 144.41,80.04 143.94,79.57 143.94,79.1 143.59,78.75 133.14,78.75 132.63,79.26 129.44,79.26 129.31,79.38 129.31,79.61 129.43,79.72 131.95,79.72 132.07,79.84 132.07,80.13 131.95,80.25 126.64,80.25 126.52,80.13 126.52,79.88 126.64,79.76 128.55,79.76 128.67,79.64 128.67,79.4 128.53,79.26 125.91,79.26 124.65,80.52 124.65,80.68 124.77,80.8 124.94,80.8 125.66,80.07 125.83,80.07 125.95,80.19 125.95,80.36 123.66,82.65 123.49,82.65 123.38,82.53 123.38,82.36 124.41,81.33 124.41,81.16 124.29,81.04 124.12,81.04 122.5,82.66 111.29,82.66 110.91,82.28 110.91,79.82 v1(111.33,79.41)
DDR4_DIMM1_DQ47: length 76.2
  L16_SIG6 w0.081: v1(112.13,79.87) 113.09,79.87 113.55,80.33 113.89,80.33 114.35,80.79 114.71,80.79 115.17,80.33 115.5,80.33 115.96,80.79 116.27,80.79 116.73,81.25 117.1,81.25 117.56,80.79 117.89,80.79 118.35,81.25 118.7,81.25 119.16,80.79 119.45,80.79 119.91,81.25 120.27,81.25 120.73,80.79 121.04,80.79 121.5,81.25 121.92,81.25 122.38,80.79 122.86,80.79 124.49,79.16 124.83,79.16 125.69,78.3 132.15,78.3 133.21,77.24 143.72,77.24 145.4,78.92 145.4,79.84 145.7,80.14 145.7,86.53 146.38,87.21 146.71,87.21 147.02,87.52 147.02,88.55 148.39,89.92 149.39,89.92 150,90.53 150.64,90.53 151.64,91.53 151.64,94.2 151.87,94.43 152.17,94.43 153.04,95.31 153.04,99.24 152.5,99.78 152.5,103.29 152.28,103.52 151.85,103.52 151.7,103.37 151.7,101.65 151.56,101.51 151,101.51 150.86,101.65 150.86,102.9 150.71,103.04 150.25,103.04 150.01,102.8 150.01,101.44 150.68,100.77 150.96,100.77 151.24,100.48 v1(151.24,99.98)
DDR4_DIMM1_DQ48: length 72.3
  L03_SIG1 w0.081: v4(104.16,78.03) 104.46,77.72 104.46,77.44 104.75,77.16 105.18,77.16 105.53,77.51 105.92,77.51 106.3,77.13 106.78,77.13 107.2,76.71 107.51,76.71 108,77.2 108.36,77.2 108.73,77.57 109.44,77.57 110.36,78.49 110.71,78.49 111.15,78.93 111.48,78.93 111.95,79.4 112.26,79.4 112.72,79.86 113.06,79.86 113.52,80.32 113.87,80.32 114.34,80.79 114.65,80.79 115.11,81.25 115.48,81.25 115.94,81.71 116.28,81.71 117.13,82.56 124.41,82.56 130.14,76.83 131.49,76.83 131.6,76.94 131.6,77.1 131.49,77.21 130.43,77.21 130.31,77.33 130.31,77.49 130.43,77.6 132.29,77.6 132.9,78.21 132.9,79.63 133.33,80.06 142.35,80.06 142.69,80.4 142.69,81.04 143,81.36 143.36,81.36 143.81,81.81 143.81,87.09 144.29,87.56 144.29,88 144.46,88.17 149.59,88.17 149.91,88.48 151.32,88.48 155.11,92.28 155.11,93.6 v4(155.49,93.98)
DDR4_DIMM1_DQ49: length 73.2
  L03_SIG1 w0.081: v4(156.34,99.98) 155.83,99.47 154.44,99.47 150.04,95.07 149.48,95.07 149.28,94.87 149.12,94.87 148.91,95.07 148.73,95.07 148.62,94.96 148.62,94.48 148.5,94.36 148.34,94.36 148.23,94.48 148.23,94.96 148.12,95.07 147.96,95.07 147.85,94.96 147.85,94.48 147.73,94.36 147.57,94.36 147.46,94.48 147.46,94.96 147.35,95.07 146.8,95.07 145.14,94.39 144.89,94.14 144.89,93.83 144.67,93.61 141.67,93.61 140.89,92.82 136.29,92.82 130.95,87.48 129.1,87.48 127.68,86.05 127.52,86.05 127.41,86.17 127.41,86.33 128.3,87.22 128.3,87.38 128.19,87.49 128.03,87.49 126.5,85.97 125.18,85.97 125.07,86.08 125.07,86.39 124.97,86.49 124.78,86.49 124.68,86.39 124.68,86.08 124.57,85.97 124.41,85.97 124.3,86.08 124.3,86.88 124.18,87 124.02,87 123.91,86.88 123.91,86.08 123.8,85.97 123.64,85.97 123.52,86.08 123.52,86.88 123.41,87 123.25,87 123.14,86.88 123.14,86.08 123.02,85.97 111.14,85.97 110.91,85.73 110.91,85.57 111.1,85.37 111.1,85.21 110.99,85.1 110.83,85.1 110.63,85.3 110.47,85.3 110.36,85.18 110.36,85.02 110.55,84.83 110.55,84.67 110.44,84.55 110.28,84.55 110.09,84.75 109.93,84.75 109.4,84.23 107.57,84.23 105.15,83.23 104.55,82.62 104.55,80.26 v4(104.16,79.87)
DDR4_DIMM1_DQ50: length 74.5
  L03_SIG1 w0.081: v4(103.36,79.41) 103.79,79.83 103.79,82.46 104.79,83.46 107.66,84.65 109.1,84.65 110.76,86.31 120.32,86.31 120.64,86.63 120.64,87.01 121,87.37 126.78,87.37 127.34,87.92 130.91,87.92 136.14,93.16 140.75,93.16 141.52,93.94 141.52,94.14 141.71,94.32 141.85,94.38 144.19,94.38 147.09,95.58 149.84,95.58 153.81,99.55 154.03,99.55 154.25,99.77 154.25,100.11 154.9,100.76 159.19,100.76 159.54,100.42 160.73,100.42 160.97,100.18 160.97,95.13 v4(161.44,93.98)
DDR4_DIMM1_DQ51: length 71.9
  L03_SIG1 w0.081: v4(103.36,78.49) 102.95,78.9 102.95,82.61 103.77,83.43 107.61,85.02 108.83,85.02 111.08,87.27 112.76,87.27 113.3,87.81 115.8,87.81 116.34,87.27 119.85,87.27 120.94,88.36 130.83,88.36 136,93.53 137.4,93.53 138.31,94.44 141.12,94.44 141.78,94.71 144.08,94.71 147.21,96.01 149.76,96.01 153.36,99.61 153.36,100.14 153.62,100.4 154.05,100.4 154.82,101.17 159.36,101.17 159.73,100.8 160.82,100.8 161.13,100.49 161.78,100.49 v4(162.29,99.98)
DDR4_DIMM1_DQ52: length 74.3
  L03_SIG1 w0.081: v4(107.35,78.03) 107.35,78.32 107.99,78.96 108.34,78.96 108.75,79.38 109.06,79.38 109.54,79.86 109.87,79.86 110.36,80.34 110.71,80.34 111.19,80.82 111.47,80.82 111.9,81.24 112.26,81.24 112.69,81.67 113.04,81.67 113.45,82.08 113.45,83.07 113.62,83.24 113.79,83.24 113.9,83.12 113.9,82.87 114.02,82.76 114.18,82.76 114.29,82.87 114.29,83.12 114.4,83.24 114.56,83.24 114.67,83.12 114.67,82.87 114.79,82.76 114.95,82.76 115.06,82.87 115.06,83.12 115.17,83.24 124.82,83.24 128.87,79.19 131.47,79.19 131.58,79.3 131.58,79.46 131.47,79.58 129.22,79.58 129.11,79.69 129.11,79.85 129.22,79.96 131.87,79.96 131.99,80.08 131.99,80.24 131.87,80.35 128.88,80.35 128.77,80.45 128.77,80.63 128.88,80.74 131.74,80.74 132.7,81.69 140.88,81.69 141.22,82.02 141.22,82.51 141.93,83.22 141.93,83.94 143.07,85.08 143.07,87.47 142.81,87.73 142.81,88.32 143.09,88.6 143.67,88.6 143.98,88.91 148.89,88.91 149.85,89.87 150.86,89.87 152.13,91.14 152.13,91.49 152.71,92.08 153.25,92.08 153.55,92.38 153.55,93.31 153.79,93.55 v4(153.79,93.98)
DDR4_DIMM1_DQ53: length 74.1
  L03_SIG1 w0.081: v4(106.55,79.41) 106.55,79.8 106.94,80.19 106.94,81.85 107.31,82.22 108.39,82.67 110.02,82.99 110.71,82.99 112.53,84.81 126.73,84.81 127.59,83.95 132.77,83.95 133.48,84.66 133.48,88.41 136.77,91.7 146.76,91.7 148.94,92.13 149.97,93.16 150.47,93.37 150.81,93.71 150.81,94 150.89,94.19 154.06,97.36 156.18,97.36 156.29,97.48 156.29,97.64 156.18,97.75 154.76,97.75 154.64,97.86 154.64,98.02 154.76,98.14 157.94,98.14 159.32,99.51 159.32,100.14 159.07,100.38 155.05,100.38 v4(154.64,99.98)
DDR4_DIMM1_DQ54: length 74.3
  L03_SIG1 w0.081: v4(106.55,78.49) 106.82,78.22 106.82,77.94 107.19,77.57 107.51,77.57 107.97,78.03 108.32,78.03 108.8,78.51 109.13,78.51 109.57,78.95 109.91,78.95 110.39,79.43 110.72,79.43 111.14,79.86 111.46,79.86 111.91,80.31 112.26,80.31 112.74,80.79 113.04,80.79 113.51,81.25 113.88,81.25 114.33,81.7 114.66,81.7 115.85,82.9 124.58,82.9 128.67,78.81 131.27,78.81 131.38,78.69 131.38,78.53 131.27,78.42 129.94,78.42 129.83,78.31 129.83,78.15 129.94,78.03 131.94,78.03 132.47,78.56 132.47,80.88 132.85,81.26 141.67,81.26 142.53,82.12 142.53,84.07 143.46,85 143.46,87.24 143.95,87.73 143.95,88.21 144.31,88.58 149.35,88.58 149.67,88.89 150.49,88.89 152.48,90.88 152.48,91.29 152.89,91.7 153.39,91.7 153.89,92.19 153.89,93.16 154.19,93.45 154.19,94.15 154.61,94.57 155.58,94.57 155.92,94.22 155.92,93.83 156.3,93.45 159.21,93.45 v4(159.74,93.98)
DDR4_DIMM1_DQ55: length 74.4
  L03_SIG1 w0.081: v4(160.59,99.98) 160.59,98 159.23,96.64 159.07,96.64 158.96,96.75 158.96,96.91 159.85,97.81 159.85,97.97 159.74,98.08 159.58,98.08 158.68,97.19 158.52,97.19 158.41,97.3 158.41,97.46 159.75,98.8 159.75,98.96 159.64,99.07 159.48,99.07 157.31,96.9 154.16,96.9 151.72,94.46 151.72,93.86 150.79,92.93 150.79,92.42 149.99,91.62 148.76,91.62 147.35,91.34 136.89,91.34 133.89,88.34 133.89,84.58 132.87,83.57 127.18,83.57 126.28,84.48 112.74,84.48 110.86,82.6 109.83,82.6 108.72,82.14 108.26,81.67 107.96,81.67 107.74,81.45 107.74,80.62 107.35,80.23 v4(107.35,79.87)
DDR4_DIMM1_DQ56: length 70.8
  L12_SIG4 w0.089: v1(164.84,93.98) 164.39,93.53 163.01,93.53 162.71,93.83 162.71,94.91 161.77,95.85 160.59,95.85 159.94,96.49 152.54,96.49 152.3,96.25 141.84,96.25 140.65,95.06 140.65,93.53 139.76,92.64 136.36,92.64 135.6,91.88 134.34,91.88 133.49,91.03 133.49,90.85 133.62,90.72 133.8,90.72 134.43,91.34 134.61,91.34 134.74,91.21 134.74,91.03 132.49,88.77 132.3,88.77 132.17,88.9 132.17,89.09 132.67,89.58 132.67,89.76 132.54,89.89 132.35,89.89 130.18,87.72 130.18,86.92 124.9,81.65 122.25,81.65 121.86,81.26 121.44,81.26 120.96,80.78 120.73,80.78 120.29,80.34 120.02,80.34 119.54,79.87 118.86,79.87 117.49,78.49 116.83,78.49 116.5,78.16 116.5,77.36 116.25,77.12 115.93,77.12 115.48,76.66 115.15,76.66 114.69,76.2 114.03,76.2 113.31,76.92 113.31,77.61 v1(113.72,78.03)
DDR4_DIMM1_DQ57: length 70.1
  L12_SIG4 w0.089: v1(112.92,79.41) 112.53,79.8 112.53,82.37 116.47,86.32 120.03,86.32 121.01,87.3 121.66,87.3 121.97,87.61 121.97,87.84 127.02,92.89 127.02,94.89 130.56,98.43 133.47,98.43 134.7,99.65 134.7,100.52 135.53,101.35 135.53,101.9 135.98,102.35 136.52,102.35 137.11,102.94 142.25,102.94 142.86,102.33 146.03,102.33 146.63,102.94 151.61,102.94 152.25,102.29 157.42,102.29 158.07,102.94 159.09,102.94 159.77,102.26 164.93,102.26 165.69,101.49 v1(165.69,99.98)
DDR4_DIMM1_DQ58: length 71.3
  L12_SIG4 w0.089: v1(112.92,78.49) 112.54,78.1 112.54,76.36 113.17,75.72 115.48,75.72 115.93,76.18 116.26,76.18 116.79,76.71 117.08,76.71 117.52,77.15 117.9,77.15 118.35,77.6 118.96,77.6 119.83,78.46 120.25,78.46 121.19,79.41 121.86,79.41 122.32,79.86 125.06,79.86 135.9,90.7 138.41,91.73 140.26,91.73 141.71,93.19 142.5,93.19 143.14,93.83 143.14,94.1 143.5,94.47 146.03,94.47 146.8,95.24 153.23,95.24 153.55,95.56 155.84,95.56 156.03,95.36 159.17,95.36 160.17,94.95 161.05,94.07 161.05,93.75 162.06,92.74 167.19,92.74 167.9,92.03 168.84,92.03 v1(170.79,93.98)
DDR4_DIMM1_DQ59: length 70.6
  L12_SIG4 w0.089: v1(171.64,99.98) 171.14,100.49 166.5,100.49 166.1,100.09 166.1,99.8 165.75,99.45 162.99,99.45 162.71,99.72 162.71,100.28 162.55,100.44 138.31,100.44 138.07,100.21 138.07,99.78 137.73,99.43 136.98,99.43 135.08,97.53 133.98,97.53 133.46,97.01 131.84,97.01 129.19,94.36 129.19,92.88 124.88,88.57 124.88,88.21 122.02,85.34 117.09,85.34 114.1,82.36 114.1,80.6 113.72,80.21 v1(113.72,79.87)
DDR4_DIMM1_DQ60: length 71
  L12_SIG4 w0.089: v1(163.14,93.98) 163.14,94.97 161.92,96.19 160.98,96.19 160.33,96.84 148.37,96.84 148.19,96.66 142.09,96.66 141.91,96.84 139.09,96.84 138.96,96.71 138.96,96.52 139.09,96.39 140.81,96.39 140.94,96.26 140.94,96.08 140.81,95.95 138.66,95.95 138.53,95.82 138.53,95.63 138.66,95.5 139.72,95.5 139.85,95.37 139.85,95.19 139.72,95.06 138.28,95.06 138.08,95.26 137.4,95.26 137.19,95.05 137.19,94.37 137.51,94.05 137.86,94.05 138.18,94.37 139.61,94.37 139.82,94.16 139.82,93.64 139.6,93.42 137.52,93.42 137.12,93.03 136.79,93.03 136.66,93.16 136.66,93.51 136.53,93.64 136.34,93.64 136.21,93.51 136.21,93.26 135.51,92.55 134.21,92.55 129.5,87.85 129.5,86.87 124.85,82.21 121.55,82.21 121.09,81.75 120.74,81.75 120.31,81.32 119.96,81.32 119.49,80.84 119.19,80.84 117.76,79.41 v1(116.11,79.41)
DDR4_DIMM1_DQ61: length 71.7
  L12_SIG4 w0.089: v1(163.99,99.98) 164.38,100.37 165,100.37 165.21,100.58 165.21,100.95 165.03,101.13 136.15,101.13 135.55,100.53 135.55,98.83 135.09,98.38 134.09,98.38 133.27,97.56 131.67,97.56 129.72,95.61 128.75,95.61 127.85,94.71 127.85,92.59 124.16,88.9 124.16,88.53 123.01,87.38 122.5,87.38 122.03,86.91 122.03,86.52 121.37,85.85 117.08,85.85 113.32,82.09 113.32,78.74 113.55,78.51 113.82,78.51 114.14,78.19 114.14,78.03 114.64,77.53 115.51,77.53 116.11,78.14 v1(116.11,78.49)
DDR4_DIMM1_DQ62: length 71.6
  L12_SIG4 w0.089: v1(169.09,93.98) 169.09,93.58 168.69,93.18 162.37,93.18 161.9,93.66 161.9,94.14 160.53,95.51 160.25,95.51 159.9,95.86 158.51,95.86 158.36,95.71 156.83,95.71 156.56,95.98 152.99,95.98 152.71,95.71 144.55,95.71 144.42,95.58 144.42,95.39 144.55,95.26 145.83,95.26 145.96,95.13 145.96,94.95 145.83,94.82 142.78,94.82 142.65,94.95 142.65,95.13 142.78,95.26 143.63,95.26 143.76,95.39 143.76,95.58 143.63,95.71 142.27,95.71 141.45,94.89 141.45,93.58 140.05,92.18 136.65,92.18 131.57,87.1 131.38,87.1 131.25,87.23 131.25,87.41 131.76,87.91 131.76,88.1 131.63,88.23 131.44,88.23 130.62,87.41 130.62,86.61 125.19,81.18 123.34,81.18 122.94,80.77 122.32,80.77 121.88,80.34 121.49,80.34 120.57,79.42 119.56,79.42 118.66,78.52 118.37,78.52 117.87,78.03 v1(116.91,78.03)
DDR4_DIMM1_DQ63: length 71.2
  L12_SIG4 w0.089: v1(169.94,99.98) 170.59,99.33 171.53,99.33 171.84,99.03 171.84,96.79 170.62,95.57 169.59,95.57 168.64,94.62 168.64,93.82 168.39,93.57 165.45,93.57 165.25,93.76 165.25,94.22 163.82,95.65 162.99,95.65 162.1,96.54 161.16,96.54 160.51,97.18 138.79,97.18 136.66,95.05 136.66,94.63 135.28,93.25 134.15,93.25 128.67,87.77 128.67,86.83 124.49,82.65 120.31,82.65 119.41,81.75 119.21,81.75 118.71,81.25 118.27,81.25 117.81,80.8 117.53,80.8 116.91,80.17 v1(116.91,79.87)
DDR4_DIMM1_DQ64: length 50.6
  L14_SIG5 w0.081: v1(104.96,77.57) 105.37,77.98 105.37,82.29 105,82.66 104.79,82.66 103.48,83.97 103.48,84.16 103.67,84.36 103.87,84.36 105.58,82.64 105.76,82.64 105.89,82.77 105.89,82.95 103.79,85.04 103.79,85.22 103.92,85.35 104.1,85.35 105.77,83.68 105.95,83.68 106.08,83.81 106.08,83.99 105.75,84.31 105.75,84.5 105.98,84.74 105.98,84.93 105.85,85.06 105.66,85.06 105.43,84.83 105.23,84.83 105.1,84.97 105.1,85.16 105.69,85.75 105.69,85.94 105.56,86.08 105.36,86.08 104.77,85.49 104.58,85.49 104.44,85.62 104.44,85.81 104.94,86.31 104.94,86.5 104.8,86.63 104.61,86.63 104.12,86.14 103.93,86.14 103.39,86.68 103.39,86.87 103.7,87.18 103.7,87.37 103.56,87.51 103.37,87.51 103.06,87.19 102.88,87.19 102.75,87.32 102.75,87.95 102.63,88.07 101.96,88.07 101.86,87.97 101.86,87.55 103.56,85.85 103.56,85.66 103.43,85.52 103.24,85.52 101.35,87.4 101,87.4 100.85,87.25 100.67,87.25 100.45,87.46 100.45,87.64 100.7,87.88 100.7,88.27 100.49,88.48 99.48,88.48 99.34,88.34 99.34,88.16 99.21,88.03 98.96,88.03 98.83,88.16 98.83,88.95 98.27,89.5 96.47,89.5 94.37,91.6 93.02,91.6 90.89,93.73 v1(90.89,93.98)
