# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N6995373: length 2.6
  TOP w0.149: U96.C9 v1(198.06,74.6)
  BOTTOM w0.305: R6867.1 199.4,73.21 198.06,74.54 v1(198.06,74.6)
N6996186: length 0.6
  TOP w0.149: U96.F10 v1(195.66,73.8)
N6998281: length 220.3
  TOP w0.254: U96.A9 v1(199.66,74.6)
  L14_SIG5 w0.203: v1(223.53,25.23) 223.27,25.48 223.27,28.54 217.05,34.76 217.05,35.51 215.27,37.29 215.27,40.55 213.12,42.7 212.22,42.7 204.68,50.24 204.68,63.55 201.45,66.78 201.45,73.49 200.58,74.37 199.9,74.37 v1(199.66,74.6)
  BOTTOM w0.254: R6869.1 96.4,47.83 96.4,46.94 96.78,46.56 96.78,44.27 95.92,43.41 95.92,41.21 95.74,41.03 95.74,33.07 98.38,30.43 127.76,30.43 131.91,26.29 131.91,23.34 137.26,17.99 142.5,17.99 146.44,14.05 166.71,14.05 168.74,16.08 217.72,16.08 223.34,21.7 223.34,25.03 v1(223.53,25.23)
N6999941: length 216.6
  TOP w0.254: v1(195.56,76.28) 195.26,76.58 U96.F7
  L14_SIG5 w0.203: v1(195.56,76.28) 195.08,76.28 194.49,75.69 194.49,73.53 195.37,72.65 195.79,72.65 198.71,69.73 198.71,65.86 201.2,63.38 201.2,52.29 201.81,51.68 201.81,42.41 200.72,41.31 200.72,39.08 201,38.8 201,35.53 203.58,32.95 206.59,32.95 206.89,32.64 207.6,32.64 207.91,32.95 212.37,32.95 214.2,31.12 218.36,31.12 220.91,28.57 220.91,25.4 v1(220.73,25.22)
  BOTTOM w0.254: v1(220.73,25.22) 220.91,25.05 220.91,24.67 220.45,24.21 218.96,24.21 216.8,22.05 214.78,22.05 210.59,17.86 167.97,17.86 165.69,15.57 149.49,15.57 147.38,17.68 147.38,20.46 146.67,21.16 137.29,21.16 136.91,21.54 136.91,24.21 135.57,25.56 135.57,27.36 129.58,33.35 108.21,33.35 107.58,33.99 107.58,43.39 106.69,44.27 106.69,46.05 105.87,46.87 105.87,47.58 R6871.1
N7012506: length 0.9
  TOP w0.381: U95.J7 v2(180.22,29.42)
N7118059: length 6.8
  BOTTOM w0.381: D23.2 D22.2 198.45,106.38 J107.4
N7208051: length 2.1
  TOP w0.149: D24.C 34.97,61.67 Q19.3
N7208055: length 3.1
  TOP w0.149: R6888.1 36.77,64.49 D24.A
N7208455: length 2
  TOP w0.149: D25.C 28.62,61.67 Q20.3
N7208459: length 2.2
  TOP w0.149: D25.A 29.34,63.16 29.34,64.15 R6890.1
N7393705: length 2.1
  BOTTOM w0.149: U97.1 32.64,16.13 R6893.1
N7393712: length 2
  BOTTOM w0.149: U97.2 31.98,15.86 R6892.1
N7393719: length 2.1
  BOTTOM w0.149: R6891.1 31.34,16.23 U97.3
N8086837:
  vias: v3(223.4,65.57)
N62271684: length 2.6
  TOP w0.149: U93.C9 v1(53.5,90.31)
  BOTTOM w0.305: R6849.1 54.55,91.26 54.36,91.26 54.11,91.01 54.11,90.86 53.56,90.31 v1(53.5,90.31)

## Copper pours and planes (outline as drawn)
0V6_DDR4_VREF_COMP on L09_PWR1: 122.69,21.16 123.71,21.16 124.95,19.92 124.95,16.69 121.04,12.78 65.92,12.78 63.63,15.06 63.63,18.75 62.75,19.64 62.75,20.4 63,20.65 63.76,20.65 65.77,18.65 65.77,15.73 67.06,14.43 69.98,14.43 71.89,16.33 71.89,20.14 72.91,21.16 73.41,21.16 73.54,21.03 73.54,16.97 75.45,15.06 85.73,15.06 87,16.33 87,18.87 85.99,19.89 85.99,20.91 86.24,21.16 87,21.16 89.03,19.13 89.03,16.33 90.18,15.19 97.54,15.19 99.19,16.84 99.19,18.86 98.18,19.88 98.18,20.91 98.43,21.16 99.19,21.16 100.72,19.64 100.72,16.33 101.73,15.32 109.99,15.32 111.51,16.84 111.51,18.77 110.37,19.91 110.37,20.91 110.62,21.16 111.51,21.16 112.91,19.76 112.91,17.35 114.82,15.45 120.91,15.45 123.71,18.24 123.71,18.75 122.56,19.89 122.56,21.03
0V6_DDR4_VTT_COMP on TOP: 68.33,17.99 66.56,17.99 66.56,18.16 66.76,18.37 66.83,18.37 66.94,18.47 66.94,20.53 66.68,20.78 66.43,20.78 65.92,21.29 65.92,22.43 68.46,22.43 68.46,18.11
0V6_DDR4_VTT_COMP on BOTTOM: outline of 109 points within 67.19,13.54 94.37,30.69 ; 31 cut-outs
0V6_DDR4_VTT_COMP on L07_SIG3: 106.18,51.01 106.18,49.99 107.7,48.47 107.7,32.97 104.78,30.05 96.78,30.05 93.86,27.13 84.51,27.13 84.41,27.03 84.41,26.24 84.79,25.86 84.84,25.86 84.87,25.83 85.12,25.83 85.15,25.86 93.99,25.86 97.29,29.16 105.67,29.16 109.1,32.59 109.1,49.48 107.32,51.26 106.43,51.26
0V6_DDR4_VTT_DIMM on TOP: 191.02,105.11 191.02,103.33 190.84,103.33 190.63,103.53 190.63,103.61 190.23,104.02 189.16,104.02 188.73,103.58 188.35,103.58 188.09,103.33 188.09,102.69 185.81,102.69 185.55,102.95 185.55,104.98 185.81,105.23 190.89,105.23
0V6_DDR4_VTT_DIMM on BOTTOM: 114.84,93.8 114.34,93.8 114.21,93.93 114.21,96.09 113.96,96.34 112.94,96.34 112.69,96.6 112.69,98.53 113.96,99.8 113.96,101.68 114.21,101.93 114.21,103.84 113.96,104.09 112.56,104.09 112.56,105.87 113.83,105.87 114.21,106.25 114.21,107.47 114.51,107.77 114.97,107.77 114.97,93.93
0V6_DDR4_VTT_DIMM on BOTTOM: 190.89,105.23 190.89,104.22 188.22,104.22 188.09,104.09 188.09,102.95 187.84,102.69 185.81,102.69 185.55,102.95 185.55,104.98 185.81,105.23
0V6_DDR4_VTT_DIMM on L14_SIG5: 98.43,73.36 99.93,73.36 100.57,73.99 107.1,73.99 107.63,74.35 108.72,74.81 110.24,74.88 111.13,75.77 111.64,75.77 112.91,77.04 112.91,81.74 115.58,84.41 115.58,92.41 114.05,93.93 114.05,95.46 114.43,95.84 126.88,95.84 132.59,101.55 132.59,105.49 130.06,108.03 118.5,108.03 116.47,106 114.43,106 114.18,106.25 114.18,109.04 115.07,109.93 190,109.93 192.41,107.52 192.41,98.5 186.82,92.92 171.46,92.92 165.36,99.01 162.31,99.01 135.77,72.47 116.22,72.47 109.44,68.38 98.74,68.38 98.05,69.07 98.05,72.98
1V8_SI53254_1 on BOTTOM: 15.88,32.34 16.01,32.46 17.28,32.46 17.41,32.34 17.41,31.07 17.28,30.94 16.01,30.94 15.88,31.07
1V8_SI53254_1 on L07_SIG3: 26.17,32.08 24.52,30.43 24.52,24.59 23.88,23.95 18.93,23.95 17.66,22.68 13.85,22.68 13.47,23.07 13.47,33.73 13.85,34.11 25.79,34.11 26.17,33.73
1V8_SI53254_2 on BOTTOM: 23.63,53.04 23.63,51.77 23.76,51.64 24.77,51.64 24.9,51.77 24.9,53.04 24.77,53.16 23.76,53.16
1V8_SI53254_2 on L07_SIG3: 15.37,47.96 15.37,53.93 17.03,55.58 23.76,55.58 26.8,52.53 26.8,44.27 26.32,43.79 24.72,43.79 24.39,44.12 24.39,45.9 23.4,46.89 16.44,46.89
1V25_REF on BOTTOM: 219.97,66.25 219.97,67.13 219.84,67.26 217.56,67.26 217.3,67.01 217.3,63.58 218.07,63.58 218.07,65.86 218.32,66.12 219.84,66.12
2V5_DDR4_COMP on TOP (solid shape): 143.42,17.63 143.64,17.63 143.64,18.24 143.89,18.24 143.89,17.62 143.89,17.59 143.9,17.54 143.9,16.97 143.77,16.84 142.37,16.84 141.99,16.46 141.99,16.08 141.87,15.95 135.14,15.95 134.88,16.21 134.88,17.6 135.14,17.86 141.23,17.86 141.73,18.36 143.42,18.36
2V5_DDR4_COMP on TOP: 77.1,25.35 76.46,25.35 76.33,25.48 76.33,27 78.24,28.91 81.8,28.91 83.83,26.88 83.83,20.14 81.92,18.24 80.4,18.24 80.27,18.37 80.27,18.75 80.4,18.87 80.78,18.87 82.18,20.27 82.18,27 81.16,28.02 78.62,28.02 77.35,26.75 77.35,25.61
2V5_DDR4_COMP on BOTTOM: 129.67,19.51 134.63,19.51 136.53,17.6 140.98,17.6 141.36,17.22 141.36,14.18 140.98,13.79 91.7,13.79 91.19,14.3 91.19,17.6 93.1,19.51 94.75,19.51 95.13,19.13 95.13,15.95 95.38,15.7 102.75,15.7 103.13,16.08 103.13,17.35 105.29,19.51 107.32,19.51 107.58,19.26 107.58,16.08 107.83,15.83 114.94,15.83 115.2,16.08 115.2,17.48 117.23,19.51 119.51,19.51 119.9,19.13 119.9,16.59 120.15,16.33 125.86,16.33 128.15,18.62 128.79,18.62
2V5_DDR4_COMP on L03_SIG1: 85.86,26.49 86.37,27 87.76,27 88.53,27.76 89.03,27.76 93.23,23.57 93.23,18.37 92.84,17.99 86.24,17.99 85.86,18.37
2V5_DDR4_COMP on L03_SIG1: 98.05,26.49 98.56,27 100.21,27 100.9,27.69 101.3,27.69 105.44,23.55 105.44,18.44 104.99,17.99 98.43,17.99 98.05,18.37
2V5_DDR4_COMP on L05_SIG2: 72.73,27.94 72.73,23.45 73.11,23.07 111.36,23.07 112.25,22.18 112.25,18.16 112.43,17.99 117.48,17.99 117.86,18.37 117.86,19.89 117,20.75 117,24.31 112.91,28.4 73.18,28.4
2V5_DDR4_COMP on L07_SIG3: 139.83,20.4 139.83,17.22 139.58,16.97 135.26,16.97 133.13,14.84 114.79,14.84 113.42,16.21 113.42,23.95 113.04,24.34 98.2,24.34 97.85,24.69 97.85,27.21 98.33,27.69 117.69,27.69 119.13,26.24 119.13,18.62 120.78,16.97 128.79,16.97 129.29,17.48 129.29,18.62 130.69,18.62 132.98,20.91 139.33,20.91
2V5_DDR4_COMP on L12_SIG4: 98.53,27.76 128.02,27.76 128.4,27.38 128.4,24.84 128.02,24.46 98.53,24.46 98.15,24.84 98.15,27.38
2V5_DDR4_DIMM on TOP (solid shape): 189.36,94.31 189.87,93.8 189.87,93.2 189.14,93.2 189.14,92.92 189.87,92.92 189.87,92.79 189.76,92.67 189.13,92.67 189.09,92.67 189.05,92.66 188.35,92.66 186.95,94.06 186.95,96.85 187.21,97.11 189.36,97.11
2V5_DDR4_DIMM on BOTTOM (solid shape): 189.36,96.85 189.36,94.57 189.11,94.31 187.21,94.31 186.95,94.57 186.95,96.85 187.21,97.11 189.11,97.11
2V5_DDR4_DIMM on BOTTOM: 74.56,105.87 74.56,104.73 75.52,104.73 75.78,104.47 75.78,103.56 75.65,103.43 74.81,103.43 74.81,99.7 74.56,99.44 74.56,95.71 74.68,95.58 77.83,95.58 77.96,95.71 77.96,103.96 78.34,104.35 82.68,104.35 82.94,104.6 82.94,105.62 82.68,105.87 ; 1 cut-out
2V5_DDR4_DIMM on L03_SIG1: 80.53,106.76 80.91,107.14 91.45,107.14 93.35,109.04 132.21,109.04 132.47,109.3 136.02,109.3 136.28,109.04 136.28,108.41 135.52,107.65 117.23,107.65 116.09,106.5 97.8,106.5 95.89,104.6 80.91,104.6 80.53,104.98
2V5_DDR4_DIMM on L07_SIG3: 189.87,92.92 141.74,92.92 140.98,92.15 121.29,92.15 120.4,93.04 120.4,93.68 121.8,95.07 121.8,99.14 119.26,101.68 119.26,102.44 124.21,107.39 130.69,107.39 132.09,108.79 138.56,108.79 140.09,107.27 189.75,107.27 190.13,106.89 190.13,93.17
3V3_AGND on TOP (solid shape): 182.47,32.72 182.47,31.19 182.21,30.94 180.79,30.94 180.54,31.19 180.54,32.72 180.74,32.92 182.26,32.92
3V3_QSFP on BOTTOM (solid shape): 36.2,53.93 36.46,53.67 36.46,53.09 36.43,53.09 36.43,51.46 36.46,51.46 36.46,49.02 36.43,49.02 36.43,47.4 36.46,47.4 36.46,44.33 36.43,44.33 36.43,42.7 36.46,42.7 36.46,42.34 36.13,42.01 33.48,42.01 33.48,42.02 32.97,42.02 32.97,42.01 32.87,42.01 32.52,42.37 33.08,42.37 33.08,42.4 33.66,42.4 33.66,42.67 33.36,42.67 33.36,42.4 33.08,42.4 33.08,42.67 32.82,42.67 32.82,42.37 32.52,42.37 32.44,42.46 32.41,42.49 32.38,42.51 32.34,42.53 32.3,42.55 32.26,42.55 32.24,42.55 31.48,42.55 31.48,42.93 32.21,42.93 32.21,43.23 31.48,43.23 31.48,43.59 32.24,43.59 32.26,43.59 32.31,43.6 32.35,43.62 32.39,43.64 32.43,43.68 32.46,43.72 32.48,43.76 32.48,43.78 32.49,43.79 33.72,43.79 33.92,43.99 33.92,45.29 36.08,45.29 36.08,45.67 35.69,45.67 35.69,45.29 33.92,45.29 33.92,45.93 36.08,45.93 36.08,46.31 35.69,46.31 35.69,45.93 33.92,45.93 33.92,53.67 34.17,53.93 35.65,53.93
3V3_QSFPDD on BOTTOM: 44.34,34.64 47.26,34.64 47.26,29.31 47.01,29.06 46.24,29.06 45.98,28.81 45.98,27.92 45.85,27.79 44.58,27.79 44.46,27.66 44.46,24.74 44.58,24.62 45.35,24.62 45.6,24.87 45.6,25.25 45.85,25.5 47.26,25.5 47.26,23.22 43.67,23.22 43.19,23.7 43.19,28.65 43.06,28.78 42.04,28.78 41.54,29.29 40.6,29.29 40.6,29.68 41.34,29.68 41.34,29.98 40.6,29.98 40.6,30.3 41.54,30.3 41.79,30.56 42.81,30.56 43.19,30.94 43.19,33.48 ; 4 cut-outs
3V3_STBY on TOP (solid shape): 66.17,67.77 67.7,67.77 67.83,67.64 67.83,66.88 67.7,66.75 64.65,66.75 64.4,67.01 64.4,67.52 64.52,67.64 64.52,68.52 64.78,68.52 64.78,67.8 65.03,67.8 65.03,68.52 65.42,68.52
3V3_STBY on TOP (solid shape): 144.03,22.68 144.03,21.67 143.92,21.56 143.92,20.66 143.64,20.66 143.64,21.39 143.39,21.39 143.39,20.66 143,20.66 142.25,21.41 137.42,21.41 137.17,21.67 137.17,22.94 137.42,23.19 143.52,23.19
3V3_STBY on TOP (solid shape): 194.44,95.58 194.44,92.79 194.19,92.53 193.17,92.53 193.05,92.66 192.16,92.66 192.16,92.92 192.89,92.92 192.89,93.17 192.16,93.17 192.16,93.55 192.92,94.31 192.92,95.58 193.05,95.71 194.32,95.71
3V3_STBY on TOP (solid shape): 29.33,100.27 29.36,100.27 30.11,100.27 30.11,100.03 29.37,100.03 29.37,99.77 30.11,99.77 30.11,99.01 29.34,98.25 29.34,96.85 29.22,96.73 28.18,96.73 28.07,96.83 28.07,99.65 28.71,100.28 29.28,100.28
3V3_STBY on BOTTOM (solid shape): 67.83,67.52 67.83,67.01 67.57,66.75 66.56,66.75 66.3,67.01 66.3,67.52 66.54,67.76 67.58,67.76
3V3_STBY on BOTTOM (solid shape): 142.12,22.68 142.12,21.92 141.87,21.67 137.65,21.67 137.4,21.92 137.4,22.68 137.65,22.94 141.87,22.94
3V3_STBY on BOTTOM (solid shape): 194.44,95.58 194.44,94.31 194.32,94.19 193.05,94.19 192.92,94.31 192.92,95.58 193.05,95.71 194.32,95.71
3V3_STBY on BOTTOM (solid shape): 12.83,67.13 12.83,65.86 13.59,65.11 13.59,64.72 12.86,64.72 12.86,64.47 13.58,64.47 13.58,64.19 12.69,64.19 12.58,64.09 11.56,64.09 11.31,64.34 11.31,67.13 11.35,67.13 11.51,67.18 11.67,67.26 12.71,67.26
3V3_STBY on BOTTOM (solid shape): 38.87,101.42 38.87,100.98 39.18,100.66 40.77,100.66 41.03,100.41 41.03,96.85 40.9,96.73 39.25,96.73 39,96.98 39,99.43 38.65,99.77 37.6,99.77 36.72,100.66 36.72,101.33 37.47,101.33 37.47,101.55 36.84,101.55 36.84,101.83 37.51,101.83 37.61,101.93 38.36,101.93
3V3_STBY on TOP: 193.56,42.75 193.56,36.2 193.43,36.07 183.38,36.07 183.16,36.16 183.08,36.24 183.08,39.96 182.82,40.21 180.09,40.21 179.9,40.02 179.9,37.47 179.78,37.34 178.76,37.34 178.63,37.21 178.63,36.2 178.51,36.07 169.55,36.07 169.43,36.2 169.43,42.62 169.93,43.13 193.17,43.13
3V3_STBY on TOP: 214.51,46.43 217.05,46.43 217.3,46.18 217.3,44.4 217.05,44.15 214.51,44.15 214.26,44.4 214.26,46.18
3V3_STBY on TOP: 191.78,99.9 191.9,100.03 193.56,100.03 193.68,99.9 195.08,99.9 195.33,99.65 195.33,98.38 195.08,98.12 192.79,98.12 191.78,99.14
3V3_STBY on TOP: 63.38,17.22 63.51,17.1 63.51,15.32 63.38,15.19 63.38,14.43 63.13,14.18 61.22,14.18 61.09,14.3 61.09,16.46 61.86,17.22
3V3_STBY on TOP: 36.71,96.47 41.92,96.47 42.17,96.73 42.17,101.3 41.92,101.55 36.71,101.55 36.46,101.3 36.46,96.73
3V3_STBY on TOP: 15.37,101.93 14.1,101.93 13.85,101.68 13.85,100.79 14.1,100.54 15.37,100.54 15.63,100.79 15.63,101.68
3V3_STBY on TOP: 200.68,36.91 200.68,37.16 201.4,37.16 201.4,37.42 200.67,37.42 200.67,38.44 201.3,39.07 201.3,42.12 201.56,42.37 203.21,42.37 203.46,42.12 203.46,37.29 203.08,36.91
3V3_STBY on BOTTOM: 193.56,41.48 193.56,36.27 193.43,36.15 184.28,36.15 183.28,37.15 183.28,39.83 182.9,40.21 179.97,40.21 179.59,39.83 179.59,39.72 179.6,39.7 179.6,37.67 179.34,37.42 179.33,37.42 178.06,36.15 169.43,36.15 169.43,44.53 169.93,45.04 200.54,45.04 201.94,46.43 217.05,46.43 217.3,46.18 217.3,44.27 215.4,42.37 204.73,42.37 204.22,41.86 204.22,39.32 203.97,39.07 201.68,39.07 201.43,39.32 201.43,41.61 200.79,42.24 194.32,42.24
3V3_STBY on BOTTOM: 58.3,40.21 54.62,40.21 50.55,36.15 48.65,36.15 47.89,35.38 42.27,35.38 41.89,35 41.89,34.75 42.04,34.6 42.3,34.6 42.7,35 48.14,35 48.78,35.64 50.81,35.64 54.74,39.58 58.3,39.58 58.43,39.7 58.43,40.08
3V3_STBY on L05_SIG2: 184.67,43.64 184.67,36.4 184.6,36.46 184.6,34.56 186.57,32.59 193.3,32.59 194.32,33.61 194.32,34.88 195.33,35.89 208.8,35.89 216.03,28.65 216.03,17.22 217.94,15.32 233.43,15.32 234.07,15.95 234.07,20.91 237.75,24.59 237.75,49.23 224.42,62.56 200.79,62.56 199.65,61.41 199.65,55.92 198.48,54.76 194.41,54.76 193.74,54.08 191.19,54.08 189.11,52.01 189.11,47.07 186.32,44.27 185.3,44.27
3V3_STBY on L05_SIG2: 38.23,71.2 40.77,71.2 48.01,78.43 62.48,78.43 63,78.95 63.38,78.95 63.51,78.82 63.51,78.56 62.83,77.89 48.61,77.89 41.28,70.56 37.98,70.56 35.57,72.98 35.57,73.23 35.69,73.36 36.08,73.36
3V3_STBY on L07_SIG3: 252.74,15.06 252.74,109.25 251.92,110.06 230.51,110.06 230.13,109.68 230.13,107.9 231.02,107.01 231.02,104.98 230.26,104.22 218.57,104.22 218.07,103.71 218.07,100.66 216.1,98.69 197.94,98.69 195.21,101.42 193.17,101.42 192.54,100.79 192.54,94.08 197.67,88.95 197.67,84.36 201.37,80.66 201.37,73.1 204.03,70.44 217.81,70.44 218.96,69.29 218.96,66.63 214,61.67 214,39.32 212.86,38.18 204.35,38.18 203.33,39.19 203.33,40.85 202.7,41.48 200.92,41.48 197.24,37.8 195.33,37.8 193.86,39.27 193.86,42.32 193.3,42.88 144.15,42.88 142.12,40.85 142.12,34.11 136.66,28.65 136.66,21.92 136.91,21.67 139.96,21.67 140.85,20.78 140.85,18.11 141.23,17.73 215.91,17.73 217.81,19.64 224.16,19.64 229.88,13.92 251.59,13.92
3V3_STBY on L09_PWR1: 1.28,110.06 239.02,110.06 239.4,109.68 239.4,107.39 238.89,106.89 46.87,106.89 43.44,103.46 43.44,98.25 41.28,96.09 37.98,96.09 36.33,97.74 32.65,97.74 29.47,94.57 23.5,94.57 21.98,93.04 21.98,85.3 22.61,84.66 23.88,84.66 25.03,85.8 27.95,85.8 28.46,85.3 28.46,83.14 26.42,81.1 26.42,80.47 26.3,80.34 26.04,80.34 25.92,80.47 25.92,81.1 25.15,81.87 23.5,81.87 22.74,81.1 22.74,76.91 20.96,75.14 20.96,73.36 22.49,71.83 29.34,71.83 29.73,71.45 29.73,63.2 28.58,62.05 7.37,62.05 7.31,62.12 7.25,62.05 1.79,62.05 1.28,62.56
3V3_STBY on L10_PWR2: 1.28,110.06 239.02,110.06 239.4,109.68 239.4,107.39 238.89,106.89 46.87,106.89 43.44,103.46 43.44,98.25 41.28,96.09 37.98,96.09 36.33,97.74 32.65,97.74 29.47,94.57 23.5,94.57 21.98,93.04 21.98,85.3 22.61,84.66 23.88,84.66 25.03,85.8 27.95,85.8 28.46,85.3 28.46,83.14 26.42,81.1 26.42,80.47 26.3,80.34 26.04,80.34 25.92,80.47 25.92,81.1 25.15,81.87 23.5,81.87 22.74,81.1 22.74,76.91 20.96,75.14 20.96,73.36 22.49,71.83 29.34,71.83 29.73,71.45 29.73,63.2 28.58,62.05 1.79,62.05 1.28,62.56
3V3_STBY on L12_SIG4: outline of 100 points within 1.15,6.3 149.03,109.93
3V3_STBY on L12_SIG4: 210.88,110.06 252.1,110.06 252.74,109.43 252.74,68.15 244.74,60.15 244.74,44.02 240.67,39.96 218.19,39.96 202.06,56.09 202.06,77.42 196.83,82.65 196.83,88.52 194.85,90.5 189.54,90.5 189.11,90.93 189.11,98.68 190.84,100.41 200.03,100.41 204.3,104.68 210.04,104.68 210.78,105.41 210.78,109.96
3V3_STBY on L14_SIG5: 56.78,46.56 54.41,44.2 54.41,43.31 42.3,31.19 33.03,31.19 32.65,31.57 32.65,33.86 32.9,34.11 34.17,34.11 34.68,33.61 41.16,33.61 41.79,34.24 41.79,35.13 42.81,36.15 45.22,36.15 53.09,44.02 53.09,44.66 55.38,46.94 55.38,51.59 55.63,51.84 56.4,51.84 56.78,51.46
3V3_STBY on L16_SIG6: 80.88,31.17 85.48,35.77 90.18,35.77 90.45,36.04 90.45,37.52 90.2,37.77 83.93,37.77 79.17,33.02 75.81,27.65 64.54,21.05 60.21,16.72 60.21,14.68 60.43,14.45 62.13,14.45 67.91,20.23 76.3,24.64
3V3_STBY on L16_SIG6: 67.57,67.01 67.83,67.26 67.83,69.17 66.95,70.04 65.18,70.94 59.84,70.94 57.81,70.06 42.55,70.06 40.14,72.47 40.14,75.9 38.11,77.93 38.11,79.07 37.29,79.89 37.29,83.52 37.17,83.64 35.06,83.64 34.55,84.15 31,84.15 30.61,83.77 30.61,76.79 31,76.41 31.38,76.41 32.39,75.39 32.39,72.98 31.5,72.09 26.17,72.09 25.92,71.83 25.92,70.34 23.1,67.52 22.74,67.52 22.49,67.26 22.49,65.89 23.1,65.28 56.18,65.28 60.78,67.01
3V3_STBY on L16_SIG6: 37.83,92.87 47.76,92.87 48.01,93.12 48.01,94.41 47.76,94.67 37.83,94.67 37.57,94.41 37.57,93.12
3V3_SYS on TOP (solid shape): 66.17,59.9 67.93,59.9 68.05,59.77 68.05,59.01 67.93,58.88 64.65,58.88 64.4,59.13 64.4,59.64 64.52,59.77 64.52,60.64 64.78,60.64 64.78,59.92 65.03,59.92 65.03,60.65 65.42,60.65
3V3_SYS on BOTTOM (solid shape): 28.22,43.6 29.28,43.6 29.28,42.58 28.28,42.58 28.01,42.31 26.52,42.31 26.5,42.34 26.5,44.18 26.62,44.3 27.51,44.3
3V3_SYS on TOP: 37.73,102.31 37.73,103.84 37.22,104.35 37.22,106.38 37.47,106.63 41.92,106.63 42.17,106.38 42.17,102.44 41.92,102.19 37.85,102.19
3V3_SYS on TOP: 68.33,29.42 65.03,32.72 65.03,34.24 63.76,34.24 63.76,32.08 66.99,28.86 67.32,28.86 67.47,28.7 67.47,28.02 67.8,28.02 67.8,28.76 67.95,28.91 68.16,28.91 68.33,29.09
3V3_SYS on BOTTOM: outline of 98 points within 27.06,35.77 72.52,60.78 ; 19 cut-outs
3V3_SYS on BOTTOM: 38.4,29.32 37.4,29.32 37.14,29.06 35.65,29.06 35.62,29.09 35.62,30.88 35.79,31.05 36.73,31.05 37.46,30.32 38.4,30.32
3V3_SYS on L03_SIG1: 28.58,107.9 26.04,107.9 24.39,109.55 2.67,109.55 1.91,108.79 1.91,50.68 7.55,45.04 15.7,45.04 17.99,42.75 25.15,42.75 26.17,41.73 27.69,41.73 28.2,42.24 28.2,47.32 25.23,50.29 7.3,50.29 4.33,53.27 4.33,55.07 7.63,58.37 7.63,68.15 10.29,70.82 10.29,82.37 18.17,90.25 31.88,90.25 33.92,92.28 33.92,96.98 34.78,97.84 36.28,97.84 38.84,100.41 41.92,100.41 42.68,101.17 42.68,108.44 42.02,109.1 29.78,109.1 ; 1 cut-out
3V3_SYS on L03_SIG1: 135.26,9.48 136.68,9.48 137.09,9.88 137.09,11.23 139.68,13.82 226.85,13.82 238.26,25.22 238.26,60.66 244.86,67.26 244.86,77.68 252.36,85.17 252.36,99.77 244.23,107.9 217.05,107.9 216.67,107.52 216.67,105.62 217.05,105.23 235.34,105.23 249.44,91.14 249.44,86.18 241.82,78.56 241.82,69.04 234.2,61.42 234.2,26.49 223.91,16.21 138.44,16.21 134.88,12.65 134.88,9.86
3V3_SYS on L05_SIG2: 198.89,64.09 224.92,64.09 233.31,55.7 236.23,55.7 236.35,55.83 236.35,56.47 236.23,56.59 233.81,56.59 225.43,64.98 198.13,64.98 197.37,64.21 194.32,64.21 192.92,62.82 192.92,62.56 193.17,62.31 197.11,62.31
3V3_SYS on L05_SIG2: 60.84,106.25 59.19,106.25 55.89,102.95 39.12,102.95 38.87,102.69 38.87,101.81 39.12,101.55 56.52,101.55 60,105.03 60.97,105.03 61.07,105.13 61.07,106.02
3V3_SYS on L07_SIG3: 128.53,10.62 129.29,11.38 136.91,11.38 137.29,11 137.29,10.11 136.91,9.73 129.67,9.73 128.28,8.33 67.44,8.33 61.48,14.3 59.32,14.3 58.43,15.19 58.43,17.86 58.81,18.24 63.25,18.24 70.87,10.62
3V3_SYS on L14_SIG5: 43.7,13.92 4.58,13.92 1.28,17.22 1.28,108.92 2.55,110.19 40.77,110.19 42.17,108.79 42.17,96.6 39.76,94.19 35.95,94.19 34.93,93.17 30.11,93.17 29.22,92.28 25.53,92.28 23.88,90.63 22.49,90.63 13.34,81.49 13.34,66.75 14.99,65.1 28.96,65.1 29.47,64.59 29.47,59.39 23.38,53.29 23.38,46.43 24.9,44.91 32.01,44.91 41.28,54.18 41.28,54.94 43.44,57.1 55,57.1 56.27,58.37 57.16,58.37 57.54,57.99 57.54,53.42 56.9,52.78 45.85,52.78 30.36,37.29 18.3,37.29 14.74,40.85 11.69,40.85 11.56,40.72 11.56,34.75 8.14,31.32 8.14,21.8 9.91,20.02 14.61,20.02 17.66,23.07 24.42,23.07 25.79,21.69 43.47,21.69 44.41,22.63 44.86,22.63 46.29,21.21 52.94,21.21 54.79,23.07 58.6,23.07 59.14,23.6 64.07,23.6 65.08,24.62 65.08,29.85 65.92,30.69 67.95,30.69 69.55,29.09 69.55,19.08 64.14,13.67 43.95,13.67
3V3_SYS on L16_SIG6: 33.92,43.26 38.79,38.38 38.79,29.34 38.28,28.83 31.71,28.83 29.34,26.47 29.34,19.89 27.82,18.37 19.18,18.37 16.26,21.29 16.26,30.94 18.3,32.97 18.3,42.88 20.33,44.91 26.8,44.91 28.46,43.26
3V3_USBPHY on TOP (solid shape): 14.87,99.01 13.72,99.01 13.22,98.5 12.2,98.5 12.07,98.63 12.07,100.03 14.87,100.03
3V3_USBPHY on L05_SIG2: 10.04,100.15 15.76,100.15 16.39,99.52 22.49,99.52 22.87,99.14 22.87,95.46 22.23,94.82 22.23,89.36 20.45,87.58 11.18,87.58 7.5,91.26 7.5,97.61
3VBAT on TOP: 223.02,62.56 223.02,64.21 222.26,64.98 217.18,64.98 217.18,62.31 222.77,62.31
5V0 on TOP: 193.3,46.18 193.3,50.73 195.13,52.56 195.13,54.31 193.78,55.65 192.95,55.65 190.38,53.09 190.38,45.93 190.51,45.8 192.92,45.8
5V0 on TOP: 158.52,40.96 158.52,40.73 159.27,40.73 159.27,40.46 158.52,40.46 158.52,40.23 159.6,40.23 160.51,39.32 161.42,39.32 161.68,39.58 163.08,39.58 163.08,40.59 160.66,40.59 160.29,40.96
5V0 on TOP: 158.52,55.44 158.52,55.21 159.27,55.21 159.27,54.94 158.52,54.94 158.52,54.71 159.6,54.71 160.51,53.8 161.42,53.8 161.68,54.05 163.08,54.05 163.08,55.07 160.66,55.07 160.29,55.44
5V0 on TOP: 158.52,26.36 158.52,26.13 159.27,26.13 159.27,25.86 158.52,25.86 158.52,25.62 159.6,25.62 160.51,24.72 161.42,24.72 161.68,24.97 163.08,24.97 163.08,25.99 160.66,25.99 160.29,26.36
5V0 on TOP: 158.52,69.92 158.52,69.69 159.27,69.69 159.27,69.42 158.52,69.42 158.52,69.18 159.6,69.18 160.51,68.28 161.42,68.28 161.68,68.53 163.08,68.53 163.08,69.55 160.66,69.55 160.29,69.92
5V0 on TOP: 158.52,84.39 158.52,84.16 159.27,84.16 159.27,83.9 158.52,83.9 158.52,83.66 159.6,83.66 160.51,82.76 161.42,82.76 161.68,83.01 163.08,83.01 163.08,84.03 160.66,84.03 160.29,84.39
5V0 on BOTTOM: 193.3,50.73 194.83,52.25 194.83,54.82 194.44,55.2 192.49,55.2 190.76,53.47 190.76,46.05 191.02,45.8 192.92,45.8 193.3,46.18
5V0 on L16_SIG6: 187.46,95.33 189.75,93.04 189.75,75.9 192.92,72.72 192.92,64.72 195.59,62.05 198.38,62.05 203.08,57.36 203.08,46.69 201.81,45.42 191.14,45.42 188.98,47.58 188.98,51.51 184.79,55.7 184.79,58.88 180.98,62.69 175.14,62.69 172.85,64.98 170.57,64.98 169.17,63.58 169.17,24.59 168.54,23.95 163.2,23.95 162.69,24.46 160.41,24.46 160.15,24.72 160.15,26.75 162.69,29.29 162.69,38.18 162.06,38.81 160.41,38.81 160.15,39.07 160.15,41.35 162.69,43.89 162.69,46.94 161.04,48.59 161.04,52.66 160.15,53.55 160.15,59.01 160.92,59.77 160.92,62.18 160.15,62.94 160.15,69.04 160.92,69.8 160.92,76.41 160.28,77.04 160.28,83.26 162.06,85.04 162.06,90.5 161.81,90.76 160.41,90.76 160.03,91.14 160.03,108.16 159.27,108.92 71.38,108.92 70.35,107.88 44.44,107.88 42.68,106.12 39,106.12 38.87,106.25 38.87,108.03 39.12,108.28 39.89,108.28 40.14,108.03 40.14,107.27 40.39,107.01 41.79,107.01 44.33,109.55 163.58,109.55 164.85,108.28 164.85,96.57 166.1,95.33
5V0_AGND on TOP: 190.63,56.97 190.63,57.56 190.02,57.56 190.02,56.85 189.75,56.85 189.75,59.59 190.3,60.15 198.23,60.15 198.33,60.05 198.33,59.11 198.1,58.88 192.72,58.88 192.49,58.65 192.49,57.89 192.87,57.51 192.87,57.08 192.77,56.97 ; 1 cut-out
5V0_AGND on BOTTOM: 197.64,56.26 198.89,56.26 199.09,56.47 199.09,59.46 198.84,59.72 196.6,59.72 196.6,59.29 198.58,59.29 198.66,59.21 198.66,57.53 198.56,57.43 197.75,57.43 197.75,57.05 198.08,57.05 198.15,56.97 198.15,56.87 198.05,56.77 197.82,56.77 197.57,56.52 197.57,56.34
12V_AUX on TOP (solid shape): outline of 522 points within 226.96,79.71 244.23,97.36
12V_AUX on BOTTOM (solid shape): outline of 609 points within 227.08,79.71 244.23,98.19
12V_AUX on L03_SIG1: 241.43,79.71 238.77,79.71 237.85,80.63 227.65,80.63 227.46,80.82 227.46,82.25 225.81,83.9 225.81,99.77 226.83,100.79 238.01,100.79 245.5,93.3 245.5,83.77
12V_AUX on L16_SIG6: 244.23,79.71 238.77,79.71 237.85,80.63 226.16,80.63 225.81,80.98 225.81,107.14 226.83,108.16 244.48,108.16 245.5,107.14 245.5,80.98
12V_AUX_IN on BOTTOM (solid shape): outline of 328 points within 218.57,57.1 241.43,80.25
12V_AUX_IN on TOP: 157.36,93.04 163.84,93.04 164.09,92.79 164.09,90.38 163.84,90.12 162.19,90.12 161.81,90.5 159.77,90.5 159.39,90.12 159.39,88.72 158.88,88.22 158.21,88.22 158.12,88.13 158.12,80.43 158.34,80.22 161.42,80.22 162.06,80.85 162.06,82.25 163.96,82.25 164.35,81.87 164.35,76.41 163.96,76.02 159.77,76.02 159.39,75.64 159.39,74.25 158.88,73.74 158.21,73.74 158.12,73.65 158.12,65.96 158.34,65.74 161.42,65.74 162.06,66.37 162.06,67.77 163.96,67.77 164.35,67.39 164.35,61.93 163.96,61.55 159.77,61.55 159.39,61.17 159.39,59.77 158.88,59.26 158.21,59.26 158.12,59.17 158.12,51.48 158.34,51.26 161.42,51.26 162.06,51.89 162.06,53.29 163.96,53.29 164.35,52.91 164.35,47.45 163.96,47.07 159.77,47.07 159.39,46.69 159.39,45.29 158.88,44.78 158.21,44.78 158.12,44.69 158.12,37 158.34,36.78 161.42,36.78 162.06,37.42 162.06,38.81 163.96,38.81 164.35,38.43 164.35,35.64 164.09,35.38 161.04,35.38 160.79,35.13 160.79,34.37 160.54,34.11 157.36,34.11 156.98,34.5 156.98,92.66
12V_AUX_IN on TOP: 198.38,54.31 198.38,51.89 198.13,51.64 198.13,46.05 198.38,45.8 201.3,45.8 201.56,46.05 201.56,54.05 201.05,54.56 198.64,54.56 ; 2 cut-outs
12V_AUX_IN on TOP: 227.92,80.29 237.37,80.29 237.37,80.22 238.77,78.82 238.77,75.39 240.67,73.48 240.67,57.86 240.16,57.36 228.73,57.36 227.21,58.88 227.21,61.04 225.69,62.56 225.69,65.74 224.42,67.01 219.84,67.01 218.96,67.9 218.96,75.52 219.08,75.64 220.73,75.64 221.11,76.02 221.11,79.33 220.86,79.58 220.1,79.58 220.1,80.47 219.97,80.6 218.07,80.6 217.94,80.72 217.94,81.87 217.3,82.5 215.02,82.5 214.51,83.01 214.51,90.63 212.61,92.53 208.03,92.53 207.78,92.79 207.78,96.73 208.03,96.98 219.72,96.98 220.35,96.34 220.35,85.55 222.13,83.77 222.13,75.64 223.78,73.99 225.43,73.99 225.69,74.25 225.69,75.14 225.94,75.39 227.97,75.39 228.23,75.64 228.23,76.15 228.68,76.15 228.68,76.66 228.23,76.66 228.23,77.29 227.92,77.6 ; 5 cut-outs
12V_AUX_IN on BOTTOM: 198.13,50.37 198.13,46.05 198.38,45.8 200.03,45.8 200.29,46.05 200.29,50.37 200.03,50.62 198.38,50.62
12V_AUX_IN on BOTTOM: 157.36,93.04 163.84,93.04 164.09,92.79 164.09,90.38 163.84,90.12 162.57,90.12 162.06,90.63 159.52,90.63 159.14,90.25 159.14,85.3 159.52,84.91 164.22,84.91 164.35,84.79 164.35,75.52 164.09,75.26 161.3,75.26 160.41,76.15 159.52,76.15 159.14,75.77 159.14,70.82 159.52,70.44 164.22,70.44 164.35,70.31 164.35,61.04 164.09,60.78 161.3,60.78 160.41,61.67 159.52,61.67 159.14,61.29 159.14,56.34 159.52,55.96 164.22,55.96 164.35,55.83 164.35,46.56 164.09,46.31 161.3,46.31 160.41,47.2 159.52,47.2 159.14,46.81 159.14,41.86 159.52,41.48 164.22,41.48 164.35,41.35 164.35,35.51 164.09,35.26 161.04,35.26 160.79,35 160.79,34.37 160.54,34.11 156.98,34.11 156.98,92.66 ; 4 cut-outs
12V_AUX_IN on L05_SIG2: 156.6,63.2 156.6,91.57 157.21,92.18 159.8,92.18 161.17,93.55 164.98,93.55 169.55,98.12 175.01,98.12 177.3,100.41 250.45,100.41 252.61,98.25 252.61,14.05 236.61,14.05 236.1,14.56 236.1,18.49 240.04,22.43 240.04,54 236.4,57.64 234.17,57.64 225.56,66.25 219.59,66.25 219.08,66.75 219.08,69.42 218.32,70.18 215.27,70.18 214.26,69.17 182,69.17 179.33,71.83 169.68,71.83 166.25,68.4 166.25,65.36 163.58,62.69 157.11,62.69
12V_AUX_IN on L07_SIG3: 153.55,90.25 153.55,69.42 159.9,63.07 159.9,62.69 161.42,61.17 166.63,61.17 167.27,61.8 167.27,90.63 165.87,92.03 155.33,92.03
12V_AUX_IN on L09_PWR1: 156.98,34.37 156.98,68.53 157.11,68.66 188.86,68.66 192.03,65.48 211.72,65.48 216.8,70.56 216.8,79.33 208.29,87.84 208.29,105.62 208.67,106 239.53,106 240.16,106.63 240.16,109.68 240.55,110.06 252.61,110.06 252.61,14.05 230.64,14.05 229.5,15.19 229.5,43.64 228.48,44.66 220.48,44.66 218.83,43 194.57,43 192.67,41.1 168.66,41.1 167.39,39.83 167.39,35.51 166,34.11 157.23,34.11
12V_AUX_IN on L10_PWR2: 192.03,65.48 211.72,65.48 216.8,70.56 216.8,79.33 208.29,87.84 208.29,105.62 208.67,106 239.53,106 240.16,106.63 240.16,109.68 240.55,110.06 252.61,110.06 252.61,14.05 230.64,14.05 229.5,15.19 229.5,43.64 228.48,44.66 220.48,44.66 218.83,43 194.57,43 192.67,41.1 168.66,41.1 167.39,39.83 167.39,35.51 166,34.11 157.23,34.11 156.98,34.37 156.98,68.4 157.23,68.66 188.86,68.66
12V_AUX_IN on L12_SIG4: 156.6,91.65 156.6,66.5 156.98,66.12 166.12,66.12 167.14,67.13 167.14,89.11 166.38,89.87 161.3,89.87 159.14,92.03 156.98,92.03
12V_PCIE_HSC on TOP: 226.58,44.27 226.45,44.15 219.21,44.15 218.7,44.66 218.7,55.45 219.08,55.83 226.58,55.83 226.96,55.45 226.96,49.35 226.32,48.72 226.32,47.07 226.58,46.81 ; 3 cut-outs
12V_PCIE_HSC on BOTTOM: 226.58,55.83 218.19,55.83 217.84,55.48 217.84,51.62 218.98,51.62 219.08,51.51 219.08,44.4 219.34,44.15 226.32,44.15 226.58,44.4 226.58,45.39 227.03,45.85 227.03,55.37 ; 2 cut-outs
12V_PCIE_HSC on L14_SIG5: 220.56,55.96 226.58,55.96 227.34,55.2 227.34,44.91 226.58,44.15 220.3,44.15 219.79,44.66 219.79,55.2
12V_PCIE_HSC on L16_SIG6: 219.59,55.96 226.58,55.96 227.34,55.2 227.34,44.91 226.58,44.15 220.28,44.15 218.83,45.6 218.83,55.2
12V_PCIE_IN on TOP (solid shape): 47.76,86.06 47.76,82.63 47.63,82.5 39.63,82.5 39.38,82.76 39.38,84.91 39.63,85.17 43.95,85.17 44.97,86.18 47.63,86.18
12V_PCIE_IN on TOP (solid shape): 193.17,88.47 193.17,83.9 193.94,83.14 193.94,80.47 193.81,80.34 190.38,80.34 190.25,80.47 190.25,88.47 190.51,88.72 192.92,88.72
12V_PCIE_IN on TOP (solid shape): 194.83,77.55 194.83,73.87 195.46,73.23 196.1,73.23 196.35,72.98 196.35,72.21 197.37,71.2 197.37,66.75 196.86,66.25 194.32,66.25 193.94,66.63 193.94,73.23 194.16,73.46 194.16,76.05 193.94,76.28 193.86,76.28 190.38,76.28 190.25,76.41 190.25,77.55 190.38,77.68 194.7,77.68
12V_PCIE_IN on TOP (solid shape): 61.73,88.34 61.73,86.06 61.48,85.8 56.52,85.8 55.89,86.44 55.23,86.44 52.1,86.44 52.08,86.44 51.82,86.18 51.82,86.16 51.82,82.63 51.7,82.5 50.55,82.5 50.43,82.63 50.43,86.95 50.55,87.07 54.24,87.07 55.31,88.15 55.4,88.14 55.71,88.26 55.86,88.56 55.86,88.6 61.48,88.6
12V_PCIE_IN on BOTTOM (solid shape): outline of 277 points within 202.32,48.59 218.19,77.8
12V_PCIE_IN on TOP: 157.23,33.73 160.79,33.73 161.3,34.24 161.3,34.88 161.42,35 164.09,35 164.35,34.75 164.35,32.46 164.09,32.21 160.54,32.21 160.28,32.46 159.77,32.46 159.27,31.96 159.27,30.56 158.88,30.18 158.21,30.18 158.12,30.09 158.12,22.39 158.34,22.18 161.42,22.18 162.06,22.81 162.06,23.07 163.96,23.07 164.35,22.68 164.35,16.97 163.96,16.59 157.36,16.59 156.98,16.97 156.98,33.48
12V_PCIE_IN on TOP: 187.84,28.98 187.84,18.75 187.71,18.62 175.27,18.62 175.14,18.75 175.14,28.98 175.27,29.11 178.53,29.11 178.66,28.98 178.66,26.7 178.78,26.57 184.22,26.57 184.35,26.7 184.35,28.98 184.47,29.11 187.71,29.11 ; 2 cut-outs
12V_PCIE_IN on TOP: 217.43,26.49 218.7,26.49 218.96,26.75 218.96,30.05 218.7,30.3 217.43,30.3 217.18,30.05 217.18,26.75 ; 2 cut-outs
12V_PCIE_IN on TOP: 211.21,47.45 217.3,47.45 217.81,47.96 217.81,57.1 217.3,57.61 215.15,57.61 214,56.47 212.48,56.47 210.45,54.43 210.45,48.21
12V_PCIE_IN on TOP: 201.68,20.78 202.7,20.78 202.95,21.03 202.95,22.68 202.7,22.94 201.68,22.94 201.43,22.68 201.43,21.03
12V_PCIE_IN on TOP: 204.6,72.47 204.99,72.09 212.1,72.09 214,70.18 218.19,70.18 218.45,70.44 218.45,77.8 217.94,78.31 213.11,78.31 212.99,78.44 212.99,78.95 212.73,79.2 204.99,79.2 204.6,78.82
12V_PCIE_IN on BOTTOM: 187.84,28.91 187.84,18.9 187.75,18.68 187.69,18.62 175.27,18.62 175.14,18.75 175.14,28.91 175.27,29.03 178.44,29.03 178.57,28.91 178.57,26.62 178.7,26.49 184.28,26.49 184.41,26.62 184.41,28.91 184.54,29.03 187.71,29.03
12V_PCIE_IN on BOTTOM: 203.72,21.16 203.72,22.43 203.08,22.43 202.57,22.94 201.81,22.94 201.56,22.68 201.56,21.29 201.68,21.16
12V_PCIE_IN on BOTTOM: 47.38,85.68 47.38,82.63 47.25,82.5 41.03,82.5 40.77,82.76 40.77,85.17 41.16,85.55 45.09,85.55 45.35,85.8 47.25,85.8 ; 2 cut-outs
12V_PCIE_IN on BOTTOM: 193.43,80.72 190.28,80.72 189.77,81.23 189.77,87.33 190.02,87.58 192.92,87.58 193.3,87.2 193.3,83.52 193.56,83.26 193.56,80.85 ; 2 cut-outs
12V_PCIE_IN on BOTTOM: 161.55,34.75 164.09,34.75 164.35,34.5 164.35,31.96 164.09,31.7 161.3,31.7 160.41,32.59 159.52,32.59 159.14,32.21 159.14,27.26 159.52,26.88 164.22,26.88 164.35,26.75 164.35,16.97 163.71,16.33 157.36,16.33 156.98,16.72 156.98,33.48 157.11,33.61 160.79,33.61 161.3,34.11 161.3,34.5 ; 1 cut-out
12V_PCIE_IN on L03_SIG1: 175.78,89.11 194.7,89.11 194.95,88.85 194.95,80.6 196.35,79.2 216.54,79.2 217.18,78.56 217.18,69.07 215.53,67.41 215.53,57.99 217.18,56.34 217.18,47.45 214.64,44.91 214.64,34.11 218.7,30.05 218.7,21.8 216.42,19.51 216.42,17.6 215.78,16.97 152.66,16.97 151.9,17.73 151.9,44.27 153.17,45.54 158.5,45.54 160.54,43.51 165.36,43.51 166.25,44.4 166.25,48.97 166.89,49.61 182.13,49.61 183.65,51.13 183.65,55.32 182.25,56.72 177.68,56.72 175.14,59.26 175.14,88.47
12V_PCIE_IN on L09_PWR1: 47.38,106.12 207.14,106.12 207.53,105.74 207.53,87.2 215.78,78.95 215.78,70.94 211.08,66.25 192.41,66.25 189.24,69.42 183.52,69.42 183.14,69.8 183.14,89.99 179.71,93.42 68.41,93.42 57.74,82.76 39.63,82.76 39.25,83.14 39.25,94.44 39.89,95.07 41.66,95.07 44.33,97.74 44.33,103.08
12V_PCIE_IN on L10_PWR2: 47.38,106.12 207.14,106.12 207.53,105.74 207.53,87.2 215.78,78.95 215.78,70.94 211.08,66.25 192.41,66.25 189.24,69.42 183.52,69.42 183.14,69.8 183.14,96.47 179.33,100.28 128.15,100.28 126.12,98.25 115.96,98.25 113.93,100.28 60.71,100.28 47.38,86.95 47.38,83.01 47.12,82.76 39.63,82.76 39.25,83.14 39.25,94.44 39.89,95.07 41.66,95.07 44.33,97.74 44.33,103.08
12V_PCIE_IN on L14_SIG5: 60.33,82.78 41,82.78 40.65,83.14 40.65,86.36 41.08,86.79 47.1,86.79 48.65,88.34 51.32,88.34 51.82,88.85 51.82,90.38 52.08,90.63 53.02,90.63 54.41,89.23 60.46,89.23 61.09,88.6 61.09,83.54
12V_PCIE_IN on L16_SIG6: 47.76,106 63.51,106 66.17,103.33 66.17,86.95 65.06,85.83 58.07,85.83 57.54,86.36 57.54,87.61 56.04,89.11 53.35,89.11 52.46,89.99 52.46,94.24 50.98,95.71 47.76,95.71 46.87,96.6 46.87,105.11
GND on TOP (solid shape): 178.44,78.18 186.57,78.18 186.82,77.93 186.82,77.55 186.57,77.29 178.57,77.29 177.93,76.66 177.93,75.39 177.3,74.75 170.57,74.75 170.31,75.01 170.31,79.07 170.57,79.33 177.3,79.33
GND on TOP (solid shape): 50.81,79.2 50.81,72.6 51.57,71.83 52.84,71.83 53.22,71.45 53.22,66.25 52.97,65.99 49.03,65.99 48.78,66.25 48.78,71.58 49.03,71.83 49.41,71.83 49.92,72.34 49.92,79.2 50.17,79.45 50.55,79.45
GND on TOP (solid shape): 56.14,85.17 61.48,85.17 61.73,84.91 61.73,81.99 61.48,81.74 57.29,81.74 55.89,81.74 55.13,82.5 52.2,82.5 52.08,82.63 52.08,86.06 52.2,86.18 55.13,86.18
GND on TOP (solid shape): 193.89,75.9 193.89,73.69 193.3,73.1 193.3,72.43 193.22,72.21 193.3,72 193.3,66.63 192.92,66.25 190.63,66.25 190.25,66.63 190.25,75.9 190.38,76.02 193.76,76.02
GND on TOP (solid shape): 225.81,96.6 225.81,84.79 226.45,84.79 226.45,84.28 225.81,84.28 225.81,83.48 225.59,83.26 225.18,83.26 224.22,84.22 224.2,84.25 224.17,84.27 223.44,85.01 221.91,85.01 221.11,85.8 221.11,96.47 221.62,96.98 225.43,96.98
GND on TOP (solid shape): 63.38,64.34 63.23,64.19 63.23,62.6 66.33,62.6 66.68,62.94 69.22,62.94 69.22,60.53 69.1,60.4 66.3,60.4 65.7,61 61.48,61 61.48,61.27 62.24,61.27 62.24,61.67 61.86,61.67 61.86,61.27 61.48,61.27 61.48,62.69 62.87,62.69 62.87,63.07 62.62,63.07 62.62,62.69 61.48,62.69 61.48,63.45 62.87,63.45 62.87,63.83 62.62,63.83 62.62,63.45 61.48,63.45 61.48,63.71 61.49,63.73 61.53,63.78 61.55,63.83 61.57,63.88 61.58,63.93 61.58,63.99 61.57,64.04 61.55,64.09 61.53,64.14 61.49,64.19 61.48,64.21 61.48,64.52 63.2,64.52 63.2,64.95 62.75,64.95 62.75,64.52 61.48,64.52 61.48,64.72 61.98,65.23 63.38,65.23
GND on TOP (solid shape): 46.64,87.06 46.7,87.05 46.76,87.06 46.83,87.07 47.37,87.07 47.44,87.06 47.5,87.05 47.56,87.06 47.63,87.07 48.17,87.07 48.24,87.06 48.3,87.05 48.36,87.06 48.43,87.07 48.97,87.07 49.04,87.06 49.1,87.05 49.16,87.06 49.23,87.07 49.77,87.07 49.84,87.06 49.9,87.05 49.97,87.06 50.03,87.07 50.05,87.07 50.17,86.95 50.17,82.63 50.05,82.5 48.14,82.5 48.01,82.63 48.01,86.16 48.01,86.18 47.76,86.44 47.74,86.44 44.86,86.44 44.58,86.44 43.95,85.8 39.38,85.8 39.38,87.07 46.57,87.07
GND on TOP (solid shape): 194.83,81.53 194.81,81.47 194.81,81.4 194.81,81.34 194.83,81.27 194.83,80.73 194.81,80.67 194.81,80.6 194.81,80.54 194.83,80.47 194.83,79.93 194.81,79.87 194.81,79.8 194.81,79.74 194.83,79.67 194.83,79.13 194.81,79.07 194.81,79 194.81,78.94 194.83,78.87 194.83,78.33 194.81,78.27 194.81,78.2 194.81,78.14 194.83,78.06 194.7,77.93 190.38,77.93 190.25,78.06 190.25,79.96 190.38,80.09 193.91,80.09 193.94,80.09 194.19,80.34 194.19,83.24 194.19,83.39 193.56,84.03 193.56,88.72 194.83,88.72
GND on TOP (solid shape): 63.38,72.21 63.23,72.06 63.23,70.48 66.33,70.48 66.68,70.82 67.7,70.82 67.7,68.28 66.3,68.28 65.7,68.87 61.48,68.87 61.48,69.14 62.24,69.14 62.24,69.55 61.86,69.55 61.86,69.14 61.48,69.14 61.48,70.56 62.87,70.56 62.87,70.94 62.62,70.94 62.62,70.56 61.48,70.56 61.48,71.33 62.87,71.33 62.87,71.71 62.62,71.71 62.62,71.33 61.48,71.33 61.48,72.39 63.2,72.39 63.2,72.82 62.75,72.82 62.75,72.39 61.48,72.39 61.48,72.6 61.6,72.73 61.62,72.71 61.67,72.67 61.72,72.65 61.77,72.63 61.83,72.62 61.88,72.62 61.94,72.63 61.99,72.65 62.04,72.67 62.09,72.71 62.13,72.75 62.16,72.79 62.19,72.84 62.2,72.89 62.21,72.95 62.21,73.04 62.23,73.07 62.24,73.08 62.26,73.1 62.3,73.1 63.38,73.1
GND on TOP (solid shape): 192.41,96.85 192.41,94.44 191.78,93.8 191.78,89.74 188.22,89.74 188.16,89.81 188.16,89.83 188.16,89.86 188.17,89.88 188.21,89.93 188.25,89.97 188.27,89.99 191.55,89.99 191.55,90.38 191.14,90.38 191.14,89.99 188.27,89.99 188.28,90.01 188.3,90.06 188.31,90.11 188.32,90.16 188.32,90.21 188.31,90.27 188.3,90.32 188.27,90.37 188.24,90.42 188.2,90.46 188.15,90.49 188.1,90.51 188.05,90.53 187.99,90.54 187.94,90.54 187.89,90.53 187.84,90.52 187.8,90.5 187.75,90.47 187.7,90.43 187.68,90.43 187.65,90.43 187.63,90.45 187.61,90.46 187.59,90.48 187.59,90.76 190.13,90.76 190.13,91.01 189.75,91.01 189.75,90.76 189.36,90.76 189.36,91.01 188.98,91.01 188.98,90.76 187.59,90.76 187.59,90.88 188.3,90.88 188.3,91.34 187.87,91.34 187.87,90.88 187.59,90.88 187.59,91.65 188.35,91.65 188.63,91.37 190.25,91.37 190.25,93.93 189.87,94.31 189.87,97.11 192.16,97.11
GND on TOP (solid shape): outline of 85 points within 137.17,16.08 146.95,20.91
GND on TOP (solid shape): outline of 124 points within 29.85,95.58 34.58,103.43
GND on TOP (solid shape): outline of 239 points within 46.49,18.62 59.7,34.5
GND on TOP (solid shape): outline of 458 points within 62.24,74.37 69.86,85.17
GND on TOP (solid shape): outline of 744 points within 85.86,30.18 96.12,40.08
GND on BOTTOM (solid shape): 67.95,68.96 67.84,68.85 64.76,68.85 64.71,68.9 64.71,70.71 64.82,70.82 67.95,70.82
GND on BOTTOM (solid shape): 146.44,20.14 146.44,18.24 146.18,17.99 143.64,17.99 142.88,18.75 142.66,18.75 137.58,18.75 137.17,19.16 137.17,20.02 137.55,20.4 146.18,20.4
GND on BOTTOM (solid shape): 192.67,96.85 192.67,94.21 192.67,90.25 192.41,89.99 189.75,89.99 189.49,90.25 189.49,93.68 189.87,94.06 189.87,96.85 190.13,97.11 192.41,97.11
GND on BOTTOM (solid shape): 63.57,71.01 63.57,70.94 63.57,68.66 63.57,68.63 63.55,68.56 63.48,68.53 62.36,68.53 62.11,68.79 62.11,70.91 62.32,71.12 62.35,71.16 62.38,71.2 63.38,71.2
GND on BOTTOM (solid shape): 65.54,63.32 65.92,62.94 67.44,62.94 67.7,62.69 67.7,61.04 67.95,61.04 67.95,60.66 67.32,60.66 66.81,60.15 62.24,60.15 62.07,60.32 62.07,62.68 62.71,63.32
GND on BOTTOM (solid shape): 31.88,102.44 32.01,102.31 32.01,101.93 32.01,99.9 31.76,99.65 31.12,99.65 31,99.52 31,97.23 31.25,96.98 32.01,96.98 32.01,94.31 29.93,94.31 29.6,94.64 29.6,102.19 29.85,102.44
GND on BOTTOM (solid shape): 42.96,51 42.96,49.86 42.91,49.81 42.87,49.81 42.82,49.79 42.77,49.77 42.72,49.74 42.68,49.7 42.65,49.66 42.63,49.61 36.96,49.61 36.96,50.62 39.89,50.62 39.89,51.01 39.5,51.01 39.5,50.62 39.25,50.62 39.25,51.01 38.87,51.01 38.87,50.62 36.96,50.62 36.96,51.01 37.12,51.16 38.44,51.16 38.53,51.25 42.71,51.25
GND on BOTTOM (solid shape): 59.44,24.62 59.44,20.42 59.19,20.17 51.01,20.17 50.67,20.51 50.67,21.54 52.59,21.54 52.59,22.18 52.08,22.18 52.08,21.54 50.67,21.54 50.67,22.2 50.77,22.3 54.87,22.3 54.87,22.94 54.36,22.94 54.36,22.3 50.77,22.3 51.3,22.84 53.25,22.84 53.6,23.19 53.6,23.6 54.71,23.6 55,23.89 55,24.59 57.92,24.59 57.92,24.97 57.67,24.97 57.67,24.59 57.41,24.59 57.41,24.97 57.16,24.97 57.16,24.59 56.27,24.59 56.27,24.97 56.01,24.97 56.01,24.59 55.76,24.59 55.76,24.97 55.51,24.97 55.51,24.59 55,24.59 55,24.87 55.38,25.25 58.81,25.25
GND on BOTTOM (solid shape): 20.56,92.15 20.43,92.03 19.84,92.03 19.72,91.9 19.72,91.6 19.84,91.47 20.45,91.47 20.45,91.14 19.87,91.14 19.79,91.06 19.79,90.76 20,90.55 20,89.11 19.69,89.11 19.69,89.74 19.57,89.87 15.15,89.87 15.02,89.74 15.02,89.11 14.7,89.11 14.7,89.74 14.57,89.87 14.18,89.87 13.93,90.12 13.93,90.99 13.8,91.11 13.29,91.11 13.29,91.47 14.36,91.47 14.49,91.6 14.49,92.92 15.12,92.92 15.12,93.3 14.74,93.3 14.74,92.92 14.49,92.92 14.49,93.55 15.12,93.55 15.12,93.93 14.74,93.93 14.74,93.55 14.49,93.55 14.49,94.82 15.12,94.82 15.12,95.2 14.74,95.2 14.74,94.82 14.49,94.82 14.49,95.58 19.08,95.58 19.21,95.71 19.21,96.22 19.57,96.22 19.57,95.71 19.69,95.58 20.07,95.58 20.2,95.71 20.2,96.85 20.56,96.85
GND on BOTTOM (solid shape): 33.51,46.41 33.51,45.16 33.43,45.08 31.26,45.08 31.09,44.9 31.09,41.73 31.34,41.48 33.54,41.48 33.73,41.28 33.73,40.16 33.13,39.55 33.03,39.45 26.62,39.45 26.37,39.7 26.37,40.85 33.15,40.85 33.15,41.23 32.65,41.23 32.65,40.85 26.37,40.85 26.37,41.09 28.11,41.09 28.11,41.45 27.78,41.45 27.78,41.09 27.53,41.09 27.53,41.45 26.77,41.45 26.77,41.09 26.37,41.09 26.37,41.55 26.49,41.68 28.09,41.68 28.14,41.73 29.41,41.73 29.41,41.98 28.88,41.98 28.88,41.73 28.14,41.73 28.68,42.27 29.57,42.27 29.66,42.36 29.66,44.89 29.48,45.07 29.26,45.07 29.09,45.23 29.09,45.36 33.14,45.36 33.14,45.71 32.74,45.71 32.74,45.36 29.73,45.36 29.73,45.61 29.34,45.61 29.34,45.36 29.09,45.36 29.09,45.87 29.73,45.87 29.73,46.12 29.34,46.12 29.34,45.87 29.09,45.87 29.09,46.25 28.96,46.37 27.44,46.37 27.31,46.25 27.31,45.07 26.65,45.07 26.65,46.46 26.95,46.76 33.17,46.76
GND on BOTTOM (solid shape): 44,47.42 44,46.96 43.99,46.92 43.98,46.9 43.96,46.88 43.94,46.87 43.91,46.87 43.85,46.89 43.81,46.9 43.76,46.91 43.71,46.91 43.65,46.9 43.6,46.88 43.55,46.85 43.5,46.82 43.46,46.78 43.43,46.74 43.41,46.69 43.39,46.63 43.38,46.58 43.38,46.52 43.39,46.47 43.4,46.42 43.43,46.37 43.46,46.33 43.49,46.29 43.54,46.25 43.58,46.23 43.63,46.21 43.7,46.2 43.7,45.42 42.56,44.28 38.99,44.28 38.63,44.64 42.17,44.64 42.17,45.02 41.79,45.02 41.79,44.64 38.63,44.64 38.34,44.93 37.05,44.93 36.84,45.14 36.84,45.29 37.6,45.29 37.6,45.67 37.22,45.67 37.22,45.29 36.84,45.29 36.84,45.57 36.84,45.57 36.84,45.93 37.6,45.93 37.6,46.18 42.93,46.18 42.93,46.56 42.55,46.56 42.55,46.18 42.3,46.18 42.3,46.56 41.92,46.56 41.92,46.18 37.6,46.18 37.6,46.31 37.22,46.31 37.22,45.93 36.84,45.93 36.84,46.08 36.84,46.66 37,46.83 42.69,46.83 43.29,47.43 43.95,47.43
GND on BOTTOM (solid shape): outline of 100 points within 55.63,28.93 59.82,31.96
GND on BOTTOM (solid shape): outline of 93 points within 32.39,95.33 38.49,104.73
GND on BOTTOM (solid shape): outline of 118 points within 49.79,27.92 53.09,31.98
GND on BOTTOM (solid shape): outline of 143 points within 13.34,61.29 18.17,71.2
GND on BOTTOM (solid shape): outline of 331 points within 218.83,74.75 225.81,98.21
GND on BOTTOM (solid shape): outline of 456 points within 38.87,66.25 61.22,87.96
GND on BOTTOM (solid shape): outline of 550 points within 170.06,65.61 195.66,90.12
GND on TOP: 59.82,65.99 60.84,65.99 61.09,66.25 61.09,73.23 60.84,73.48 59.82,73.48 59.57,73.23 59.57,66.25
GND on TOP: 39.63,66.75 41.28,66.75 41.54,67.01 41.54,74.25 41.28,74.5 39.63,74.5 39.38,74.25 39.38,67.01
GND on TOP: 34.17,104.47 35.82,104.47 36.08,104.73 36.08,106.12 35.82,106.38 34.17,106.38 33.92,106.12 33.92,104.73
GND on TOP: 170.57,87.58 177.81,87.58 178.06,87.84 178.06,89.36 177.81,89.61 170.57,89.61 170.31,89.36 170.31,87.84
GND on TOP: 148.22,33.73 156.22,33.73 156.47,33.48 156.47,31.07 156.73,30.81 156.73,21.67 156.47,21.41 156.47,16.84 156.22,16.59 149.44,16.59 149.05,16.97 149.05,21.29 149.44,21.67 155.01,21.67 155.33,21.98 155.33,25.62 153.72,25.62 153.72,26.87 155.33,26.87 155.33,30.43 154.95,30.81 148.22,30.81 147.96,31.07 147.96,33.48
GND on TOP: 161.42,82.25 160.28,82.25 160.08,82.45 160.08,82.71 159.93,82.86 159.85,82.86 159.67,83.04 159.49,83.04 159.49,81.64 159.9,81.23 161.42,81.23 161.55,81.36 161.55,82.12
GND on TOP: 13.34,61.67 15.37,61.67 15.88,62.18 15.88,68.53 15.63,68.79 13.34,68.79 13.09,68.53 13.09,61.93
GND on TOP: 103.1,36.35 103.2,36.35 103.3,36.3 103.86,35.74 131.35,35.74 131.58,35.51 131.58,31.96 131.33,31.7 101.86,31.7 101.48,32.08 101.48,36.23 101.6,36.35 102,36.35 102,35.85 102.1,35.75 102.9,35.75 103,35.85 103,36.25
GND on TOP: 182.76,39.7 182.76,37.47 182.63,37.34 180.47,37.34 180.35,37.47 180.35,39.7 180.47,39.83 182.63,39.83
GND on TOP: 170.57,65.61 178.95,65.61 179.2,65.86 179.2,67.13 178.95,67.39 170.57,67.39 170.31,67.13 170.31,65.86
GND on TOP: 236.23,50.12 240.42,50.12 240.8,50.5 240.8,54.43 240.52,54.71 236.13,54.71 235.85,54.43 235.85,50.5
GND on TOP: 65.41,16.72 65.41,18.49 66.56,18.49 66.56,18.75 65.38,18.75 65.38,19.6 65.79,20.02 65.79,20.78 65.41,21.16 65.41,22.43 63.38,22.43 63.25,22.3 63.25,21.8 63.38,21.67 63.76,21.67 63.92,21.51 63.92,18.24 62.75,18.24 62.75,17.99 63.91,17.99 63.91,13.9 64.02,13.79 65.67,13.79 65.67,14.05 65.16,14.05 65.03,14.18 65.03,14.68 65.16,14.81 65.67,14.81 65.67,16.46 ; 1 cut-out
GND on TOP: 178.67,30.25 178.67,29.54 178.54,29.42 174.97,29.42 174.85,29.29 174.85,18.75 174.72,18.62 170.19,18.62 169.43,19.38 169.43,35.64 169.55,35.77 178.51,35.77 178.63,35.64 178.63,34.93 178.51,34.8 177.5,34.8 177.37,34.67 177.37,30.51 177.5,30.38 178.54,30.38 ; 1 cut-out
GND on TOP: 11.02,63.58 11.02,85.55 10.9,85.68 3.28,85.68 3.02,85.43 3.02,63.71 3.28,63.46 10.9,63.46
GND on TOP: 214.38,43.64 218.96,43.64 219.21,43.39 219.21,35.38 218.96,35.13 216.54,35.13 216.29,34.88 216.29,32.59 215.91,32.21 214,32.21 213.75,32.46 213.75,43
GND on TOP: 82.51,30.56 85.1,30.56 85.35,30.81 85.35,32.72 85.1,32.97 82.51,32.97 82.26,32.72 82.26,30.81
GND on TOP: 161.42,38.81 160.28,38.81 160.08,39.02 160.08,39.27 159.93,39.42 159.85,39.42 159.67,39.6 159.49,39.6 159.49,38.2 159.9,37.8 161.42,37.8 161.55,37.92 161.55,38.69
GND on TOP: 161.42,67.77 160.28,67.77 160.08,67.97 160.08,68.23 159.93,68.38 159.85,68.38 159.67,68.56 159.49,68.56 159.49,67.16 159.9,66.75 161.42,66.75 161.55,66.88 161.55,67.64
GND on TOP: 234.83,99.9 239.53,99.9 239.78,100.15 239.78,103.84 239.53,104.09 234.83,104.09 234.58,103.84 234.58,100.15
GND on TOP: 164.85,35.51 164.85,92.79 165.11,93.04 166.89,93.04 167.39,92.53 167.39,35.51 167.27,35.38 164.98,35.38
GND on TOP: 195.41,52.1 195.41,57.43 195.46,57.48 195.84,57.48 197.11,56.21 197.11,54.94 197.75,54.31 197.75,53.8 197.11,53.16 197.11,51.77 197.62,51.26 197.62,46.05 197.37,45.8 194.19,45.8 194.06,45.93 194.06,50.75 ; 2 cut-outs
GND on TOP: 161.42,24.21 160.28,24.21 160.08,24.41 160.08,24.67 159.93,24.82 159.85,24.82 159.67,25 159.49,25 159.49,23.6 159.9,23.19 161.42,23.19 161.55,23.32 161.55,24.08
GND on TOP: 161.42,53.29 160.28,53.29 160.08,53.5 160.08,53.75 159.93,53.9 159.85,53.9 159.67,54.08 159.49,54.08 159.49,52.68 159.9,52.28 161.42,52.28 161.55,52.4 161.55,53.16
GND on TOP: 148.22,93.04 156.09,93.04 156.47,92.66 156.47,89.11 156.73,88.85 156.73,79.71 156.47,79.45 156.47,74.63 156.73,74.37 156.73,65.23 156.47,64.98 156.47,60.15 156.73,59.9 156.73,50.75 156.47,50.5 156.47,45.67 156.73,45.42 156.73,36.27 156.47,36.02 156.47,34.5 156.09,34.11 148.09,34.11 147.96,34.24 147.96,36.02 148.22,36.27 155.01,36.27 155.33,36.59 155.33,40.22 153.72,40.22 153.72,41.47 155.33,41.47 155.33,45.04 154.95,45.42 148.22,45.42 147.96,45.67 147.96,50.5 148.22,50.75 155.01,50.75 155.33,51.07 155.33,54.7 153.72,54.7 153.72,55.95 155.33,55.95 155.33,59.51 154.95,59.9 148.22,59.9 147.96,60.15 147.96,64.98 148.22,65.23 155.01,65.23 155.33,65.54 155.33,69.18 153.72,69.18 153.72,70.43 155.33,70.43 155.33,73.99 154.95,74.37 148.22,74.37 147.96,74.63 147.96,79.45 148.22,79.71 155.01,79.71 155.33,80.02 155.33,83.66 153.72,83.66 153.72,84.9 155.33,84.9 155.33,88.47 154.95,88.85 148.22,88.85 147.96,89.11 147.96,92.79
GND on TOP: 227.97,55.83 234.58,55.83 235.21,55.2 235.21,31.57 234.96,31.32 231.4,31.32 231.02,31.7 231.02,35.71 230.77,35.97 227.97,35.97 227.72,36.22 227.72,40.21 229.62,40.21 230,39.83 232.16,39.83 232.8,40.46 232.8,48.72 232.54,48.97 228.1,48.97 227.72,49.35 227.72,55.58 ; 1 cut-out
GND on TOP: 68.97,22.68 68.97,14.94 69.98,14.94 69.98,23.45 69.73,23.7 67.44,23.7 67.32,23.57 67.32,22.94 67.44,22.81 68.84,22.81
GND on TOP: 35.06,100.54 36.13,100.54 36.25,100.66 36.25,103.94 36.13,104.07 35.06,104.07 34.93,103.94 34.93,100.66
GND on TOP: 96.53,35.77 96.53,34.37 96.78,34.11 97.29,34.11 97.54,34.37 97.54,35.77
GND on TOP: 200.32,33.35 200.32,38.6 200.79,39.07 200.79,42.12 200.54,42.37 198.51,42.37 198.25,42.12 198.25,38.81 198.72,38.34 198.72,35.61 197.14,35.61 196.86,35.89 196.1,35.89 196.1,33.73 196.48,33.35 ; 4 cut-outs
