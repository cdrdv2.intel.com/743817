# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFPDD_RX1_N: length 38.6
  L03_SIG1 w0.079: v4(58.78,20.36) 59.04,20.62 arc(59.06,20.64) 59.1,20.64 59.43,20.64 arc(62.33,21.22) 64.78,22.86 65.65,23.73 arc(66.17,24.21) 66.74,24.64 69.21,26.34 arc(69.77,26.77) 70.29,27.24 70.49,27.44 arc(71.07,27.83) 71.75,27.96 71.92,27.96 arc(72.85,28.15) 73.64,28.68 74.72,29.75 arc(76.16,31.9) 76.66,34.44 76.66,39.34 arc(77.01,41.08) 77.99,42.55 79.24,43.8 arc(79.33,43.86) 79.43,43.88 79.48,43.88 arc(79.75,43.95) 79.95,44.15 79.96,44.18 arc(80.08,44.29) 80.24,44.34 80.28,44.34 arc(80.55,44.41) 80.75,44.61 80.76,44.64 arc(80.88,44.75) 81.03,44.79 81.07,44.79 arc(81.34,44.87) 81.54,45.07 81.59,45.15 arc(81.66,45.21) 81.75,45.24 82,45.24 arc(82.15,45.28) 82.27,45.39 82.32,45.46 arc(82.37,45.5) 82.44,45.49 v4(82.65,45.37)
QSFPDD_RX1_P: length 38.6
  L03_SIG1 w0.079: v4(58.78,21.16) 59.04,20.9 arc(59.06,20.88) 59.1,20.87 59.43,20.87 arc(62.24,21.43) 64.61,23.02 65.49,23.89 arc(66.03,24.39) 66.61,24.83 69.08,26.53 arc(69.63,26.94) 70.13,27.4 70.33,27.6 arc(70.98,28.04) 71.75,28.19 71.92,28.19 arc(72.77,28.36) 73.48,28.84 74.56,29.92 arc(75.95,31.99) 76.43,34.44 76.43,39.34 arc(76.8,41.17) 77.83,42.71 77.93,42.82 77.93,43.02 78.11,43.2 78.32,43.2 78.5,43.38 78.5,43.59 78.68,43.77 78.89,43.77 79.08,43.96 arc(79.24,44.07) 79.43,44.11 79.48,44.11 arc(79.64,44.15) 79.75,44.26 79.77,44.29 arc(79.96,44.49) 80.24,44.56 80.28,44.56 arc(80.43,44.61) 80.55,44.72 80.56,44.75 arc(80.76,44.95) 81.03,45.02 81.07,45.02 arc(81.23,45.06) 81.35,45.18 81.39,45.26 arc(81.54,45.41) 81.75,45.47 82,45.47 arc(82.04,45.48) 82.08,45.51 82.1,45.55 arc(82.12,45.64) 82.07,45.7 v4(81.85,45.83)
QSFPDD_RX2_N: length 49.9
  L03_SIG1 w0.079: v4(80.26,55.95) 80.03,55.82 arc(79.99,55.76) 80,55.69 80.02,55.67 arc(80.08,55.49) 80.03,55.31 79.94,55.14 arc(79.76,54.96) 79.52,54.9 79.4,54.9 arc(79.27,54.86) 79.18,54.77 79.12,54.68 arc(78.95,54.5) 78.71,54.44 78.46,54.44 arc(78.38,54.42) 78.31,54.38 76.57,52.64 arc(76.11,52.1) 75.73,51.51 75.36,50.61 arc(75.08,50.02) 74.75,49.47 73.64,47.81 69.94,41.64 arc(69.82,41.46) 69.67,41.29 69.51,41.13 arc(68.88,40.71) 68.15,40.57 67.94,40.57 arc(67.67,40.51) 67.44,40.36 67.07,39.99 arc(66.7,39.69) 66.28,39.46 65.05,38.95 arc(64.58,38.81) 64.1,38.76 64.01,38.76 arc(63.31,38.69) 62.65,38.49 56.37,35.89 arc(55.47,35.41) 54.68,34.76 54.46,34.54 arc(54.03,33.9) 53.88,33.15 53.88,29.44 arc(53.77,28.88) 53.45,28.4 52.97,27.92 arc(52.71,27.75) 52.41,27.69 arc(52.2,27.65) 52.02,27.53 51.49,27 arc(51.25,26.71) 51.07,26.37 arc(50.96,26.01) 50.92,25.63 50.92,23.07 arc(50.8,22.77) 50.5,22.64 50.31,22.64 arc(50.27,22.64) 50.25,22.62 v4(49.99,22.36)
QSFPDD_RX2_P: length 49.9
  L03_SIG1 w0.079: v4(49.99,23.16) 50.25,22.9 arc(50.27,22.88) 50.31,22.87 50.5,22.87 arc(50.64,22.93) 50.69,23.07 50.69,23.99 50.55,24.14 50.55,24.39 50.69,24.54 50.69,25.63 arc(50.86,26.46) 51.33,27.16 51.86,27.69 arc(52.11,27.86) 52.41,27.92 arc(52.62,27.96) 52.81,28.08 53.29,28.56 arc(53.56,28.97) 53.65,29.44 53.65,33.15 arc(53.82,33.99) 54.3,34.7 54.52,34.93 arc(55.34,35.6) 56.28,36.1 62.56,38.7 arc(63.27,38.92) 64.01,38.99 64.1,38.99 arc(64.54,39.04) 64.96,39.16 66.19,39.67 arc(66.57,39.88) 66.91,40.15 67.28,40.52 arc(67.58,40.72) 67.94,40.8 68.15,40.8 arc(68.79,40.92) 69.34,41.29 69.51,41.46 arc(69.64,41.6) 69.75,41.76 73.45,47.93 74.56,49.6 arc(74.88,50.13) 75.15,50.69 75.52,51.61 arc(75.92,52.23) 76.4,52.8 76.55,52.95 76.55,53.15 76.73,53.33 76.94,53.33 77.12,53.51 77.12,53.72 77.29,53.89 77.49,53.89 77.69,54.09 77.69,54.29 77.88,54.48 78.09,54.48 78.15,54.54 arc(78.29,54.64) 78.46,54.67 78.71,54.67 arc(78.84,54.7) 78.93,54.79 78.98,54.88 arc(79.16,55.06) 79.4,55.13 79.52,55.13 arc(79.65,55.16) 79.74,55.25 79.84,55.42 arc(79.85,55.48) 79.83,55.54 79.8,55.59 arc(79.75,55.63) 79.68,55.62 v4(79.46,55.49)
QSFPDD_RX3_N: length 38.6
  L03_SIG1 w0.079: v4(82.65,47.21) 82.44,47.33 arc(82.37,47.34) 82.32,47.3 82.27,47.23 arc(82.15,47.12) 82,47.08 81.75,47.08 arc(81.66,47.05) 81.59,46.99 81.54,46.91 arc(81.34,46.71) 81.07,46.63 81.03,46.63 arc(80.93,46.62) 80.83,46.58 80.23,46.23 arc(80.04,46.09) 79.9,45.9 79.78,45.69 arc(79.6,45.42) 79.39,45.18 77.29,43.08 arc(76.09,41.28) 75.66,39.14 75.66,34.29 arc(75.21,32) 73.91,30.06 73.28,29.43 arc(72.55,28.94) 71.69,28.77 71.63,28.77 arc(70.8,28.6) 70.1,28.13 69.85,27.88 arc(69.33,27.42) 68.77,27.02 66.16,25.38 arc(65.92,25.21) 65.7,25.01 65.64,24.94 arc(63.22,23.33) 60.38,22.76 60.22,22.76 arc(59.96,22.8) 59.72,22.9 arc(59.48,23.01) 59.22,23.04 59.1,23.04 arc(59.06,23.04) 59.04,23.02 v4(58.78,22.76)
QSFPDD_RX3_P: length 38.6
  L03_SIG1 w0.079: v4(81.85,47.67) 82.07,47.54 arc(82.12,47.48) 82.1,47.39 82.08,47.35 arc(82.04,47.32) 82,47.31 81.75,47.31 arc(81.54,47.25) 81.39,47.1 81.35,47.02 arc(81.23,46.9) 81.07,46.86 81.03,46.86 arc(80.87,46.84) 80.72,46.78 80.12,46.43 arc(79.88,46.25) 79.7,46.01 79.58,45.8 arc(79.42,45.56) 79.23,45.34 79.05,45.16 78.84,45.16 78.66,44.98 78.66,44.78 78.43,44.54 78.22,44.54 78.04,44.36 78.04,44.15 77.13,43.24 arc(75.87,41.36) 75.43,39.14 75.43,34.29 arc(74.99,32.09) 73.75,30.22 73.12,29.59 arc(72.46,29.15) 71.69,29 71.63,29 arc(70.72,28.82) 69.94,28.3 69.69,28.04 arc(69.19,27.6) 68.64,27.21 66.04,25.57 arc(65.78,25.38) 65.54,25.17 65.48,25.1 arc(63.14,23.54) 60.38,22.99 60.22,22.99 arc(60.02,23.02) 59.84,23.1 arc(59.54,23.23) 59.22,23.27 59.1,23.27 arc(59.06,23.28) 59.04,23.3 v4(58.78,23.56)
QSFPDD_RX4_N: length 45.5
  L03_SIG1 w0.079: v4(52.92,19.96) 53.16,20.21 arc(53.21,20.23) 53.25,20.24 53.51,20.24 arc(53.83,20.38) 53.97,20.71 53.97,21.92 arc(53.99,22) 54.04,22.08 54.06,22.1 arc(54.17,22.26) 54.21,22.45 54.21,24.16 arc(54.28,24.53) 54.49,24.84 54.78,25.14 arc(54.88,25.2) 55,25.22 arc(55.23,25.27) 55.43,25.4 56.51,26.48 arc(56.71,26.78) 56.78,27.13 arc(56.85,27.48) 57.05,27.78 57.16,27.9 arc(57.58,28.18) 58.07,28.27 58.68,28.27 arc(59.85,28.51) 60.85,29.17 61.74,30.06 arc(62.36,30.81) 62.82,31.68 63.54,33.41 arc(64.53,35.26) 65.86,36.89 65.96,36.99 arc(66.87,37.74) 67.91,38.3 69.38,38.9 arc(70.37,39.43) 71.24,40.14 72.92,41.83 arc(73.48,42.44) 73.98,43.11 75.44,45.3 arc(76.12,46.58) 76.54,47.97 76.64,48.47 arc(76.83,49) 77.16,49.45 78.43,50.71 arc(78.48,50.75) 78.55,50.76 78.71,50.76 arc(78.95,50.82) 79.12,51 79.18,51.09 arc(79.27,51.18) 79.4,51.22 79.52,51.22 arc(79.76,51.28) 79.94,51.46 80.03,51.63 arc(80.08,51.81) 80.02,51.99 80,52.01 arc(79.99,52.08) 80.03,52.14 v4(80.26,52.27)
QSFPDD_RX4_P: length 45.5
  L03_SIG1 w0.079: v4(79.46,51.81) 79.68,51.94 arc(79.75,51.95) 79.8,51.91 79.83,51.86 arc(79.85,51.8) 79.84,51.74 79.74,51.57 arc(79.65,51.48) 79.52,51.45 79.4,51.45 arc(79.16,51.38) 78.98,51.2 78.93,51.11 arc(78.84,51.02) 78.71,50.99 78.55,50.99 arc(78.4,50.96) 78.26,50.87 78.2,50.81 78,50.81 77.82,50.63 77.82,50.42 77.64,50.24 77.43,50.24 77.25,50.06 77.25,49.85 77,49.61 arc(76.63,49.11) 76.42,48.52 76.32,48.02 arc(75.91,46.67) 75.25,45.43 73.79,43.24 arc(73.3,42.59) 72.76,41.99 71.07,40.3 arc(70.24,39.62) 69.3,39.12 67.83,38.51 arc(66.75,37.93) 65.8,37.15 65.7,37.05 arc(64.34,35.39) 63.32,33.5 62.61,31.77 arc(62.17,30.94) 61.57,30.22 60.69,29.33 arc(59.77,28.72) 58.68,28.5 58.07,28.5 arc(57.49,28.39) 57,28.06 56.88,27.94 arc(56.63,27.57) 56.55,27.13 arc(56.49,26.87) 56.34,26.64 55.84,26.13 55.63,26.13 55.45,25.95 55.45,25.75 55.27,25.57 arc(55.15,25.48) 55,25.45 arc(54.79,25.41) 54.62,25.3 54.33,25.01 arc(54.07,24.62) 53.98,24.16 53.98,22.45 arc(53.96,22.35) 53.9,22.26 53.87,22.24 arc(53.78,22.09) 53.74,21.92 53.74,21.66 53.59,21.52 53.59,21.26 53.74,21.12 53.74,20.71 arc(53.67,20.54) 53.51,20.47 53.24,20.47 arc(53.2,20.48) 53.17,20.5 v4(52.92,20.76)
QSFPDD_RX5_N: length 39.8
  L03_SIG1 w0.079: v4(55.85,20.36) 56.08,20.59 arc(56.14,20.63) 56.21,20.64 56.43,20.64 arc(56.76,20.78) 56.9,21.11 56.9,22.03 arc(56.92,22.12) 56.97,22.19 57,22.23 arc(57.1,22.38) 57.14,22.55 57.14,24.3 arc(57.19,24.55) 57.33,24.76 57.41,24.84 arc(57.7,25.03) 58.03,25.1 58.39,25.1 arc(59.36,25.29) 60.19,25.84 62.67,28.32 arc(63.71,29.59) 64.48,31.04 65.35,33.14 arc(66.17,34.66) 67.26,36 67.37,36.11 arc(68.14,36.74) 69.01,37.2 72.18,38.52 arc(72.95,38.93) 73.62,39.48 arc(73.92,39.81) 74.18,40.16 76.14,43.09 77.18,44.44 79.16,47.39 arc(79.29,47.5) 79.45,47.54 79.52,47.54 arc(79.76,47.6) 79.94,47.78 80.03,47.95 arc(80.08,48.13) 80.02,48.31 80,48.33 arc(79.99,48.4) 80.03,48.46 v4(80.26,48.59)
QSFPDD_RX5_P: length 39.8
  L03_SIG1 w0.079: v4(79.46,48.13) 79.68,48.26 arc(79.75,48.27) 79.8,48.23 79.83,48.18 arc(79.85,48.12) 79.84,48.06 79.74,47.89 arc(79.65,47.8) 79.52,47.77 79.45,47.77 arc(79.18,47.7) 78.97,47.51 78.8,47.25 78.6,47.21 78.46,47 78.5,46.8 78.35,46.59 78.16,46.55 78.01,46.34 78.05,46.15 77.91,45.93 77.71,45.9 77.57,45.69 77.61,45.49 77,44.58 75.95,43.22 73.99,40.29 arc(73.74,39.95) 73.46,39.64 arc(72.82,39.12) 72.09,38.73 68.93,37.42 arc(68.01,36.93) 67.21,36.27 67.1,36.16 arc(65.98,34.79) 65.14,33.22 64.27,31.12 arc(63.52,29.72) 62.51,28.48 60.59,26.57 60.38,26.57 60.2,26.39 60.2,26.18 60.02,26 arc(59.28,25.5) 58.39,25.33 58.03,25.33 arc(57.61,25.24) 57.25,25 57.16,24.92 arc(56.97,24.63) 56.91,24.3 56.91,22.55 arc(56.89,22.46) 56.84,22.39 56.8,22.35 arc(56.71,22.21) 56.67,22.03 56.67,21.11 arc(56.6,20.94) 56.43,20.87 56.2,20.87 arc(56.14,20.89) 56.08,20.92 v4(55.85,21.16)
QSFPDD_RX6_N: length 46.5
  L03_SIG1 w0.079: v4(80.26,54.11) 80.03,53.98 arc(79.99,53.92) 80,53.85 80.02,53.83 arc(80.08,53.65) 80.03,53.47 79.94,53.3 arc(79.76,53.12) 79.52,53.06 79.4,53.06 arc(79.27,53.02) 79.18,52.93 79.12,52.84 arc(78.95,52.66) 78.71,52.6 78.58,52.6 arc(78.41,52.57) 78.26,52.47 76.57,50.78 arc(75.96,50.03) 75.5,49.18 74.28,46.23 arc(74.13,45.9) 73.94,45.59 71.23,41.54 arc(70.89,41.08) 70.51,40.66 70.03,40.19 arc(69.59,39.82) 69.09,39.56 65.21,37.95 arc(64.65,37.78) 64.07,37.72 63.85,37.72 arc(63.28,37.67) 62.73,37.5 60.39,36.53 arc(59.07,35.82) 57.92,34.88 57.21,34.17 arc(56.95,33.77) 56.85,33.3 56.85,29.88 arc(56.72,29.22) 56.34,28.65 arc(55.98,28.41) 55.55,28.32 55.02,28.32 arc(54.72,28.26) 54.46,28.09 54.38,28.01 arc(53.73,27.04) 53.5,25.9 53.5,23.91 arc(53.52,23.79) 53.55,23.67 arc(53.6,23.48) 53.62,23.28 53.62,22.95 arc(53.53,22.73) 53.31,22.64 53.24,22.64 arc(53.2,22.64) 53.18,22.62 v4(52.92,22.36)
QSFPDD_RX6_P: length 46.5
  L03_SIG1 w0.079: v4(79.46,53.65) 79.68,53.78 arc(79.75,53.79) 79.8,53.75 79.83,53.7 arc(79.85,53.64) 79.84,53.58 79.74,53.41 arc(79.65,53.32) 79.52,53.29 79.4,53.29 arc(79.16,53.22) 78.98,53.04 78.93,52.95 arc(78.84,52.86) 78.71,52.83 78.58,52.83 arc(78.32,52.78) 78.1,52.63 78.07,52.6 77.86,52.6 77.69,52.42 77.69,52.22 77.51,52.04 77.3,52.04 77.12,51.86 77.12,51.65 76.94,51.47 76.73,51.47 76.55,51.29 76.55,51.08 76.41,50.94 arc(75.77,50.16) 75.29,49.26 74.07,46.32 arc(73.92,46.01) 73.75,45.72 71.04,41.66 arc(70.71,41.23) 70.35,40.82 69.87,40.35 arc(69.47,40.01) 69.01,39.77 65.12,38.16 arc(64.61,38) 64.07,37.95 63.85,37.95 arc(63.24,37.89) 62.64,37.71 60.3,36.74 arc(58.95,36.01) 57.76,35.04 57.05,34.33 arc(56.73,33.86) 56.62,33.3 56.62,29.88 arc(56.51,29.3) 56.18,28.82 arc(55.89,28.62) 55.55,28.55 55.02,28.55 arc(54.63,28.47) 54.3,28.25 54.22,28.17 arc(53.52,27.13) 53.28,25.9 53.28,25.12 53.13,24.97 53.13,24.72 53.28,24.57 53.28,23.91 arc(53.29,23.75) 53.33,23.59 arc(53.37,23.44) 53.39,23.28 53.39,22.95 arc(53.36,22.9) 53.31,22.87 53.24,22.87 arc(53.2,22.88) 53.18,22.9 v4(52.92,23.16)
QSFPDD_RX7_N: length 38.9
  L03_SIG1 w0.079: v4(80.26,50.43) 80.03,50.3 arc(79.99,50.24) 80,50.17 80.02,50.15 arc(80.08,49.97) 80.03,49.79 79.94,49.62 arc(79.76,49.44) 79.52,49.38 79.4,49.38 arc(79.27,49.34) 79.18,49.25 79.12,49.16 arc(78.95,48.98) 78.71,48.92 78.67,48.92 arc(78.46,48.86) 78.3,48.7 76.5,45.32 arc(76.18,44.76) 75.84,44.22 75.37,43.52 arc(74.45,42.27) 73.41,41.13 71.95,39.67 arc(71.08,38.96) 70.09,38.43 68.43,37.74 arc(67.61,37.3) 66.89,36.71 66.53,36.35 arc(65.27,34.81) 64.33,33.06 63.77,31.72 arc(63.01,30.29) 61.98,29.03 59.38,26.44 arc(58.89,26.1) 58.3,25.99 57.95,25.99 arc(57.45,25.89) 57.03,25.61 56.67,25.25 arc(56.5,24.99) 56.43,24.67 56.43,24.53 arc(56.44,24.38) 56.46,24.22 56.52,23.91 arc(56.54,23.79) 56.55,23.67 56.55,23.34 arc(56.46,23.13) 56.25,23.04 56.17,23.04 arc(56.13,23.04) 56.11,23.02 v4(55.85,22.76)
QSFPDD_RX7_P: length 38.9
  L03_SIG1 w0.079: v4(55.85,23.56) 56.11,23.3 arc(56.13,23.28) 56.17,23.27 56.25,23.27 arc(56.3,23.29) 56.32,23.34 56.32,23.67 arc(56.31,23.77) 56.3,23.87 56.24,24.18 arc(56.21,24.35) 56.21,24.53 56.21,24.67 arc(56.29,25.07) 56.51,25.41 56.87,25.77 arc(57.36,26.1) 57.95,26.22 58.3,26.22 arc(58.8,26.31) 59.22,26.6 59.43,26.81 59.43,27.02 59.61,27.2 59.82,27.2 60.22,27.6 60.22,27.8 60.4,27.98 60.6,27.98 61.82,29.2 arc(62.82,30.41) 63.56,31.8 64.12,33.15 arc(65.08,34.94) 66.37,36.51 66.73,36.87 arc(67.48,37.49) 68.34,37.95 70,38.64 arc(70.96,39.15) 71.79,39.84 73.25,41.29 arc(74.27,42.42) 75.18,43.65 75.65,44.35 arc(75.99,44.88) 76.29,45.42 77.38,47.46 77.33,47.65 77.44,47.88 77.64,47.94 77.76,48.16 77.7,48.35 77.82,48.58 78.01,48.63 78.1,48.81 arc(78.34,49.06) 78.67,49.15 78.71,49.15 arc(78.84,49.18) 78.93,49.27 78.98,49.36 arc(79.16,49.54) 79.4,49.61 79.52,49.61 arc(79.65,49.64) 79.74,49.73 79.84,49.9 arc(79.85,49.96) 79.83,50.02 79.8,50.07 arc(79.75,50.11) 79.68,50.1 v4(79.46,49.97)
QSFPDD_TX0_N: length 42.8
  L16_SIG6 w0.079: U8.AU51 82.44,58.37 arc(82.36,58.38) 82.29,58.33 82.27,58.29 arc(82.14,58.17) 81.96,58.12 81.84,58.12 arc(81.69,58.08) 81.57,57.98 81.49,57.87 arc(81.33,57.72) 81.12,57.67 80.93,57.67 arc(80.85,57.66) 80.78,57.63 79.41,56.84 arc(79.29,56.75) 79.2,56.63 79.17,56.57 arc(78.97,56.37) 78.69,56.29 78.6,56.29 arc(78.43,56.26) 78.3,56.17 75.59,53.47 arc(75.01,52.76) 74.58,51.95 74.56,51.9 arc(74.33,51.46) 74.01,51.08 73.59,50.65 arc(73.3,50.34) 73.05,50 70.02,45.46 arc(69.65,45.05) 69.18,44.77 68.58,44.52 arc(68.38,44.41) 68.2,44.27 68.1,44.17 arc(67.78,43.91) 67.43,43.72 66.51,43.34 arc(64.04,42.59) 61.47,42.34 59.55,42.34 arc(58.41,42.11) 57.44,41.46 57.32,41.34 arc(56.88,40.69) 56.73,39.91 56.73,39.06 56.87,38.91 56.87,38.66 56.73,38.51 56.73,38.26 56.87,38.11 56.87,37.86 56.73,37.71 56.73,37.46 56.87,37.31 56.87,37.06 56.73,36.91 56.73,36.72 arc(56.78,36.45) 56.93,36.22 58.03,35.12 arc(58.21,34.85) 58.27,34.54 58.27,34.16 58.42,34.01 58.42,33.76 58.27,33.61 58.27,32.96 arc(58.3,32.9) 58.36,32.87 58.45,32.87 arc(58.49,32.88) 58.52,32.9 58.78,33.16
QSFPDD_TX0_P: length 42.8
  L16_SIG6 w0.079: U8.AV52 82.06,58.58 arc(82.11,58.52) 82.1,58.45 82.08,58.41 arc(82.03,58.37) 81.96,58.35 81.84,58.35 arc(81.58,58.29) 81.38,58.11 81.3,58 arc(81.22,57.93) 81.12,57.9 80.93,57.9 arc(80.79,57.88) 80.66,57.83 79.29,57.04 arc(79.13,56.91) 79,56.74 78.97,56.68 arc(78.85,56.56) 78.69,56.52 78.6,56.52 arc(78.35,56.47) 78.13,56.33 75.43,53.63 arc(74.82,52.89) 74.37,52.04 74.35,51.99 arc(74.14,51.59) 73.85,51.24 73.43,50.82 arc(73.13,50.49) 72.86,50.13 69.83,45.59 arc(69.5,45.23) 69.09,44.98 68.49,44.73 arc(68.25,44.6) 68.04,44.43 67.94,44.33 arc(67.66,44.1) 67.34,43.93 66.43,43.55 arc(63.99,42.81) 61.47,42.56 59.55,42.56 arc(58.32,42.32) 57.28,41.62 57.15,41.5 arc(56.67,40.77) 56.5,39.91 56.5,36.72 arc(56.57,36.36) 56.77,36.06 57.87,34.96 arc(58,34.76) 58.05,34.54 58.05,32.96 arc(58.14,32.74) 58.36,32.64 58.45,32.64 arc(58.49,32.64) 58.52,32.62 58.78,32.36
QSFPDD_TX1_N: length 58.7
  L16_SIG6 w0.079: 49.99,32.76 49.73,32.51 arc(49.7,32.48) 49.65,32.47 49.54,32.47 arc(49.19,32.33) 49.05,31.98 49.05,29.32 arc(49.15,28.78) 49.46,28.31 50.51,27.26 arc(50.69,27) 50.75,26.7 50.75,26.55 arc(50.8,26.26) 50.96,26.02 52.15,24.84 arc(52.29,24.74) 52.46,24.71 52.59,24.71 arc(52.71,24.68) 52.81,24.62 54.26,23.16 arc(55.07,22.62) 56.02,22.43 58.8,22.43 arc(58.95,22.42) 59.1,22.37 59.24,22.32 arc(59.58,22.21) 59.94,22.18 61.19,22.18 arc(62.82,22.42) 64.3,23.12 71.08,27.66 arc(71.3,27.79) 71.53,27.9 73.07,28.54 arc(73.75,28.9) 74.34,29.38 74.67,29.72 arc(75.04,30.17) 75.32,30.68 75.98,32.29 arc(76.2,32.9) 76.36,33.53 78.01,41.84 arc(78.12,42.26) 78.26,42.66 79.04,44.55 arc(79.13,44.7) 79.24,44.84 79.43,45.04 arc(79.69,45.2) 79.98,45.26 80.29,45.26 arc(80.55,45.33) 80.74,45.52 80.77,45.58 arc(80.88,45.68) 81.02,45.71 81.11,45.71 arc(81.74,45.87) 82.22,46.29 82.42,46.58 arc(82.85,46.96) 83.4,47.09 83.48,47.09 arc(83.73,47.16) 83.92,47.34 83.98,47.44 arc(84.05,47.51) 84.16,47.54 84.34,47.54 arc(84.55,47.59) 84.7,47.74 84.8,47.93 arc(84.85,48.11) 84.81,48.29 84.79,48.32 arc(84.78,48.4) 84.83,48.47 U8.T48
QSFPDD_TX1_P: length 58.7
  L16_SIG6 w0.079: U8.R49 84.46,48.25 arc(84.53,48.26) 84.59,48.22 84.61,48.18 arc(84.63,48.11) 84.61,48.04 84.5,47.86 arc(84.43,47.79) 84.34,47.77 84.16,47.77 arc(83.94,47.71) 83.78,47.56 83.72,47.46 arc(83.62,47.36) 83.48,47.32 83.4,47.32 arc(82.74,47.16) 82.23,46.71 82.03,46.42 arc(81.63,46.07) 81.11,45.94 81.02,45.94 arc(80.77,45.88) 80.58,45.69 80.54,45.64 arc(80.43,45.53) 80.29,45.49 79.98,45.49 arc(79.6,45.41) 79.27,45.2 79.08,45 arc(78.94,44.83) 78.83,44.63 78.05,42.74 arc(77.9,42.32) 77.79,41.89 77.74,41.64 77.57,41.52 77.52,41.27 77.63,41.1 77.58,40.85 77.41,40.73 77.36,40.49 77.48,40.31 77.43,40.06 77.25,39.95 77.2,39.7 77.32,39.52 77.27,39.28 77.1,39.16 77.05,38.91 77.16,38.74 76.13,33.57 arc(75.98,32.97) 75.77,32.38 75.11,30.77 arc(74.85,30.3) 74.51,29.88 74.17,29.54 arc(73.62,29.09) 72.98,28.75 71.45,28.11 arc(71.2,27.99) 70.96,27.85 64.18,23.31 arc(62.75,22.64) 61.19,22.41 59.94,22.41 arc(59.63,22.44) 59.32,22.53 59.19,22.59 arc(59,22.64) 58.8,22.66 56.02,22.66 arc(55.16,22.83) 54.43,23.32 54.11,23.64 54.11,23.85 53.93,24.03 53.72,24.03 53.54,24.21 53.54,24.42 53.36,24.6 53.15,24.6 52.97,24.78 arc(52.79,24.9) 52.59,24.94 52.46,24.94 arc(52.38,24.95) 52.31,25 51.94,25.37 51.94,25.58 51.76,25.76 51.55,25.76 51.13,26.18 arc(51.01,26.35) 50.98,26.55 50.98,26.7 arc(50.9,27.09) 50.68,27.42 50.19,27.91 50.19,28.12 50.01,28.29 49.8,28.29 49.62,28.47 arc(49.36,28.86) 49.27,29.32 49.27,30.37 49.41,30.51 49.41,30.78 49.27,30.92 49.27,31.17 49.41,31.31 49.41,31.58 49.27,31.72 49.27,31.98 arc(49.35,32.17) 49.54,32.24 49.66,32.24 arc(49.7,32.24) 49.73,32.22 49.99,31.96
QSFPDD_TX2_N: length 37.6
  L16_SIG6 w0.079: 58.78,30.76 59,30.53 arc(59.07,30.49) 59.14,30.47 59.25,30.47 arc(59.39,30.53) 59.45,30.67 59.45,32.24 arc(59.55,32.74) 59.83,33.16 59.89,33.21 59.89,33.42 60.07,33.6 60.27,33.6 60.45,33.78 60.45,33.99 60.63,34.17 60.84,34.17 67.09,40.42 arc(67.54,40.72) 68.07,40.83 68.32,40.83 arc(68.85,40.93) 69.29,41.23 69.85,41.79 arc(70,41.97) 70.13,42.16 70.69,43.52 arc(71.77,45.53) 73.22,47.3 73.44,47.52 arc(73.8,47.96) 74.06,48.45 74.33,49.09 arc(74.64,49.76) 75.02,50.4 76.46,52.54 arc(77.12,53.44) 77.87,54.27 78.09,54.48 arc(78.31,54.63) 78.58,54.68 78.68,54.68 arc(78.84,54.73) 78.96,54.84 78.98,54.88 arc(79.08,55.02) 79.22,55.13 80.69,55.98 arc(80.84,56.04) 80.99,56.06 81.12,56.06 arc(81.22,56.09) 81.3,56.16 81.38,56.27 arc(81.58,56.45) 81.84,56.51 81.96,56.51 arc(82.03,56.53) 82.08,56.57 82.1,56.61 arc(82.11,56.68) 82.06,56.74 U8.AP52
QSFPDD_TX2_P: length 37.6
  L16_SIG6 w0.079: U8.AN51 82.44,56.53 arc(82.36,56.54) 82.29,56.49 82.27,56.45 arc(82.14,56.33) 81.96,56.28 81.84,56.28 arc(81.69,56.24) 81.57,56.14 81.49,56.03 arc(81.33,55.88) 81.12,55.83 80.99,55.83 arc(80.9,55.82) 80.81,55.78 79.34,54.93 arc(79.25,54.86) 79.17,54.76 79.15,54.73 arc(78.95,54.53) 78.68,54.45 78.58,54.45 arc(78.4,54.42) 78.25,54.32 78.04,54.11 arc(77.3,53.29) 76.65,52.41 75.21,50.27 arc(74.85,49.65) 74.54,49.01 74.27,48.36 arc(73.99,47.83) 73.6,47.36 73.38,47.14 arc(71.96,45.4) 70.9,43.43 70.34,42.07 arc(70.19,41.83) 70.01,41.63 69.46,41.07 arc(68.93,40.72) 68.32,40.6 68.07,40.6 arc(67.63,40.51) 67.25,40.26 59.99,33 arc(59.76,32.65) 59.68,32.24 59.68,30.67 arc(59.55,30.37) 59.25,30.24 59.14,30.24 arc(59.07,30.23) 59.01,30.19 58.78,29.96
QSFPDD_TX3_N: length 51.9
  L16_SIG6 w0.079: 49.99,30.36 50.25,30.1 arc(50.27,30.08) 50.31,30.07 50.48,30.07 arc(50.69,30.03) 50.86,29.92 50.97,29.81 arc(51.12,29.57) 51.18,29.3 51.18,28.85 arc(51.23,28.62) 51.36,28.42 51.54,28.24 51.75,28.24 51.92,28.06 51.92,27.85 52.86,26.92 arc(53.02,26.67) 53.08,26.38 53.08,26.27 arc(53.13,26.01) 53.28,25.79 54.71,24.36 arc(55.71,23.69) 56.89,23.46 57.12,23.46 57.27,23.6 57.52,23.6 57.67,23.46 59.06,23.46 arc(59.29,23.43) 59.51,23.37 59.58,23.34 arc(60,23.21) 60.44,23.17 60.96,23.17 arc(62.51,23.4) 63.93,24.07 70.21,28.26 arc(70.71,28.56) 71.23,28.81 72.13,29.18 arc(72.97,29.63) 73.71,30.24 74.1,30.63 arc(74.32,30.89) 74.48,31.18 74.66,31.6 arc(74.91,32.31) 75.09,33.03 76.9,42.12 arc(77.55,44.46) 78.53,46.69 78.96,47.5 arc(79.08,47.65) 79.22,47.77 80.62,48.58 arc(80.84,48.67) 81.07,48.7 81.12,48.7 arc(81.22,48.73) 81.3,48.8 81.38,48.91 arc(81.58,49.09) 81.84,49.15 81.96,49.15 arc(82.03,49.17) 82.08,49.21 82.1,49.25 arc(82.11,49.32) 82.06,49.38 U8.V52
QSFPDD_TX3_P: length 51.9
  L16_SIG6 w0.079: U8.U51 82.44,49.17 arc(82.36,49.18) 82.29,49.13 82.27,49.09 arc(82.14,48.97) 81.96,48.92 81.84,48.92 arc(81.69,48.88) 81.57,48.78 81.49,48.67 arc(81.33,48.52) 81.12,48.47 81.07,48.47 arc(80.9,48.45) 80.74,48.38 79.34,47.57 arc(79.24,47.49) 79.17,47.39 78.74,46.59 arc(77.76,44.39) 77.12,42.07 75.31,32.99 arc(75.13,32.24) 74.87,31.51 74.69,31.09 arc(74.5,30.76) 74.26,30.47 73.87,30.07 arc(73.09,29.44) 72.21,28.97 71.32,28.6 arc(70.82,28.36) 70.34,28.07 64.05,23.88 arc(62.58,23.18) 60.96,22.94 60.44,22.94 arc(59.96,22.99) 59.49,23.13 59.42,23.16 arc(59.24,23.21) 59.06,23.23 56.89,23.23 arc(55.62,23.48) 54.55,24.2 53.12,25.63 arc(52.92,25.92) 52.85,26.27 52.85,26.38 arc(52.81,26.58) 52.7,26.76 51.2,28.26 arc(51.01,28.53) 50.95,28.85 50.95,29.3 arc(50.91,29.49) 50.8,29.65 50.7,29.75 arc(50.6,29.82) 50.48,29.84 50.31,29.84 arc(50.27,29.84) 50.25,29.82 49.99,29.56
QSFPDD_TX4_N: length 47.2
  L16_SIG6 w0.079: U8.AE51 82.44,52.85 arc(82.36,52.86) 82.29,52.81 82.27,52.77 arc(82.14,52.65) 81.96,52.6 81.84,52.6 arc(81.69,52.56) 81.57,52.46 81.49,52.35 arc(81.33,52.2) 81.12,52.15 80.99,52.15 arc(80.94,52.15) 80.9,52.14 arc(80.85,52.13) 80.81,52.1 79.34,51.25 arc(79.25,51.18) 79.17,51.08 79.15,51.05 arc(78.95,50.85) 78.68,50.77 78.59,50.77 arc(78.54,50.76) 78.5,50.73 77.84,50.07 arc(77.35,49.48) 76.99,48.81 75.78,45.89 arc(74.86,44.17) 73.62,42.65 70.72,39.76 arc(70.18,39.31) 69.55,38.97 67.84,38.27 arc(67.21,37.89) 66.65,37.41 66.57,37.33 arc(65.9,36.51) 65.4,35.58 63.26,30.41 arc(63.01,29.94) 62.67,29.52 59.69,26.54 arc(59.18,26.2) 58.57,26.08 57.74,26.08 arc(57.52,26.12) 57.34,26.25 57.26,26.33 arc(57.07,26.62) 57,26.95 57,27.02 arc(56.98,27.13) 56.92,27.21 55.95,28.18 arc(55.86,28.26) 55.75,28.31 arc(55.64,28.36) 55.55,28.43 55.25,28.74 arc(55.1,28.96) 55.05,29.22 55.05,32.51 arc(55.15,32.77) 55.41,32.87 55.52,32.87 arc(55.56,32.88) 55.59,32.9 55.85,33.16
QSFPDD_TX4_P: length 47.2
  L16_SIG6 w0.079: 55.85,32.36 55.59,32.62 arc(55.56,32.64) 55.52,32.64 55.41,32.64 arc(55.31,32.6) 55.28,32.51 55.28,31.82 55.42,31.67 55.42,31.42 55.28,31.27 55.28,29.22 arc(55.31,29.05) 55.41,28.9 55.71,28.6 arc(55.76,28.55) 55.83,28.52 arc(55.98,28.45) 56.12,28.34 56.3,28.16 56.51,28.16 56.69,27.98 56.69,27.77 57.08,27.38 arc(57.19,27.21) 57.23,27.02 57.23,26.95 arc(57.28,26.7) 57.42,26.49 57.5,26.41 arc(57.61,26.33) 57.74,26.31 58.57,26.31 arc(59.09,26.41) 59.53,26.71 60.19,27.36 60.19,27.57 60.37,27.75 60.57,27.75 60.75,27.93 60.75,28.14 60.93,28.32 61.14,28.32 61.32,28.5 61.32,28.71 61.5,28.89 61.71,28.89 61.89,29.07 61.89,29.27 62.07,29.45 62.28,29.45 62.51,29.68 arc(62.82,30.06) 63.05,30.5 65.19,35.67 arc(65.71,36.64) 66.41,37.49 66.49,37.57 arc(67.08,38.07) 67.75,38.47 69.46,39.18 arc(70.05,39.5) 70.56,39.92 73.46,42.82 arc(74.67,44.29) 75.57,45.98 76.78,48.9 arc(77.16,49.61) 77.67,50.23 77.85,50.41 77.85,50.56 78.06,50.76 78.2,50.76 78.33,50.89 arc(78.45,50.97) 78.59,51 78.68,51 arc(78.84,51.05) 78.96,51.16 78.98,51.2 arc(79.08,51.34) 79.22,51.45 80,51.9 80.05,52.1 80.27,52.23 80.47,52.17 80.69,52.3 arc(80.76,52.34) 80.84,52.36 arc(80.91,52.38) 80.99,52.38 81.12,52.38 arc(81.22,52.41) 81.3,52.48 81.38,52.59 arc(81.58,52.77) 81.84,52.83 81.96,52.83 arc(82.03,52.85) 82.08,52.89 82.1,52.93 arc(82.11,53) 82.06,53.06 U8.AF52
QSFPDD_TX5_N: length 52.9
  L16_SIG6 w0.079: 81.08,49.41 81.06,49.4 80.96,49.4 arc(80.86,49.37) 80.79,49.3 80.75,49.23 arc(80.65,49.09) 80.51,48.99 78.96,48.11 arc(78.79,48.04) 78.61,48.01 78.52,48.01 arc(78.43,48) 78.35,47.95 78.26,47.85 arc(78.14,47.7) 78.05,47.54 76.19,43.05 arc(75.24,41.28) 73.96,39.72 73.77,39.53 arc(73.6,39.37) 73.41,39.23 72.63,38.72 arc(72.41,38.59) 72.19,38.49 68.93,37.13 arc(68.36,36.83) 67.86,36.42 67.76,36.32 arc(67.19,35.62) 66.76,34.83 64.88,30.29 arc(64.45,29.47) 63.86,28.76 60.64,25.53 arc(59.72,24.92) 58.63,24.7 55.41,24.7 arc(55.05,24.77) 54.74,24.98 53.86,25.87 arc(53.62,26.21) 53.54,26.62 53.54,26.77 arc(53.5,26.97) 53.39,27.15 52.59,27.94 arc(52.23,28.49) 52.1,29.13 52.1,32.1 arc(52.21,32.36) 52.47,32.47 52.55,32.47 arc(52.62,32.49) 52.68,32.53 52.92,32.76
  L16_SIG6 w0.081: 81.08,49.41 81.16,49.41 arc(81.34,49.47) 81.47,49.62 81.49,49.67 arc(81.63,49.84) 81.84,49.9 81.89,49.9 arc(82.06,49.94) 82.2,50.02 82.45,50.25 arc(82.52,50.28) 82.59,50.3 82.7,50.3 arc(82.8,50.28) 82.87,50.23 83.1,50 arc(83.23,49.91) 83.38,49.88 83.52,49.88 arc(83.7,49.93) 83.84,50.07 83.94,50.25 arc(84.02,50.33) 84.14,50.36 84.35,50.36 arc(84.42,50.34) 84.47,50.29 84.51,50.22 arc(84.52,50.16) 84.48,50.11 U8.W49
QSFPDD_TX5_P: length 52.8
  L16_SIG6 w0.079: 81.08,49.61 81.06,49.63 80.96,49.63 arc(80.75,49.57) 80.6,49.42 80.55,49.34 arc(80.49,49.26) 80.4,49.19 78.85,48.31 arc(78.73,48.26) 78.61,48.24 78.52,48.24 arc(78.34,48.21) 78.19,48.11 78.09,48.01 arc(77.95,47.83) 77.84,47.62 75.98,43.14 arc(75.05,41.4) 73.8,39.88 73.61,39.69 arc(73.45,39.55) 73.28,39.42 72.5,38.91 arc(72.31,38.79) 72.1,38.7 68.84,37.34 arc(68.23,37.02) 67.7,36.58 67.6,36.48 arc(67,35.75) 66.55,34.91 64.67,30.38 arc(64.26,29.6) 63.7,28.92 60.47,25.7 arc(59.63,25.13) 58.63,24.93 57.02,24.93 56.87,25.08 56.62,25.08 56.47,24.93 56.21,24.93 56.06,25.08 55.82,25.08 55.67,24.93 55.41,24.93 arc(55.14,24.99) 54.9,25.14 54.02,26.03 arc(53.84,26.3) 53.77,26.62 53.77,26.77 arc(53.71,27.06) 53.55,27.31 53.32,27.54 53.32,27.75 53.14,27.93 52.93,27.93 52.75,28.11 arc(52.44,28.58) 52.33,29.13 52.33,30.89 52.48,31.04 52.48,31.29 52.33,31.44 52.33,32.1 arc(52.37,32.2) 52.47,32.24 52.55,32.24 arc(52.62,32.23) 52.68,32.19 52.92,31.96
  L16_SIG6 w0.081: 81.08,49.61 81.16,49.61 arc(81.24,49.63) 81.29,49.7 81.31,49.74 arc(81.52,50) 81.84,50.1 81.89,50.1 arc(81.99,50.12) 82.07,50.17 82.33,50.39 arc(82.45,50.47) 82.59,50.49 82.7,50.49 arc(82.87,50.46) 83.01,50.36 83.24,50.14 arc(83.3,50.09) 83.38,50.08 83.52,50.08 arc(83.6,50.1) 83.67,50.16 83.77,50.34 arc(83.93,50.5) 84.14,50.56 84.35,50.56 arc(84.52,50.51) 84.64,50.38 84.68,50.31 arc(84.73,50.28) 84.79,50.29 U8.Y48
QSFPDD_TX6_N: length 41
  L16_SIG6 w0.079: U8.AK52 82.06,54.9 arc(82.11,54.84) 82.1,54.77 82.08,54.73 arc(82.03,54.69) 81.96,54.67 81.84,54.67 arc(81.58,54.61) 81.38,54.43 81.3,54.32 arc(81.22,54.25) 81.12,54.22 80.99,54.22 arc(80.84,54.2) 80.69,54.14 79.22,53.29 arc(79.08,53.18) 78.98,53.04 78.96,53 arc(78.84,52.89) 78.68,52.84 78.59,52.84 arc(78.33,52.79) 78.1,52.64 76.51,51.05 arc(75.79,50.18) 75.26,49.18 73.86,45.79 arc(73.75,45.58) 73.6,45.4 73.52,45.33 arc(72.91,44.65) 72.37,43.92 71.17,42.13 arc(70.53,41.27) 69.82,40.47 69.42,40.08 arc(69.19,39.89) 68.92,39.74 67.65,39.22 arc(66.8,38.76) 66.05,38.15 65.4,37.5 arc(64.86,36.84) 64.46,36.09 62.73,31.91 arc(62.31,31.13) 61.75,30.44 60.61,29.3 arc(59.8,28.76) 58.85,28.58 58.75,28.58 arc(58.46,28.63) 58.21,28.8 57.81,29.2 57.81,29.41 57.63,29.59 57.42,29.59 57.24,29.77 57.24,29.98 57.06,30.16 56.85,30.16 56.67,30.34 arc(56.52,30.44) 56.34,30.47 56.17,30.47 arc(56.13,30.48) 56.11,30.5 55.85,30.76
QSFPDD_TX6_P: length 41
  L16_SIG6 w0.079: 55.85,29.96 56.11,30.22 arc(56.13,30.24) 56.17,30.24 56.34,30.24 arc(56.43,30.23) 56.51,30.18 58.05,28.64 arc(58.37,28.42) 58.75,28.35 58.85,28.35 arc(59.89,28.55) 60.77,29.14 61.91,30.28 arc(62.5,31) 62.94,31.82 64.67,36 arc(65.05,36.71) 65.56,37.34 66.21,37.99 arc(66.92,38.57) 67.74,39.01 69.01,39.53 arc(69.31,39.7) 69.58,39.91 69.98,40.31 arc(70.71,41.12) 71.36,42 72.56,43.79 arc(73.09,44.5) 73.69,45.16 73.76,45.24 arc(73.94,45.45) 74.07,45.7 75.47,49.1 arc(75.98,50.05) 76.67,50.88 78.27,52.48 arc(78.41,52.58) 78.59,52.61 78.68,52.61 arc(78.95,52.69) 79.15,52.89 79.17,52.92 arc(79.25,53.02) 79.34,53.09 80.81,53.94 arc(80.9,53.98) 80.99,53.99 81.12,53.99 arc(81.33,54.04) 81.49,54.19 81.57,54.3 arc(81.69,54.4) 81.84,54.44 81.96,54.44 arc(82.14,54.49) 82.27,54.61 82.29,54.65 arc(82.36,54.7) 82.44,54.69 U8.AJ51
QSFPDD_TX7_N: length 45.9
  L16_SIG6 w0.079: 52.92,30.36 53.18,30.1 arc(53.2,30.08) 53.24,30.07 53.49,30.07 arc(53.66,30.04) 53.81,29.94 54.18,29.57 arc(54.39,29.25) 54.47,28.87 54.47,28.47 54.61,28.32 54.61,28.07 54.47,27.92 54.47,26.72 arc(54.5,26.57) 54.58,26.45 54.78,26.25 arc(54.98,26.12) 55.21,26.07 56.57,26.07 arc(56.83,26.02) 57.05,25.87 57.17,25.76 arc(57.32,25.66) 57.5,25.62 58.59,25.62 arc(59.36,25.77) 60.02,26.21 63.07,29.27 arc(63.49,29.77) 63.79,30.35 65.75,35.06 arc(66.26,36.03) 66.95,36.87 67.29,37.21 arc(67.86,37.67) 68.51,38.02 70.32,38.77 arc(70.85,39.05) 71.32,39.43 73.78,41.89 arc(75.19,43.62) 76.24,45.58 77.17,47.83 arc(77.48,48.42) 77.91,48.93 arc(78.17,49.1) 78.47,49.16 78.68,49.16 arc(78.84,49.21) 78.95,49.32 78.97,49.36 arc(79.08,49.5) 79.22,49.61 79.92,50.01 79.97,50.21 80.19,50.34 80.39,50.29 80.69,50.46 arc(80.84,50.52) 80.99,50.54 81.12,50.54 arc(81.22,50.57) 81.3,50.64 81.38,50.75 arc(81.58,50.93) 81.84,50.99 81.96,50.99 arc(82.03,51.01) 82.08,51.05 82.1,51.09 arc(82.11,51.16) 82.06,51.22 U8.AB52
QSFPDD_TX7_P: length 45.9
  L16_SIG6 w0.079: 52.92,29.56 53.18,29.82 arc(53.2,29.84) 53.24,29.84 53.49,29.84 arc(53.57,29.83) 53.65,29.78 54.02,29.41 arc(54.18,29.16) 54.24,28.87 54.24,26.72 arc(54.29,26.49) 54.42,26.29 54.62,26.09 arc(54.89,25.91) 55.21,25.84 56.57,25.84 arc(56.74,25.81) 56.89,25.71 57,25.59 arc(57.23,25.44) 57.5,25.39 58.59,25.39 arc(59.45,25.56) 60.18,26.05 63.23,29.11 arc(63.68,29.64) 64,30.26 65.96,34.98 arc(66.45,35.9) 67.12,36.71 67.45,37.04 arc(67.99,37.48) 68.6,37.81 70.41,38.56 arc(70.98,38.86) 71.48,39.27 73.94,41.73 arc(75.38,43.49) 76.45,45.49 77.38,47.74 arc(77.67,48.29) 78.07,48.77 arc(78.25,48.89) 78.47,48.93 78.68,48.93 arc(78.95,49.01) 79.15,49.21 79.17,49.24 arc(79.24,49.34) 79.34,49.41 80.81,50.26 arc(80.9,50.3) 80.99,50.31 81.12,50.31 arc(81.33,50.36) 81.49,50.51 81.57,50.62 arc(81.69,50.72) 81.84,50.76 81.96,50.76 arc(82.14,50.81) 82.27,50.93 82.29,50.97 arc(82.36,51.02) 82.44,51.01 U8.AA51
QSFPDD_VCC:
  vias: v1(55,27.58) v1(55.72,27.58) v1(57.84,27.58) v1(58.56,27.58)
QSFPDD_VCCR: length 0.7
  TOP w0.381: J7.10 v1(48.72,26.36)
  vias: v1(50.07,26.38) v1(51.72,26.38) v1(52.32,26.38)
QSFPDD_VCCT:
  vias: v1(55,26.78) v1(55.72,26.78) v1(57.84,26.83) v1(58.6,26.83)
R_CIPRI_HIGH_REFCLK_N: length 3.6
  TOP w0.102: C1030.1 62.5,56.64 62.5,56.48 62.17,56.15 R842.1 62.17,56.02 62.5,55.69 62.5,55.13 62.39,55.02 62.39,54.39 62.26,54.25 62.26,54.25 U23.27
R_CIPRI_HIGH_REFCLK_P: length 3.6
  TOP w0.102: U23.26 62.76,54.27 62.62,54.41 62.62,54.92 62.73,55.03 62.73,55.69 63.06,56.02 R842.2 63.06,56.15 62.73,56.48 62.73,56.64 C1029.1
R_CIPRI_LOW_REFCLK_N: length 3.8
  TOP w0.102: C1028.1 60.47,56.64 60.47,56.48 60.14,56.15 R843.1 60.14,56.02 60.47,55.69 60.47,55.32 60.89,54.9 60.89,54.39 60.76,54.25 U23.30
R_CIPRI_LOW_REFCLK_P: length 3.8
  TOP w0.102: U23.29 61.26,54.27 61.12,54.41 61.12,54.99 60.7,55.41 60.7,55.69 61.03,56.02 R843.2 61.03,56.15 60.7,56.48 60.7,56.64 C1027.1
R_CLK_FPGA_100M_N: length 4.1
  TOP w0.102: R254.2 59.71,42.7 59.71,42.87 59.38,43.2 R6940.1 59.38,43.32 59.71,43.65 59.71,43.93 59.97,44.19 60.68,44.19 60.89,44.4 60.89,44.6 60.76,44.74 U23.51
R_CLK_FPGA_100M_P: length 4.1
  TOP w0.102: U23.52 61.26,44.69 61.12,44.56 61.12,44.3 60.78,43.96 60.07,43.96 59.94,43.83 59.94,43.65 60.27,43.32 R6940.2 60.27,43.2 59.94,42.87 59.94,42.7 R253.2
R_DDR4_COMP_REFCLK_N: length 3.9
  TOP w0.102: U23.63 66.76,44.73 66.89,44.6 66.89,44.31 67.15,44.05 67.67,44.05 67.84,43.88 67.84,43.65 67.51,43.32 R6943.1 67.51,43.2 67.84,42.87 67.84,42.7 R252.2
R_DDR4_COMP_REFCLK_P: length 3.9
  TOP w0.102: U23.64 67.26,44.72 67.12,44.59 67.12,44.4 67.25,44.27 67.77,44.27 68.07,43.98 68.07,43.65 68.4,43.32 R6943.2 68.4,43.2 68.07,42.87 68.07,42.7 R251.2
R_DDR4_DIMM1_REFCLK_N: length 3.2
  TOP w0.102: U23.57 63.76,44.69 63.89,44.55 63.89,44.22 63.77,44.1 63.77,43.65 63.44,43.32 R6941.1 63.44,43.2 63.77,42.87 63.77,42.7 R248.2
R_DDR4_DIMM1_REFCLK_P: length 3.2
  TOP w0.102: R247.2 64,42.7 64,42.87 64.33,43.2 R6941.2 64.33,43.32 64,43.65 64,44.01 64.12,44.13 64.12,44.53 64.26,44.67 U23.58
R_DDR4_DIMM2_REFCLK_N: length 3.4
  TOP w0.102: U23.60 65.26,44.73 65.39,44.6 65.39,44.31 65.81,43.9 65.81,43.65 65.48,43.32 R6942.1 65.48,43.2 65.81,42.87 65.81,42.7 R250.2
R_DDR4_DIMM2_REFCLK_P: length 3.4
  TOP w0.102: R249.2 66.03,42.7 66.03,42.87 66.36,43.2 R6942.2 66.36,43.32 66.03,43.65 66.03,43.99 65.62,44.41 65.62,44.59 65.76,44.72 U23.61
REFCLK_CXL_CONN_N: length 72
  L14_SIG5 w0.079: 80.88,63.2 80.86,63.2 80.84,63.18 80.47,63.18 80.01,62.72 78.47,62.72 78.03,62.28 72.76,62.28 72.29,62.75 72.1,62.75 v1(71.84,62.49) 71.56,62.77 71.28,62.77 71.17,62.88 63.13,62.88 62.42,62.17 56.85,62.17 54.1,59.42 39.91,59.42 38.74,58.24 38.74,54.94 32.37,48.57 25.92,48.57 24.8,49.69 24.8,50.16 25.12,50.49 25.51,50.49 25.6,50.57 v1(25.6,50.88)
  L14_SIG5 w0.081: v1(85.04,62.39) 84.8,62.52 84.68,62.49 84.62,62.38 84.53,62.29 84.01,62.29 83.81,62.41 83.67,62.64 83.53,62.72 83.28,62.72 82.83,63.18 82.48,63.18 82.09,62.79 81.62,62.79 81.21,63.2 80.88,63.2
REFCLK_CXL_CONN_P: length 71.8
  L14_SIG5 w0.079: 80.88,63.4 80.86,63.4 80.84,63.41 80.38,63.41 79.92,62.95 78.37,62.95 77.93,62.51 72.85,62.51 72.38,62.98 72.13,62.98 v1(71.84,63.27) 71.56,62.99 71.38,62.99 71.27,63.11 63.03,63.11 62.32,62.39 56.76,62.39 54.01,59.64 39.82,59.64 38.51,58.34 38.51,55.04 32.27,48.8 28,48.8 27.9,48.9 27.9,49 27.8,49.1 27.62,49.1 27.52,49 27.52,48.9 27.42,48.8 27.24,48.8 27.13,48.9 27.13,49.01 27.03,49.11 26.85,49.11 26.75,49.01 26.75,48.9 26.65,48.8 26.02,48.8 25.03,49.79 25.03,50.07 25.22,50.26 25.51,50.26 25.6,50.17 v1(25.6,49.86)
  L14_SIG5 w0.081: 80.88,63.4 81.29,63.4 81.7,62.98 82.01,62.98 82.4,63.37 82.91,63.37 83.36,62.92 83.59,62.92 83.82,62.79 83.95,62.55 84.06,62.49 84.45,62.49 84.46,62.5 84.51,62.59 84.48,62.71 v1(84.24,62.85)
REFCLK_CXL_EP_N: length 67.9
  L14_SIG5 w0.079: 80.93,61.58 80.91,61.58 80.9,61.59 80.23,61.59 79.76,61.13 77.71,61.13 77.58,61.26 76.95,61.26 76.67,61.54 v1(75.93,61.54) 75.65,61.26 75.35,61.26 75.06,61.55 66.51,61.55 65.54,60.58 62.04,60.58 61.16,61.45 57.19,61.45 54.44,58.7 42.81,58.7 39.66,55.55 39.66,54.71 31.74,46.8 25.69,46.8 25.6,46.89 v1(25.6,47.2)
  L14_SIG5 w0.081: 80.93,61.58 81.25,61.58 81.68,61.14 82.01,61.14 82.4,61.53 82.88,61.53 83.23,61.19 83.36,61.13 83.55,61.13 83.68,61.2 83.82,61.46 84.01,61.57 84.15,61.57 84.24,61.66 v1(84.24,61.93)
REFCLK_CXL_EP_P: length 68.2
  L14_SIG5 w0.079: 80.93,61.38 80.91,61.38 80.9,61.36 80.32,61.36 79.86,60.9 79.69,60.9 79.58,60.8 79.58,60.73 79.48,60.63 79.3,60.63 79.2,60.73 79.2,60.8 79.1,60.9 77.61,60.9 77.48,61.03 76.93,61.03 76.65,60.75 v1(75.93,60.75) 75.65,61.03 75.26,61.03 74.97,61.32 66.61,61.32 65.64,60.35 61.94,60.35 61.07,61.22 57.28,61.22 54.53,58.47 42.91,58.47 39.89,55.45 39.89,54.62 31.84,46.57 25.69,46.57 25.6,46.48 v1(25.6,46.18)
  L14_SIG5 w0.081: v1(84.24,61.01) 84.24,61.3 84.16,61.37 84.06,61.37 83.97,61.32 83.82,61.06 83.61,60.94 83.32,60.94 83.12,61.02 82.8,61.34 82.48,61.34 82.09,60.94 81.6,60.94 81.17,61.38 80.93,61.38
REFCLK_CXL_RP_N: length 18.7
  TOP w0.102: v1(11.23,67.89) 10.9,68.22 10.31,68.22 10.12,68.03 J9.B30
  L03_SIG1 w0.079: v1(9.28,54.37) 8.88,54.77 8.88,56.2 10.02,57.34 10.02,65.26 10.17,65.41 10.17,65.66 10.02,65.81 10.02,66.06 10.17,66.21 10.17,66.46 10.02,66.61 10.02,66.86 10.17,67.01 10.17,67.26 10.02,67.41 10.02,67.81 10.43,68.22 10.9,68.22 v1(11.23,67.89)
  BOTTOM w0.102: v1(9.28,54.37) R280.1
REFCLK_CXL_RP_P: length 18.8
  TOP w0.102: J9.B29 10.12,68.63 10.3,68.45 10.9,68.45 v1(11.23,68.78)
  L03_SIG1 w0.079: v1(11.23,68.78) 10.9,68.45 10.34,68.45 9.8,67.91 9.8,57.43 8.66,56.29 8.66,54.77 v1(8.26,54.37)
  BOTTOM w0.102: v1(8.26,54.37) R278.1
REFCLK_PCIE_13A_CH2_N: length 187
  L05_SIG2 w0.079: v1(22.74,32.91) 23.04,32.91 23.13,32.82 23.13,31.75 23.93,30.96 33.67,30.96 34.52,31.8 38.22,31.8 38.7,31.32 45.88,31.32 48.47,33.91 53.36,33.91 53.52,33.74 53.52,29.26 54.3,28.48 64.31,28.48 65.13,27.66 66.46,27.66 70.47,23.66 70.47,19.52 73.37,16.62 85.83,16.62 86.62,15.82 120.25,15.82 120.5,15.57 125.25,15.57 126.14,16.45 129.68,16.45 132.95,19.73 132.95,35.81 131.07,37.7 131.07,48.72 124.57,55.22 124.57,66.06 123.99,66.64 123.34,66.64
  L05_SIG2 w0.081: 123.34,66.64 123.32,66.63 123.09,66.63 122.66,66.19 122.32,66.19 121.92,66.6 121.51,66.6 121.4,66.67 121.3,66.91 121.04,67.09 120.75,67.09 120.31,67.53 119.86,67.53 119.44,67.11 119.14,67.11 118.71,67.54 118.38,67.54 118.13,67.4 117.98,67.14 117.88,67.09 117.75,67.09 117.7,67.14 v1(117.7,67.45)
  BOTTOM w0.102: R118.1 117.1,67.45 v1(117.7,67.45)
REFCLK_PCIE_13A_CH2_P: length 186.6
  L05_SIG2 w0.079: 123.32,66.43 123.34,66.41 123.89,66.41 124.34,65.97 124.34,65.57 124.24,65.47 124.14,65.47 124.03,65.37 124.03,65.19 124.14,65.09 124.24,65.09 124.34,64.99 124.34,55.13 130.84,48.63 130.84,37.61 132.72,35.72 132.72,19.83 129.58,16.68 126.04,16.68 125.16,15.8 120.59,15.8 120.34,16.05 86.72,16.05 85.92,16.84 73.47,16.84 70.7,19.62 70.7,23.75 66.56,27.89 65.23,27.89 64.41,28.71 54.39,28.71 53.75,29.35 53.75,33.84 53.45,34.14 48.38,34.14 45.79,31.55 38.79,31.55 38.31,32.03 34.42,32.03 33.57,31.18 24.02,31.18 23.9,31.3 23.9,31.41 23.98,31.49 23.98,31.61 23.82,31.77 23.71,31.77 23.63,31.69 23.52,31.69 23.36,31.84 23.36,32.82 23.45,32.91 v1(23.76,32.91)
  L05_SIG2 w0.081: 123.32,66.43 123.17,66.43 122.74,66 122.24,66 121.83,66.4 121.46,66.4 121.24,66.54 121.15,66.78 120.98,66.89 120.67,66.89 120.23,67.33 119.94,67.33 119.52,66.92 119.06,66.92 118.63,67.35 118.43,67.35 118.27,67.26 118.12,67 117.94,66.89 117.79,66.89 117.7,66.8 v1(117.7,66.53)
  BOTTOM w0.102: R117.1 117.1,66.53 v1(117.7,66.53)
REFCLK_PCIE_13A_CH5_N: length 193.4
  L05_SIG2 w0.079: v1(19.06,32.91) 19.36,32.91 19.45,33 19.45,33.79 20.05,34.39 20.78,34.39 21.52,33.65 21.52,32.31 24.03,29.81 33.21,29.81 34.7,28.32 40.91,28.32 40.98,28.4 41.54,28.4 42.05,28.91 48.01,28.91 48.59,28.33 52.86,28.33 54.87,26.32 60.06,26.32 60.85,27.1 62.9,27.1 63.38,26.62 64.14,26.62 64.65,26.11 64.65,25.55 69.66,20.54 69.66,19.05 72.86,15.85 85.05,15.85 86.05,14.86 125.55,14.86 126.43,15.74 130.03,15.74 133.67,19.38 133.67,37.77 133.02,38.41 133.02,48.99 125.46,56.55 125.46,68.52 124.87,69.11 124.73,69.11 124.67,69.05 124.53,69.05 124.44,69.15 124.44,69.28 124.5,69.34 124.5,69.48 124.4,69.58 124.26,69.58 124.2,69.52 124.06,69.52 123.96,69.62 123.96,69.75 124.02,69.82 124.02,69.95 123.9,70.07 123.51,70.07
  L05_SIG2 w0.081: 123.51,70.07 123.49,70.1 123.13,70.1 122.71,69.68 122.24,69.68 121.83,70.09 121.54,70.09 arc(121.42,70.11) 121.32,70.18 arc(121.23,70.3) 121.16,70.43 arc(121.08,70.52) 120.97,70.57 120.67,70.57 120.23,71.01 119.94,71.01 119.53,70.6 119.06,70.6 118.63,71.03 117.96,71.03 117.48,70.55 117.43,70.47 117.47,70.34 v1(117.7,70.21)
  BOTTOM w0.102: R115.2 117.81,70.85 117.61,70.52 R6917.1
REFCLK_PCIE_13A_CH5_P: length 193.3
  L05_SIG2 w0.079: v1(20.07,32.91) 19.77,32.91 19.68,33 19.68,33.7 20.15,34.17 20.68,34.17 21.29,33.56 21.29,32.22 23.93,29.58 33.12,29.58 34.6,28.1 41,28.1 41.08,28.17 41.64,28.17 42.15,28.68 47.92,28.68 48.5,28.1 52.76,28.1 54.78,26.09 60.15,26.09 60.94,26.88 62.8,26.88 63.29,26.39 64.05,26.39 64.42,26.02 64.42,25.45 69.43,20.44 69.43,18.96 72.77,15.62 84.96,15.62 85.95,14.63 125.64,14.63 126.53,15.51 130.12,15.51 133.9,19.29 133.9,37.86 133.25,38.51 133.25,49.08 125.69,56.64 125.69,68.61 124,70.3 123.51,70.3
  L05_SIG2 w0.081: v1(116.91,70.67) 117.14,70.53 117.27,70.56 117.33,70.67 117.88,71.22 118.71,71.22 119.14,70.79 119.45,70.79 119.86,71.21 120.31,71.21 120.75,70.77 120.98,70.77 arc(121.19,70.68) 121.34,70.51 arc(121.39,70.41) 121.47,70.31 arc(121.5,70.29) 121.54,70.28 121.91,70.28 122.32,69.87 122.63,69.87 123.05,70.29 123.5,70.29 123.51,70.3
  BOTTOM w0.102: v1(116.91,70.67) 116.97,70.37 116.78,70.04 R116.2
REFCLK_PCIE_EP_EDGE_N: length 66.2
  L03_SIG1 w0.079: v1(15.31,25.86) 15.31,25.56 15.4,25.47 17.43,25.47 18.31,24.59 24.14,24.59 26.6,27.05 29.34,27.05 30.51,25.88 30.51,24.18 32.04,22.66 37.48,22.66 44.21,15.93 46.6,15.93 47,16.33 55.01,16.33 60.28,11.07 60.28,10 v1(60.54,9.73)
  BOTTOM w0.102: U26.3 18.72,25.88 18.58,25.74 17.93,25.74 17.65,25.47 15.7,25.47 v1(15.31,25.86) ; v1(60.54,9.73) 60.28,9.46 60.28,9.04 60.08,8.84 60.08,7.42 60.28,7.22 60.28,6.49 60.65,6.11 J1.A14
REFCLK_PCIE_EP_EDGE_P: length 66.2
  L03_SIG1 w0.079: v1(59.78,9.73) 60.05,10 60.05,10.97 59.84,11.18 59.63,11.18 59.45,11.36 59.45,11.57 56.2,14.82 55.99,14.82 55.81,15 55.81,15.21 55.63,15.39 55.42,15.39 55.24,15.57 55.24,15.78 54.91,16.11 47.1,16.11 46.69,15.7 44.11,15.7 37.38,22.43 31.94,22.43 30.28,24.09 30.28,25.78 29.24,26.83 26.7,26.83 24.23,24.36 18.21,24.36 17.34,25.24 15.4,25.24 15.31,25.15 v1(15.31,24.84)
  BOTTOM w0.102: U26.2 18.72,25.38 18.59,25.52 18.02,25.52 17.74,25.24 15.7,25.24 v1(15.31,24.84) ; v1(59.78,9.73) 60.05,9.46 60.05,9.13 59.85,8.94 59.85,7.32 60.05,7.13 60.05,6.52 59.65,6.13 J1.A13
REFCLK_PCIE_EP_N: length 31.8
  L03_SIG1 w0.079: v1(2.1,48.85) 2.43,48.52 2.67,48.52 2.95,48.24 2.95,46.73 9.25,40.43 9.25,31.98 12.85,28.39 15.22,28.39 15.31,28.48 v1(15.31,28.78)
  BOTTOM w0.102: v1(15.31,28.78) 15.7,28.39 17.8,28.39 17.94,28.24 18.59,28.24 18.72,28.38 U26.8
REFCLK_PCIE_EP_P: length 31.8
  L03_SIG1 w0.079: v1(2.1,47.96) 2.43,48.29 2.58,48.29 2.72,48.14 2.72,46.64 9.02,40.34 9.02,31.89 12.75,28.16 15.22,28.16 15.31,28.07 v1(15.31,27.76)
  BOTTOM w0.102: v1(15.31,27.76) 15.7,28.16 17.71,28.16 17.85,28.02 18.58,28.02 18.72,27.88 U26.7
SEL_CXL_REFCLK: length 284.6
  L07_SIG3 w0.089: v1(23.1,45.27) 22.66,44.83 22.66,38.13 25.03,35.77 25.31,35.77 25.94,35.13 25.94,34.85 27.19,33.61 27.19,31.18 26.96,30.95 26.96,24.56 29.6,21.92 38.49,21.92 44.46,15.95 44.99,15.95 48.17,12.78 48.17,11.15 47.63,10.62 v1(46.49,10.62)
  L14_SIG5 w0.081: v1(251.21,43.51) 246.52,38.82 246.52,34.44 243.26,31.18 243.26,18.29 238.72,13.75 136.92,13.75 133.48,10.32 129.53,10.32 127,7.79 59.57,7.79 57.93,9.43 52.69,9.43 51.14,10.98 48.18,10.98 47.57,10.37 46.74,10.37 v1(46.49,10.62)
  BOTTOM w0.149: U27.20 22.99,45.71 23.1,45.61 v1(23.1,45.27)
SEL_PCIE_REFCLK: length 269.1
  L07_SIG3 w0.089: v1(46.49,11.38) 46.9,11.79 46.9,12.5 38.39,21.01 30.03,21.01 26.6,24.44 26.6,24.79 26.1,25.29 26.1,28.98 v1(24.77,30.3)
  L14_SIG5 w0.081: v1(251.21,44.78) 250.55,45.44 248.13,45.44 245.76,43.07 245.76,34.48 242.63,31.34 242.63,18.36 238.35,14.08 136.31,14.08 132.87,10.64 129.32,10.64 127.37,8.68 59.13,8.68 58.06,9.75 52.84,9.75 51.86,10.73 51.86,11.6 51.55,11.91 48.64,11.91 48.24,11.5 47.86,11.5 47.29,10.92 46.95,10.92 v1(46.49,11.38)
  BOTTOM w0.149: v1(24.77,30.3) 24.41,30.3 U26.20
SHARE_CLK: length 3.2
  TOP w0.203: R537.1 183.9,57.69 183.27,57.05 182.79,57.05 182.11,56.38 U61.29
SI2204_OUT0N: length 2.8
  BOTTOM w0.102: U25.13 4.96,48.21 4.82,48.07 4.19,48.07 3.74,48.51 3.32,48.51 R275.2
SI2204_OUT0P: length 2.8
  BOTTOM w0.102: U25.12 4.96,47.71 4.82,47.84 4.09,47.84 3.65,48.29 3.32,48.29 R273.2
SI2204_OUT1N: length 2.6
  BOTTOM w0.102: R277.2 5.84,52.2 5.84,51.91 6.5,51.25 6.5,50.9 6.63,50.76 U25.18
SI2204_OUT1P: length 2.6
  BOTTOM w0.102: R276.2 5.61,52.2 5.61,51.81 6.27,51.15 6.27,50.88 6.13,50.75 U25.17
SI2204_OUT2N: length 2.5
  BOTTOM w0.102: R280.2 8.88,52.2 8.88,51.88 8.5,51.49 8.5,50.9 8.63,50.76 U25.22
SI2204_OUT2P: length 2.5
  BOTTOM w0.102: U25.21 8.13,50.75 8.27,50.88 8.27,51.59 8.66,51.98 8.66,52.2 R278.2
SI52204_FS: length 3.3
  BOTTOM w0.149: U25.11 3.13,47.21 R285.1 R284.1
SI52204_OE0N: length 3.7
  BOTTOM w0.149: U25.14 4.4,48.71 3.37,49.74 R267.1 R266.1
SI52204_OE1N: length 4.6
  BOTTOM w0.149: U25.16 5.12,49.71 4.81,50.02 4.81,50.93 4.2,51.54 R268.1 R270.1
SI52204_OE2N: length 3.6
  BOTTOM w0.149: R269.1 R271.1 10.29,52.15 9.13,50.99 U25.23
SI52204_OE3N: length 2.9
  BOTTOM w0.149: R274.1 R272.1 12.25,48.71 U25.27
SI52204_PWRDNB: length 299
  L07_SIG3 w0.089: v1(46.48,12.04) 43.83,14.68 35.67,14.68 34.68,15.67 13.62,15.67 9.76,19.54 9.76,41.71 10.8,42.75 v1(10.8,44.27)
  L14_SIG5 w0.081: v1(251.21,46.05) 250.58,46.69 248.87,46.69 244.92,42.74 244.92,34.43 242.11,31.63 242.11,25.03 238.69,21.61 234.67,21.61 227.46,14.4 146.84,14.4 146.57,14.68 146.06,14.68 145.78,14.4 135.74,14.4 132.31,10.97 129.14,10.97 127.41,9.23 61.7,9.23 60.77,10.16 59.41,10.16 59.34,10.09 52.96,10.09 52.19,10.86 52.19,11.78 51.71,12.26 48.53,12.26 48.1,11.83 46.69,11.83 v1(46.48,12.04)
  BOTTOM w0.149: v1(10.8,44.27) 9.86,44.27 9.13,45 U25.2
SI52204_SA: length 5.7
  BOTTOM w0.149: R286.1 R287.1 2.99,43.2 4.55,44.76 6.2,44.76 6.63,45.18 U25.7
SI52204_SSEN: length 293.8
  L16_SIG6 w0.081: v1(12.71,43.32) 14.29,43.32 17.66,46.69 23.25,46.69 25.15,48.59 32.27,48.59 37.68,43.18 42.65,43.18 43.64,42.19 44.51,42.19 46.24,40.46 46.24,30.69 47.51,29.42 47.51,24.91 50.55,21.86 50.55,20.91 58.17,13.29 58.17,11.51 58.68,11 58.68,9.17 60.14,7.72 126.59,7.72 129.62,10.75 133.99,10.75 138.44,15.19 192.36,15.19 193.63,16.46 225.43,16.46 232.93,23.95 243.34,23.95 250.86,31.47 250.86,40.11 251.47,40.72 v1(251.47,42.24)
  BOTTOM w0.149: U25.1 9.63,45.19 9.91,44.91 10.93,44.91 11.69,44.15 R279.1 v1(12.71,43.32)
SVID_ENABLE: length 271.3
  L05_SIG2 w0.081: v1(32.18,75.65) 32.18,76.06 33.22,77.11 34.48,77.11 35.44,76.15 35.95,76.15 36.96,77.17 36.96,79.58 39.46,82.08 39.46,93.62 38.11,94.97 37.5,94.97 37.06,95.4 37.06,103.58 37.38,103.89 37.38,107.69 39.75,110.06 42.04,110.06 v1(42.55,109.55)
  L14_SIG5 w0.081: v1(42.55,109.55) 43.34,110.34 190.48,110.34 195.71,105.11 195.71,94.06 190.51,88.85 179.33,88.85 178.06,87.58 178.06,77.42 179.97,75.52 179.97,70.82 182.13,68.66 188.35,68.66 191.52,65.48 191.52,63.32 193.05,61.8 195.4,61.8 v1(195.71,62.12)
TEMP1_THERMN: length 45.5
  TOP w0.149: v1(64.76,83.14) 64.76,82.41 EU1.9
  L05_SIG2 w0.081: v1(28.18,72.65) 28.68,73.15 33.39,73.15 33.65,73.42 33.65,73.89 34.01,74.24 34.65,74.24 35.07,74.66 38.13,74.66 38.28,74.8 41.2,74.8 42.81,76.41 42.81,79.33 44.2,80.72 45.6,80.72 46.49,81.61 53.86,81.61 56.93,84.69 64.04,84.69 64.35,84.38 64.35,83.55 v1(64.76,83.14)
TEMP2_THERMN: length 122.2
  TOP w0.149: v1(93.99,35.28) 93.94,35.24 EU2.9
  L05_SIG2 w0.081: v1(68.84,29.16) 73.1,29.16 74.83,30.89 88.86,30.89 93.25,35.28 v1(93.99,35.28)
  L07_SIG3 w0.089: v1(68.84,29.16) 68.84,28.27 67.19,26.62 63.38,26.62 63.03,26.97 59.73,26.97 58.5,25.73 52.59,25.73 50.3,23.45 49.92,23.45 48.65,24.72 44.44,24.72 44.32,24.84 44.32,26.61 44.97,27.26 44.97,32.25 44.23,32.99 44.23,35.28 45.73,36.78 45.73,39.47 45.32,39.88 45.32,41.28 44.66,41.94 44.66,42.75 43.54,43.87 42.4,43.87 40.14,46.13 40.14,56.09 39,57.23 39,62.84 36.33,65.51 36.33,69.29 36.48,69.45 36.48,73.97 35.2,75.25 34.08,75.25 33.76,74.94 33.76,69.47 33.46,69.17 33.08,69.17 32.59,69.65 v1(32.18,69.65)
TOD_MASTER_CLK_125M_N: length 38.7
  L14_SIG5 w0.079: v1(61.35,41.42) 61.61,41.42 61.74,41.54 61.74,41.94 62.17,42.37 70.33,42.37 71.76,40.95 77.7,40.95 78.64,40.01 85.37,40.01 87.38,38 88.48,38 88.6,38.12 88.6,38.36 88.53,38.43 v1(88.27,38.43)
  L14_SIG5 w0.081: v1(88.27,38.43) 88.6,38.76 88.6,40.62 88.36,40.86 88.36,41.3 88.38,41.32 88.38,41.59 88.55,42 88.82,42.27 89.17,42.27 89.3,42.4 89.36,42.55 89.36,42.66 89.26,42.91 89.26,43.16 89.38,43.46 89.38,43.73 89.22,43.89 88.73,43.89 88.65,43.97 88.58,44.09 88.46,44.12 v1(88.22,43.99)
  BOTTOM w0.102: R6935.1 v1(88.27,38.43)
TOD_MASTER_CLK_125M_P: length 38.8
  L14_SIG5 w0.079: v1(89.16,38.43) 88.91,38.43 88.83,38.36 88.83,38.03 88.58,37.77 87.28,37.77 85.27,39.78 78.54,39.78 77.6,40.72 71.66,40.72 70.24,42.14 62.26,42.14 61.97,41.85 61.97,41.54 62.1,41.42 v1(62.36,41.42)
  L14_SIG5 w0.081: v1(89.02,44.45) 88.78,44.31 88.75,44.19 88.81,44.09 88.81,44.09 89.3,44.09 89.58,43.81 89.58,43.42 89.45,43.12 89.45,42.95 89.55,42.7 89.55,42.51 89.46,42.29 89.25,42.08 88.9,42.08 88.72,41.89 88.58,41.55 88.58,41.32 88.59,41.3 88.59,40.96 88.83,40.72 88.83,38.76 v1(89.16,38.43)
  BOTTOM w0.102: R6934.1 v1(89.16,38.43)
TSNS0: length 89.1
  TOP w0.254: U65.22 160.46,80.78 v1(160.54,80.85) ; U63.22 160.46,51.82 v1(160.54,51.89) ; U64.22 160.46,66.3 v1(160.54,66.37) ; v1(160.54,37.42) 160.46,37.35 U62.22
  L14_SIG5 w0.203: v1(178.19,45.99) 169.59,45.99 167.7,44.1 163.77,42.47 159.72,42.47 159.44,42.75 159.44,43.33 159.75,43.64 160.05,43.64 160.38,43.97 160.38,51.11 160.54,51.26 v1(160.54,51.89) 159.77,51.89 158.99,52.68 158.99,59.46 158.25,60.2 158.25,65.1 158.63,65.48 160.03,65.48 160.54,65.99 v1(160.54,66.37) 159.77,66.37 158.58,67.57 158.58,73.79 158.25,74.12 158.25,79.71 158.76,80.22 159.9,80.22 v1(160.54,80.85)
  L16_SIG6 w0.203: v1(160.54,37.42) 159.9,37.42 159.39,37.92 159.39,44.53 159.9,45.04 161.16,45.04 161.62,45.49 161.62,46.88 160.54,47.96 v1(160.54,51.89)
TSNS1: length 49
  TOP w0.254: U66.22 160.46,22.74 v1(160.54,22.81)
  L05_SIG2 w0.203: v1(160.54,22.81) 159.43,23.92 159.43,31.26 159.72,31.55 160.1,31.55 160.38,31.83 165.21,31.83 166.25,32.87 166.25,46.69 168.16,48.59 168.16,55.27 169.93,57.05 169.93,57.97 v1(172.94,60.98)
U38_VREF2: length 3.4
  BOTTOM w0.254: U38.7 67.45,97.48 67.32,97.61 67.32,97.98 ; 67.32,97.98 66.88,97.98 R380.2 ; 67.32,97.98 U38.8
U39_VREF2: length 3.5
  BOTTOM w0.254: U39.7 72.02,104.34 72.14,104.21 72.14,103.84 ; U39.8 72.14,103.84 ; 72.14,103.84 72.71,103.84 R385.2
U93_AGND: length 45.9
  TOP w0.254: C1220.2 59.32,77.17 59.68,77.53 Q21.3 59.18,79.32 Q21.2 57.67,79.32 57.11,79.89 57.11,81.18 v1(57.28,81.36) ; Q22.3 42.93,78.55 42.93,77.8 42.74,77.61 C1221.2
  TOP w0.305: v1(40.96,79.32) 42.16,79.32 Q22.3
  L03_SIG1 w0.203: v1(51.1,89.51) 50.71,89.51 50.53,89.33 50.53,88.44 51.67,87.3 53.7,87.3 56.75,84.25 56.75,81.89 v1(57.28,81.36)
  L05_SIG2 w0.203: v1(48.7,89.51) 48.95,89.26 48.95,87.38 47.76,86.18 45.98,86.18 45.32,85.53 45.32,83.24 44.1,82.02 42.47,82.02 40.27,79.81 40.27,79.29 40.48,79.07 40.71,79.07 v1(40.96,79.32)
  BOTTOM w0.254: v1(41.98,90.76) 41.54,90.76 ; v1(44.01,88.09) 43.57,88.09 ; v1(44.01,91.65) 43.57,91.65 ; v1(41.98,92.53) 41.54,92.53 ; v1(39.89,88.09) 39.89,87.65 ; v1(41.98,88.98) 41.54,88.98 ; v1(44.01,89.87) 43.57,89.87 ; v1(48.52,93.41) 48.52,94.11
  BOTTOM w0.381: C1149.2 51.9,90.26 C1211.2 ; C1082.2 C1210.2
  vias: v1(49.5,89.51) v1(51.95,92.85)
