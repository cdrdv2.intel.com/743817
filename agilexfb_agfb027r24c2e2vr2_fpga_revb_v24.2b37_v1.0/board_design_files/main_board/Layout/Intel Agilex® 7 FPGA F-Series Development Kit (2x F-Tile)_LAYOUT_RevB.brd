# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
U93_VDD25: length 0.6
  TOP w0.381: U93.F3 v1(47.9,87.91)
  vias: v1(39.89,88.98) v1(41.98,93.42) v1(41.98,91.65) v1(41.98,89.87) v1(44.01,90.76) v1(44.01,88.98)
U93_VDD33: length 185.1
  TOP w0.381: U93.F4 v1(49.5,87.91)
  L12_SIG4 w0.508: v2(45.98,109.17) 44.08,109.17 43.44,108.54 43.44,107.52 44.08,106.89 45.85,106.89 46.87,105.87 46.87,103.24 45.93,102.3 45.93,99.34 46.74,98.52 v2(46.74,93.41)
  BOTTOM w0.254: R6834.2 48.08,90.49 v1(48.7,91.11) ; v1(49.5,87.91) 49.59,87.91 50.3,88.62 C1082.1
  BOTTOM w0.508: D22.1 205.2,107.94 203.97,109.17 v2(45.98,109.17)
  vias: v1(41.98,88.09) v1(44.01,93.42) v1(45.85,93.41)
U94_INTVCC: length 16.5
  TOP w0.254: U94.C4 v1(198.13,55.96) ; U94.B2 v1(194.32,57.23)
  TOP w0.381: U94.E4 v3(197.49,52.02)
  L05_SIG2 w0.381: v1(198.13,55.96) 197.51,56.58 194.97,56.58 v1(194.32,57.23) 193.68,57.86 192.54,57.86 192.03,58.37 v1(192.03,59.45)
  L14_SIG5 w0.381: v3(197.49,52.02) 197.92,52.02 198.69,52.79 198.69,55.4 v1(198.13,55.96)
  BOTTOM w0.254: C1204.1 197.94,52.47 v3(197.49,52.02)
U96_AGND: length 56
  TOP w0.254: Q24.3 184.96,86.25 C1223.2 ; Q23.3 185.47,69.44 C1222.2
  TOP w0.381: Q24.3 185.55,86.83 Q24.2 ; v1(186.56,71.18) 186.56,69.94 Q23.3
  L07_SIG3 w0.203: v1(197.26,77) 196.69,77.57 196.12,77.57 195.05,76.51 195.05,74.4 192.76,72.11 186.7,72.11 186.29,71.71 186.29,71.45 v1(186.56,71.18) ; v1(197.26,78.6) 196.64,79.23 195.41,79.23 194.77,79.87 194.77,87.38 193.03,89.13 185.44,89.13 185.3,88.99 185.3,88.7 v1(185.55,88.45)
  BOTTOM w0.254: v1(195.84,88.22) 195.84,88.79 ; v1(195.84,84.09) 195.84,84.66 ; C1178.2 v1(200.71,76.15) 201.81,77.26 201.81,79.58 v1(201.16,79.58) ; v1(200.29,86.12) 200.29,86.69 ; v1(196.73,86.12) 196.73,86.69 ; v1(199.4,84.09) 199.4,84.66 ; v1(197.62,84.09) 197.62,84.66 ; v1(198.51,86.12) 198.51,86.69
  BOTTOM w0.279: 183.78,89.87 ST34.1 184.28,89.36
  BOTTOM w0.381: C1179.2 198.01,76.2 C1193.2 ; C1156.2 C1191.2
  vias: v1(197.26,79.4)
U96_VDD25: length 0.6
  TOP w0.381: U96.F3 v1(195.66,80.2)
  vias: v1(196.73,88.22) v1(196.73,84.09) v1(197.62,86.12) v1(198.51,84.09) v1(199.4,86.12) v1(201.18,86.12)
U96_VDD33: length 24.9
  TOP w0.381: U96.F4 v1(195.66,78.6)
  L14_SIG5 w0.508: v2(205.2,103.96) 205.92,103.24 205.92,88.84 v1(201.18,84.09)
  BOTTOM w0.254: C1156.1 196.37,77.8 195.66,78.51 v1(195.66,78.6) ; v1(198.86,79.4) 198.13,80.14 R6828.2
  vias: v1(195.84,85.23) v1(201.16,82.25) v1(201.16,81.36)
USB_DISABLEN: length 61.6
  TOP w0.149: U5.J14 26.68,70.15 26.68,68.15 v1(26.18,67.65)
  L07_SIG3 w0.089: v1(17.91,107.58) 17.47,107.14 15.67,107.14 8.47,99.94 v1(8.47,99.22) 9.48,98.21 9.48,91.6 10.07,91.01 10.07,87.61 13.72,83.95 13.72,81.99 14.23,81.49 14.23,77.93 14.74,77.42 14.74,76.15 17.74,73.15 19.38,73.15 19.68,72.85 19.68,72.45 19.98,72.15 20.48,72.15 20.68,71.95 20.68,71.35 20.98,71.05 21.48,71.05 22.38,70.15 25.44,70.15 25.66,69.93 25.66,68.17 v1(26.18,67.65)
  L16_SIG6 w0.081: v1(17.91,107.58) 17.98,107.58 18.68,108.28 19.25,108.28 v1(19.95,107.58)
USB_MAX_JTAG_SEL: length 232.7
  L07_SIG3 w0.089: v1(27.18,69.65) 27.18,70.06 26.68,70.56 26.68,71.85 26.98,72.15 27.3,72.15 27.56,72.41 27.56,72.9 27.3,73.15 26.98,73.15 26.68,73.45 26.68,74.85 26.98,75.15 27.41,75.15 27.68,75.42 27.68,75.75 28.08,76.15 28.42,76.15 28.68,76.41 28.68,76.75 29.08,77.15 29.38,77.15 29.75,77.53 29.75,85.88 28.28,87.35 28.28,94.75 27.18,95.85 26.08,95.85 25.78,96.15 24.58,96.15 v1(24.39,96.34) 24.97,96.92 26.03,96.92 26.6,97.49 26.6,98.77 27.11,99.28 27.72,99.28 28.55,100.1 28.55,105.02 29.91,106.38 34.3,106.38 35.42,107.51 36.22,107.51 36.49,107.77 37.22,107.77 37.47,107.52 37.47,107.14 37.85,106.76 38.43,106.76 38.78,107.11 38.78,108.15 39.28,108.65 40.78,108.65 41.08,108.35 46.94,108.35 47.51,108.92 50.96,108.92 51.87,108 52.93,108 54.05,109.12 72.69,109.12 73.18,109.62 82.22,109.62 82.48,109.35 87.18,109.35 87.45,109.62 100.63,109.62 100.87,109.38 102.1,109.38 102.34,109.62 118.99,109.62 119.36,109.25 129.64,109.25 130,109.62 140.03,109.62 140.65,108.99 194.49,108.99 194.95,108.54 198.91,108.54 202.19,105.26 202.19,102.85 203.68,101.36 v1(204.22,101.36)
  BOTTOM w0.149: R87.2 v1(204.22,101.36) ; v1(24.39,96.34) 24.7,96.04 U6.15
USB_MAX_TCK: length 20.9
  L05_SIG2 w0.081: v1(27.18,81.65) 26.77,81.65 26.27,82.15 26.09,82.15 25.68,82.56 25.68,82.77 25.28,83.16 25.08,83.16 24.7,83.54 24.7,83.72 24.26,84.15 23.96,84.15 22.77,85.35 22.77,89.03 22.97,89.23 22.97,90.97 22.87,91.07 22.87,91.5 23.12,91.76 23.12,94.49 25.36,96.73 25.36,96.93 v1(26.04,97.61)
  BOTTOM w0.149: U6.2 26.35,97.31 v1(26.04,97.61)
USB_MAX_TDI: length 20.2
  L05_SIG2 w0.081: v1(28.18,83.65) 27.67,83.15 26.98,83.15 26.68,83.45 26.68,83.9 26.52,84.05 25.99,84.05 25.77,84.28 25.28,84.28 25.03,84.53 25.03,85.02 24.65,85.4 24.65,85.63 24.36,85.91 24.36,89.63 24.23,89.97 24.23,92.16 23.93,92.45 23.93,93.17 24.24,93.47 25.2,93.47 25.58,93.86 25.58,94.34 26.58,95.33 v1(28.71,95.33)
  BOTTOM w0.149: U6.7 28.4,95.64 v1(28.71,95.33)
USB_MAX_TDO: length 17.2
  L05_SIG2 w0.081: v1(27.18,83.65) 27.59,83.65 27.72,83.78 27.72,84.89 27.57,85.04 26.93,85.04 26.68,85.3 26.55,85.3 26.36,85.1 26.36,84.98 26.59,84.75 26.59,84.57 26.42,84.41 26.17,84.41 25.91,84.66 25.53,84.66 25.41,84.79 25.41,85.09 25.66,85.34 25.66,85.68 25.15,86.19 25.15,89.86 24.92,90.09 24.92,92.43 25.16,92.66 25.51,92.66 25.89,93.05 26.05,93.05 v1(27.06,94.06)
  BOTTOM w0.149: v1(27.06,94.06) 26.75,94.37 U6.10
USB_MAX_TMS: length 20.8
  L05_SIG2 w0.081: v1(27.69,97.61) 26.15,96.07 25.74,96.07 24.62,94.95 24.62,94.34 23.51,93.23 23.51,91.96 23.73,91.75 23.73,90.81 23.4,90.48 23.4,89.09 23.68,88.81 23.68,85.43 24.01,85.09 24.39,85.09 24.65,84.84 24.65,84.43 25.05,84.03 25.41,84.03 25.63,83.8 25.63,83.5 26.03,83.1 26.33,83.1 26.78,82.65 v1(27.18,82.65)
  BOTTOM w0.149: U6.5 27.84,97.01 27.69,97.16 v1(27.69,97.61)
USB_T_CLK: length 34.5
  TOP w0.149: R454.1 11.69,89.23 v1(11.69,88.09)
  L12_SIG4 w0.089: v1(21.18,75.65) 21.8,76.28 21.8,77.8 21.34,78.26 20.96,78.26 20.68,78.55 20.68,78.93 20.45,79.15 20.07,79.15 19.74,79.48 19.74,79.91 19.4,80.25 18.89,80.25 17.37,81.77 17.37,83.99 17.88,84.5 17.88,86.25 18.78,87.15 18.78,87.76 18.37,88.17 18.37,88.52 17.28,89.61 14.23,89.61 13.63,89.01 13.63,87.59 13.09,87.05 13.09,86.06 12.96,85.93 12.71,85.93 12.58,86.06 12.58,87.45 12.45,87.58 12.27,87.58 12.15,87.45 12.15,85.3 12.02,85.17 11.82,85.17 11.69,85.3 v1(11.69,88.09)
VOUT0_CFG: length 3.7
  TOP w0.203: U61.25 184.26,54.36
  TOP w0.267: 184.26,54.36 185.69,55.79 185.69,56.05 186.23,56.59 R552.1
VOUT1_CFG: length 4
  TOP w0.203: U61.26 183.96,54.76 184.26,55.07
  TOP w0.267: 184.26,55.07 185.05,55.85 185.05,56.2 186.33,57.48 R553.1
VSENSE0+: length 75.3
  TOP w0.203: U61.7 178.91,48.68 v1(178.82,48.59)
  L12_SIG4 w0.203: v1(131.39,72.72) 132.28,73.61 133.61,73.61 134.78,72.44 147.29,72.44 147.94,71.79 147.94,67.53 149.9,65.57 168.53,65.57 170.33,63.76 171.05,63.76 v1(171.33,64.04)
  L16_SIG6 w0.203: v1(171.33,64.04) 171.05,63.76 170.63,63.76 170.23,63.37 170.23,49.72 171.08,48.87 175.35,48.87 176.62,47.61 178.26,47.61 178.54,47.89 178.54,48.31 v1(178.82,48.59)
  BOTTOM w0.254: R532.1 v1(131.39,72.72)
VSENSE0-: length 74.3
  TOP w0.203: U61.6 178.51,49.57 177.93,48.99 v1(177.93,48.59)
  L12_SIG4 w0.203: v1(131.39,71.83) 131.96,72.41 131.96,72.83 132.41,73.28 133.47,73.28 134.64,72.11 147.15,72.11 147.61,71.66 147.61,67.39 149.76,65.24 168.39,65.24 170.2,63.43 171.05,63.43 v1(171.33,63.15)
  L16_SIG6 w0.203: v1(177.93,48.59) 178.21,48.31 178.21,48.03 178.12,47.94 176.76,47.94 175.49,49.2 171.22,49.2 170.56,49.86 170.56,63.23 170.76,63.43 171.05,63.43 v1(171.33,63.15)
  BOTTOM w0.254: R541.2 v1(131.39,71.83)
ZL30733_1V8: length 5.3
  TOP w0.381: C985.2 68.71,65.15 68,65.86 C983.2 R745.2
  vias: v1(55.38,43.51) v1(55.58,44.02) v1(59.44,60.15) v1(60.71,60.15) v3(67.19,63.78) v3(68.71,63.78)
ZL_GPIO3_AC3: length 49.5
  TOP w0.149: v1(57.09,46.18) R261.2 57.56,46.73 U23.46 ; v1(35.34,69.22) 35.06,69.5 35.06,74.63 34.54,75.15 33.9,75.15 33.68,75.37 33.68,77.15 U5.B7
  L05_SIG2 w0.081: v1(35.34,69.22) 35.9,68.66 38.38,68.66 39.79,67.24 40.71,67.24 41.44,66.5 41.44,63.79 42.83,62.41 43.62,62.41 44.66,61.36 44.66,60.05 46.48,58.23 48.52,58.23 50.09,56.66 51.8,56.66 54.54,53.91 54.54,49.21 57.09,46.66 v1(57.09,46.18)
ZL_OSC_CLK: length 2.1
  TOP w0.149: R240.2 57.35,49.99 58.27,49.99 58.52,50.23 U23.39
N93250:
  vias: v1(50.07,99.14) v1(50.09,98.57) v1(50.09,95.37) v1(50.07,94.87)
N96922:
  vias: v1(176.74,99.98)
N133159: length 2
  BOTTOM w0.149: R200.1 77.49,25.21 C293.1 78.39,25.31 R202.1
N140679: length 1.5
  BOTTOM w0.254: R222.1 32.46,44.37 32.14,44.05 U21.5
N226751:
  vias: v1(244.1,49.86)
N226787:
  vias: v1(244.1,51.13)
N226815:
  vias: v1(244.1,52.4)
N226847:
  vias: v1(244.1,53.67)
N227760: length 38.2
  L14_SIG5 w0.081: v1(85.04,72.51) 85.04,72.9 85.52,73.38 85.91,73.38 86.42,73.89 86.82,73.89 87.24,73.48 87.51,73.48 88.03,72.95 88.52,72.95 88.85,72.63 89.26,72.63 90.4,71.49 90.85,71.49 91.22,71.12 91.47,71.12 91.78,70.81 91.78,70.02 92,69.8 92.3,69.8 92.59,69.51 92.59,66.29 92.37,66.07 92.05,66.07 91.58,65.59 91.19,65.59 90.77,65.17 90.39,65.17 89.95,64.72 89.63,64.72 89.08,64.18 88.8,64.18 88.36,63.73 87.99,63.73 87.47,63.21 87.26,63.21 86.93,62.88 86.51,62.88 86.02,63.37 85.61,63.37 85.22,63.77 84.86,63.77 84.49,63.4 84.04,63.4 83.68,63.76 83.34,63.76 82.76,64.35 82.5,64.35 82.19,64.66 81.56,64.66 81.2,64.3 80.85,64.3 80.53,64.62 79.69,64.62 78.81,63.74 76.54,63.74 76.31,63.5 73.11,63.5 72.7,63.91 72.44,63.91 v1(71.89,64.46)
N465030:
  vias: v1(82.65,71.13)
N586023:
  vias: v1(117.7,69.29)
N586027:
  vias: v1(116.91,68.83)
N586139:
  vias: v1(85.04,55.95)
N586147:
  vias: v1(84.24,55.49)
N587132: length 1.9
  BOTTOM w0.149: R125.1 55.6,104.35 U12.1
N587200: length 1.7
  BOTTOM w0.149: U12.4 59.43,105.76 R127.1
N614425: length 7.4
  TOP w0.149: R7.1 R5.1 53.65,10.5 J1.B9
N615469: length 7.1
  TOP w0.17: J1.B30 76.65,8.33 R774.2
N615809: length 1
  TOP w0.17: C16.2 R13.1
N615921: length 0.9
  BOTTOM w0.17: C17.2 R14.1
N616003: length 1
  TOP w0.17: C19.2 R15.1
N616075: length 1
  BOTTOM w0.17: C21.2 R16.1
N616149: length 0.9
  BOTTOM w0.17: R17.1 C22.2
N616261: length 1.4
  TOP w0.17: C23.2 R18.1
N616323: length 1
  BOTTOM w0.17: R19.1 C25.2
N616411: length 1
  TOP w0.17: C27.2 R20.1
N616501: length 1
  TOP w0.17: R21.1 C28.2
N616597: length 1
  TOP w0.17: C29.2 R22.1
N616647: length 1.3
  TOP w0.17: C30.2 R23.1
N617181: length 5.1
  BOTTOM w0.149: U2.3 34.97,24.36 R24.1 33.73,25.16 33.56,25.33 33.56,26.46 R30.2
N617185: length 3
  BOTTOM w0.149: R31.2 R25.1 36.06,23.26 U2.2
N617189: length 3.1
  BOTTOM w0.149: U2.1 35.47,21.82 35,21.35 R29.2 R26.1
N617309: length 4.7
  BOTTOM w0.149: U2.7 42.65,23.09 42.93,22.81 42.93,21.67 43.12,21.48 R28.2 43.57,21.03 43.38,20.84 R27.1
N631911: length 5.5
  BOTTOM w0.149: Y1.3 9.85,40.65 9.28,41.23 9.28,43.07 C410.1 9.21,43.55 8.63,44.13 U25.3
N632203: length 5.1
  BOTTOM w0.254: U25.29 11.03,47.71 ; U25.19 7.13,51.23
  BOTTOM w0.305: v1(12.26,47.7) 12.26,47.71 11.03,47.71 ; 7.13,51.23 7.13,52.48 v1(7.25,52.59)
  BOTTOM w0.381: v1(12.26,54.69) v1(12.26,53.67)
N632477: length 3.8
  BOTTOM w0.149: U25.4 8.13,44.91 8.24,44.8 8.24,43.22 C411.1 8.55,42.9 Y1.1
N632667: length 8.6
  BOTTOM w0.254: 4.5,49.46 4.75,49.21 U25.15 ; 10.14,50.75 9.73,50.75 9.63,50.65 U25.24
  BOTTOM w0.305: 4.5,49.46 4.07,49.89 4.07,50.62 3.18,51.51 v1(2.99,51.51) ; v1(12.26,50.75) 10.14,50.75
  BOTTOM w0.381: v1(12.26,50.75) v1(12.26,51.64) FB40.2
N633145: length 3
  BOTTOM w0.149: U25.10 4.41,46.71 R282.2
N633209: length 3.1
  BOTTOM w0.149: U25.9 4.8,46.21 R283.2
N634717:
  vias: v1(244.1,46.05)
N634773:
  vias: v1(244.1,44.78)
N634823:
  vias: v1(244.1,43.51)
N744808: length 1.5
  BOTTOM w0.254: U20.5 41.27,30.8 41.59,31.12 R213.1
N748119: length 1.1
  BOTTOM w0.149: R203.1 210.26,22.11 C303.1
N754746: length 1.6
  BOTTOM w0.149: U28.6 58.38,12.64 R327.2
N754798: length 1.5
  BOTTOM w0.149: U28.4 57.15,14.63 R328.2
N754986: length 1.5
  BOTTOM w0.149: U31.6 51.52,12.64 R332.2
N755042: length 1.8
  BOTTOM w0.149: R333.2 49.6,14.11 49.78,13.94 U31.4
N756713: length 6.6
  TOP w0.149: D8.C 242.7,105.37 v1(242.7,104.35)
  BOTTOM w0.149: v1(242.7,104.35) 242.28,103.92 Q7.3
N756717: length 3.2
  TOP w0.149: v1(240.61,105.11) 240.61,105.68 241.69,106.76 242.28,106.76 D8.A
N756805: length 52.6
  TOP w0.149: v1(38.2,107.27) D2.C
  L07_SIG3 w0.089: v1(38.2,107.27) 36.73,108.75 35.27,108.75 34.81,108.28 34.81,107.52 34.3,107.01 32.06,107.01 31.68,107.39 30.23,107.39 28.19,105.35 16.48,105.35 13.6,102.47 13.6,100.66 13.98,100.28 13.98,96.98 15.28,95.68 15.28,88.25 15.98,87.55 15.98,85.07 v1(16.52,84.53)
  BOTTOM w0.149: R395.2 41.54,107.34 40.82,106.63 38.84,106.63 v1(38.2,107.27)
N756817: length 1.2
  BOTTOM w0.149: R394.1 38.91,109.32 38.72,109.32 v1(38.49,109.55)
N756925: length 6.8
  TOP w0.149: v1(239.02,105.55) 239.15,105.43 D9.C
  BOTTOM w0.149: v1(239.02,105.55) 236.93,105.55 235.3,103.92 Q12.3
N756929: length 0.6
  BOTTOM w0.149: R405.1 v1(239.15,107.27)
N757065: length 7.2
  BOTTOM w0.149: v1(236.05,105.55) 233.75,105.55 233.31,105.11 232.42,105.11 231.23,103.92 Q13.3
N757069:
  vias: v1(236.05,107.25)
N757157: length 2.1
  TOP w0.149: v1(37.6,109.55) 36.94,109.55 D5.A
  BOTTOM w0.149: v1(37.6,109.55) 38.3,108.85 R399.1
N757219: length 7.8
  BOTTOM w0.149: v1(232.75,105.55) 231.72,105.55 231.15,104.98 228.71,104.98 228.49,104.76 226.36,104.76 225.69,104.09 Q14.3
N757223:
  vias: v1(232.75,107.25)
N757357: length 1
  BOTTOM w0.149: C482.2 211.97,104.66 R418.1
N757409: length 42.5
  TOP w0.149: v1(33.92,107.56) D12.C
  L07_SIG3 w0.089: v1(13.6,86.95) 13.78,87.13 13.78,87.23 14.28,87.73 14.28,96.17 13.67,96.78 13.67,99.9 13.29,100.28 13.29,103.07 15.9,105.68 27.63,105.68 29.73,107.77 33.7,107.77 v1(33.92,107.56)
  BOTTOM w0.149: Q15.3 13.09,86.44 v1(13.6,86.95)
N757413: length 7.8
  TOP w0.149: v1(33.97,109.26) D12.A
  L05_SIG2 w0.081: v1(33.97,109.26) 32.48,109.26 30.87,107.65 29.85,107.65 29.15,106.95 v1(27.95,106.95)
N757643: length 1.1
  BOTTOM w0.149: R425.1 216.22,104.51 C483.2
N757741: length 1.1
  BOTTOM w0.149: C485.2 220.54,104.51 R427.1
N757839: length 1.1
  BOTTOM w0.149: R428.1 223.84,105.55 C486.2
N757891:
  vias: v1(252.77,101.43) v1(252.77,95.43) v1(252.77,92.43) v1(252.77,89.43) v1(252.77,86.43) v1(252.77,83.43) v1(252.77,80.43) v1(252.77,77.43) v1(252.77,74.43) v1(252.77,71.43) v1(252.77,68.43) v1(252.77,60.7) v1(252.77,56.43) v1(252.77,53.52) v1(252.77,50.52) v1(252.77,47.43) v1(252.77,44.43) v1(252.77,41.43) v1(252.77,38.43) v1(252.77,35.43) v1(252.77,32.43) v1(252.77,26.43) v1(252.77,22.41) v1(252.77,19.41)
N760346: length 2.9
  TOP w0.254: EU1.3 64.3,77.9 C450.2 64.1,76.69 R338.1
N760350: length 3
  TOP w0.254: R337.1 63.21,76.69 C450.1 63.21,77.89 63.8,78.47 EU1.2
N760466: length 3.1
  TOP w0.254: EU1.5 65.3,78.6 66.01,77.89 C452.2 66.01,76.82 R341.1
N760470: length 2.9
  TOP w0.254: R339.1 65.12,76.69 C452.1 64.8,78.03 EU1.4
N760588: length 2.9
  TOP w0.254: EU1.7 65.8,82.12 66.59,81.33 C453.2 67.98,81.33 R344.1
N760592: length 2.9
  TOP w0.254: R342.1 67.98,80.44 C453.1 66.55,80.44 65.8,79.68 EU1.6
N760654: length 2
  TOP w0.149: v1(64.75,84.18) 64.3,83.73 EU1.10
N899386: length 1.9
  TOP w0.149: R93.1 14.39,73.23 U7.3
N972002: length 2.9
  TOP w0.254: EU2.3 88.95,35.74 C457.2 87.74,35.93 R347.1
N972006: length 3
  TOP w0.254: R346.1 87.74,36.82 C457.1 88.94,36.82 89.52,36.24 EU2.2
N972122: length 3.1
  TOP w0.254: R349.1 87.87,34.03 C458.2 88.93,34.03 89.65,34.74 EU2.5
N972126: length 2.9
  TOP w0.254: EU2.4 89.08,35.24 C458.1 87.74,34.92 R348.1
N972244: length 2.9
  TOP w0.254: R353.1 92.37,32.06 C459.2 92.37,33.44 93.17,34.24 EU2.7
N972248: length 2.9
  TOP w0.254: EU2.6 90.73,34.24 91.49,33.48 C459.1 91.49,32.06 R351.1
N972310: length 2
  TOP w0.149: v1(95.23,35.28) 94.78,35.74 EU2.10
N1009139: length 2.8
  BOTTOM w0.149: R450.2 6.28,95.09 v1(4.58,95.09)
N1009759: length 1.7
  TOP w0.149: U49.13 11.61,90.29 R454.2
N1028872: length 2.1
  BOTTOM w0.149: R429.1 R435.2 221.55,57.53 v1(221.04,58.04)
N1028876: length 2
  BOTTOM w0.149: v1(221.04,59.31) 221.3,59.57 R436.2 R430.1
N1028880: length 1.9
  BOTTOM w0.149: v1(221.04,60.58) R437.2 R431.1
N1029030:
  vias: v1(224.94,59.31)
N1063403:
  vias: v1(129.36,26.56)
N1070944:
  vias: v1(117.16,26.56)
N1083557:
  vias: v1(104.97,26.56)
N1083575:
  vias: v1(92.78,26.56)
N1137042: length 5.7
  BOTTOM w0.149: R439.1 R443.2 31.53,30.81 30.89,31.45 U46.3
N1137046: length 6.9
  BOTTOM w0.149: R440.1 R444.2 33.73,34.37 29.98,34.37 29.62,34.01 U46.2
N1137050: length 3.6
  BOTTOM w0.149: R445.2 R441.1 27.88,34.69 28.35,34.22 U46.1
N1137200: length 2.4
  BOTTOM w0.149: U46.7 29.62,25.9 R442.1
N1229237: length 16.3
  BOTTOM w0.254: U51.4 218.31,50.44 ; 208.17,49.87 U52.3
  BOTTOM w0.381: 218.31,50.44 218.31,48.08 217.56,47.33 209.23,47.33 208.17,48.39 208.17,49.87
N1229245: length 1.7
  TOP w0.149: R459.1 230.18,44.89 229.92,44.89
  TOP w0.152: 229.92,44.89 U50.21
N1234667: length 2.2
  TOP w0.254: Q16.4 220.35,76.53 220.61,76.79 R467.1
N1234809: length 3.3
  TOP w0.305: v1(220.61,79.01) 220.2,79.01 220.03,78.83 U53.1
  BOTTOM w0.254: C609.1 219.43,79.01 v1(220.61,79.01)
N1235245: length 4
  TOP w0.152: v1(215.65,79.83) 215.65,80.5 215.37,80.78 U53.5
  BOTTOM w0.149: R468.2 213.56,80.09 Q17.3
N1235299: length 3.2
  TOP w0.381: v1(211.08,79.9) 212.03,79.9 212.27,80.13 U53.6
N1235337: length 1.8
  BOTTOM w0.149: R469.1 219.21,81.04 Q17.1
N1235973: length 1.7
  TOP w0.152: U54.21 224.46,79.47 R476.1
N1428757: length 17.2
  TOP w0.381: v1(36.84,103.96) Q18.4
  L16_SIG6 w0.254: v1(36.84,103.96) 36.84,105.11 35.95,106 35.06,106 34.81,106.25 32.39,106.25 31.82,105.68 v1(31.38,105.68) 31.43,105.73 31.43,107.11 31.07,107.47 29.85,107.47 28.76,106.38 24.79,106.38 v1(24.58,106.59)
N1428777: length 3.7
  BOTTOM w0.254: U60.3 24.58,109.49 24.71,109.62 R522.1 R524.2 R528.2
N1477892: length 3.4
  TOP w0.254: U74.3 R708.1 R706.1 C920.1
N1477908: length 1.9
  TOP w0.254: U74.6 201.02,35.4 C925.1
N1532849: length 3.7
  TOP w0.254: C651.1 R497.1 R500.1 33.98,101.04 33.6,100.66 U56.3
N1532865: length 3.9
  TOP w0.254: C663.1 31.22,104.06 29.76,102.6 29.76,102.57 29.73,102.54 U56.6
N1534404: length 5.4
  BOTTOM w0.254: R498.1 32.39,101.93 R501.1 U57.3
  BOTTOM w0.381: C655.1 R498.1
N1534420: length 1.6
  BOTTOM w0.254: U57.6 37.35,103.55 37.35,104.39 C664.1
N1535970: length 3.8
  BOTTOM w0.254: C659.1 R499.1 18.99,63.83 R502.1 U58.3
N1535986: length 1.3
  BOTTOM w0.254: U58.6 13.22,61.5 C665.1
N1551329: length 3.4
  TOP w0.254: C928.1 R715.1 R719.1 U75.3
N1551333: length 3.5
  TOP w0.254: C929.1 R716.1 R720.1 144.41,16.97 144.28,17.1 U76.3
N1551337: length 1.3
  TOP w0.254: C936.1 192.53,89.94 U75.6
N1551419: length 1.3
  TOP w0.254: U76.6 146.63,21.03 C937.1
N1551653: length 1.5
  TOP w0.254: v1(194.06,91.78) U75.7
N1551693: length 0.9
  TOP w0.254: v1(144.78,21.92) U76.7
N1553121: length 4.5
  TOP w0.254: R721.1 C962.1 R723.1 192,103.01 191.89,102.9 U77.1
N1553157: length 4.5
  TOP w0.254: U78.1 66.38,17.11 66.49,17 R724.1 C963.1 R722.1
N1703298: length 5.6
  TOP w0.102: U23.12 68.26,51.23 68.4,51.37 68.89,51.37 69.45,51.93 69.45,52.69 69.55,52.79 69.69,52.79 R237.1 70.35,52.79 70.62,52.79 70.75,52.66 70.75,52.58 R228.2 71,52.58 71,52.66 71.13,52.79 71.4,52.79 C1008.2
N1703311: length 5.6
  TOP w0.102: U23.13 68.26,51.73 68.4,51.6 68.8,51.6 69.22,52.02 69.22,52.78 69.45,53.02 69.69,53.02 R234.1 70.35,53.02 70.62,53.02 70.75,53.14 70.75,53.22 R229.2 71,53.22 71,53.14 71.13,53.02 71.4,53.02 C1009.2
N1703324: length 5.2
  TOP w0.102: U23.10 68.27,50.23 68.41,50.37 68.62,50.37 68.92,50.07 68.92,49.79 69.46,49.25 69.67,49.25 R235.1 70.35,49.23 70.62,49.23 70.75,49.1 70.75,49.03 R230.2 71,49.03 71,49.1 71.13,49.23 71.4,49.23 C1010.2
N1703337: length 5.2
  TOP w0.102: U23.11 68.28,50.73 68.41,50.6 68.71,50.6 69.15,50.16 69.15,49.89 69.55,49.48 69.71,49.48 R236.1 70.35,49.46 70.62,49.46 70.75,49.59 70.75,49.66 R231.2 71,49.66 71,49.59 71.13,49.46 71.4,49.46 C1011.2
N1703797:
  vias: v1(70.87,54.24) v1(70.87,51.57) v1(70.87,50.68) v1(70.87,48.08)
N1706943: length 2.1
  TOP w0.149: R238.1 59.54,61.26 U24.1
N1707033: length 8.3
  TOP w0.149: U24.3 54.83,55.53 54.83,51.62 R240.1
N1707243: length 1.1
  TOP w0.149: v1(58.05,49.48) 58.3,49.23 U23.41
N1762439: length 3.2
  TOP w0.149: R241.1 R256.2 57.82,54.18 58.77,53.23 U23.33
N1762443: length 2.2
  TOP w0.149: R257.2 57.92,53.29 58.48,52.73 U23.34
N1918614: length 1.8
  TOP w0.149: R107.1 73.44,75.14 73.32,75.26
N1965215: length 4.2
  TOP w0.267: U65.34 159.48,86.78 159.77,87.07 160.09,87.07 R591.2 R594.2
N1965219: length 3.9
  TOP w0.267: R592.2 R595.2 160.66,86.44 160,85.78 U65.32
N1965255: length 12
  TOP w0.229: 159.39,84.78 U65.30
  TOP w0.305: 160.73,84.6 160.54,84.78 159.39,84.78
  TOP w0.381: R593.2 162.31,84.79 161.81,84.79 161.61,84.6 C764.1 160.73,84.6 ; R593.2 162.38,85.23 R595.1 ; R593.2 163.46,85.04 163.84,85.42 163.84,88.85 163.33,89.36 R594.1
N1965465: length 2.4
  TOP w0.267: v1(159.9,87.71) 159.77,87.71 159.34,87.28 U65.35
  BOTTOM w0.267: v1(159.9,87.71) 160.47,87.71 R598.1
N1965499: length 1.9
  TOP w0.267: U65.36 159.08,87.78 159.9,88.6 v1(159.9,89.11)
N1980839: length 4.3
  TOP w0.267: U64.34 159.48,72.3 159.77,72.6 160.09,72.6 R583.2 R586.2
N1980841: length 3.9
  TOP w0.267: U64.32 160,71.3 160.66,71.96 R587.2 R584.2
N1980849: length 12
  TOP w0.229: 159.39,70.3 U64.30
  TOP w0.305: 159.39,70.3 160.54,70.3 160.73,70.12
  TOP w0.381: R586.1 163.2,75.01 163.84,74.37 163.84,70.94 163.46,70.56 R585.2 ; R587.1 162.38,70.75 R585.2 ; R585.2 162.31,70.31 161.81,70.31 161.61,70.12 C746.1 160.73,70.12
N1980893: length 2.4
  TOP w0.267: U64.35 159.34,72.8 159.77,73.23 v1(159.9,73.23)
  BOTTOM w0.267: v1(159.9,73.23) 160.47,73.23 R590.1
N1980897: length 1.9
  TOP w0.267: v1(159.9,74.63) 159.9,74.12 159.08,73.3 U64.36
N1982757: length 4.3
  TOP w0.267: R578.2 R575.2 160.09,58.12 159.77,58.12 159.48,57.82 U63.34
N1982759: length 3.9
  TOP w0.267: R576.2 R579.2 160.66,57.48 160,56.82 U63.32
N1982767: length 12
  TOP w0.229: 159.39,55.82 U63.30
  TOP w0.305: 159.39,55.82 160.54,55.82 160.73,55.64
  TOP w0.381: R577.2 162.38,56.28 R579.1 ; R577.2 162.31,55.83 161.81,55.83 161.61,55.64 C728.1 160.73,55.64 ; R577.2 163.46,56.09 163.84,56.47 163.84,59.9 163.2,60.53 R578.1
N1982811: length 2.4
  TOP w0.267: U63.35 159.34,58.32 159.77,58.75 v1(159.9,58.75)
  BOTTOM w0.267: R582.1 160.47,58.75 v1(159.9,58.75)
N1982815: length 1.9
  TOP w0.267: U63.36 159.08,58.82 159.9,59.64 v1(159.9,60.15)
N1984675: length 4.3
  TOP w0.267: R570.2 R567.2 160.09,43.64 159.77,43.64 159.48,43.35 U62.34
N1984677: length 3.9
  TOP w0.267: R568.2 R571.2 160.66,43 160,42.35 U62.32
N1984685: length 12
  TOP w0.229: 159.39,41.35 U62.30
  TOP w0.305: 160.73,41.16 160.54,41.35 159.39,41.35
  TOP w0.381: 160.73,41.16 C710.1 161.61,41.16 161.81,41.35 162.31,41.35 R569.2 ; R571.1 162.38,41.8 R569.2 ; R569.2 163.46,41.61 163.84,41.99 163.84,45.42 163.2,46.05 R570.1
N1984729: length 2.4
  TOP w0.267: U62.35 159.34,43.85 159.77,44.27 v1(159.9,44.27)
  BOTTOM w0.267: v1(159.9,44.27) 160.47,44.27 R574.1
N1984733: length 1.9
  TOP w0.267: v1(159.9,45.67) 159.9,45.16 159.08,44.35 U62.36
N1987677: length 3
  TOP w0.203: v1(174.76,54.94) 175.24,54.94 175.42,54.76 U61.44
  BOTTOM w0.267: v1(174.76,54.94) 173.17,54.94 R546.2
N1989130: length 4.1
  TOP w0.254: R544.2 172.97,53.62 173.93,53.62 174.38,53.16 U61.48
N1989134: length 3.1
  TOP w0.203: v1(174.63,53.93) 174.81,53.75 174.94,53.75 175.12,53.56 U61.47
  BOTTOM w0.254: R545.2 173.17,53.93 v1(174.63,53.93)
N1993333: length 6.4
  TOP w0.203: 180.91,56.16 U61.32
  TOP w0.267: 181.05,57.7 180.91,57.56 180.91,56.16
  TOP w0.381: R531.2 182.08,60.17 C693.1 181.93,59.58 181.57,59.22 181.57,58.22 181.05,57.7
N1995084: length 2.8
  TOP w0.203: U61.21 185.43,52.76
  TOP w0.267: R542.1 186.11,52.76 185.43,52.76
N1995190: length 4.3
  TOP w0.203: 179.31,47.91 U61.8
  TOP w0.267: 179.31,47.91 178.28,46.88 R548.1
N1995248: length 3
  TOP w0.203: U61.22 185.24,53.16
  TOP w0.267: 185.24,53.16 186,53.93 R554.2
N1995256: length 4.6
  TOP w0.203: 183.25,55.66 U61.27
  TOP w0.267: 183.25,55.66 183.62,55.66 186.33,58.37 R555.2
N1995356: length 5.1
  TOP w0.203: 180.91,48.73 U61.12
  TOP w0.267: 180.91,48.73 181.87,47.77 R556.1 R558.2
N1995388: length 5.6
  TOP w0.203: 181.31,49.34 U61.13
  TOP w0.254: R559.1 R557.2
  TOP w0.267: 181.31,49.34 183.65,47.01 R559.1
N1995426: length 5.7
  TOP w0.203: U61.34 180.11,57.98
  TOP w0.254: 179.2,58.89 R562.2 R561.1
  TOP w0.267: 180.11,57.98 179.2,58.89
N1995468: length 6.3
  TOP w0.203: 179.71,57.76 U61.35
  TOP w0.267: R565.1 R566.2 177.43,60.05 179.71,57.76
N1997388: length 3.8
  TOP w0.203: U61.10 180.11,46.9 C697.1
N1997392: length 4
  TOP w0.203: U61.9 179.71,47.39 C699.1
N2007530: length 7.8
  TOP w0.254: U61.39 178.11,56.85
  TOP w0.267: 178.11,56.85 177.58,57.38 175.52,57.38 172.94,59.96 R549.1
N2008530: length 4
  TOP w0.254: U36.7 194.44,60.79 v1(194.7,60.53) 194.94,60.77 U36.8
  BOTTOM w0.254: v1(194.7,60.53) C467.2 R370.2
N2089040: length 4.1
  TOP w0.203: 183.08,50.21 182.91,50.38 U61.17
  TOP w0.267: R536.2 185.87,49.99 183.31,49.99 183.08,50.21
N2153801:
  vias: v1(80.59,26.56)
N2166287: length 33.3
  L16_SIG6 w0.081: v1(23.88,89.74) 23.88,91.74 24.93,92.79 29.94,92.79 30.87,93.72 30.87,97.61 32.39,99.14 36.29,99.14 37.35,100.19 37.35,107.47 38.54,108.66 39.86,108.66 40.52,108 v1(40.52,107.22)
N2166291: length 0.7
  BOTTOM w0.149: R82.1 v1(40.39,109.55)
N2171307: length 4.3
  TOP w0.267: U66.34 159.48,28.74 159.77,29.03 160.09,29.03 R599.2 R602.2
N2171311: length 3.9
  TOP w0.267: U66.32 160,27.74 160.66,28.4 R603.2 R600.2
N2171371: length 12
  TOP w0.229: 159.39,26.74 U66.30
  TOP w0.305: 160.73,26.56 160.54,26.74 159.39,26.74
  TOP w0.381: R603.1 162.38,27.19 R601.2 ; 160.73,26.56 C782.1 161.61,26.56 161.81,26.75 162.31,26.75 R601.2 ; R602.1 163.2,31.45 163.84,30.81 163.84,27.38 163.46,27 R601.2
N2171693: length 2.4
  TOP w0.267: v1(159.9,29.67) 159.77,29.67 159.34,29.24 U66.35
  BOTTOM w0.267: R606.1 160.47,29.67 v1(159.9,29.67)
N2171731: length 1.9
  TOP w0.267: v1(159.9,31.07) 159.9,30.56 159.08,29.74 U66.36
N2530657: length 7
  TOP w0.203: 178.91,57.3 U61.37
  TOP w0.267: C698.1 174.76,59.96 176.37,58.35 177.86,58.35 178.91,57.3
N2530661: length 7.4
  TOP w0.203: 178.51,57.08 U61.38
  TOP w0.267: C700.1 173.87,59.96 175.94,57.89 177.71,57.89 178.51,57.08
N2608710: length 2.6
  TOP w0.381: 238.27,27.35 J13.4 ; J13.4 239.15,26.47 ; J13.4 240.03,27.35
N2746722: length 5
  TOP w0.254: R89.1 236.04,18.81 J2.3
N2760104: length 3.5
  BOTTOM w0.254: R464.2 245.69,96.7 SW5.4
N2760122: length 3.5
  BOTTOM w0.254: R466.2 249.75,96.65 SW5.6
N2766693: length 55.9
  L07_SIG3 w0.089: v1(26.17,23.32) 25.03,22.18 19.18,22.18 16.14,19.13 14.44,19.13 v1(13.43,18.11)
  L14_SIG5 w0.081: v1(63.89,28.02) 61.09,28.02 59.32,26.24 53.14,26.24 50.45,23.55 49.05,23.55 48.24,24.36 43.57,24.36 43.09,23.88 35.06,23.88 34.81,23.62 32.47,23.62 32.11,23.98 31.63,23.98 31.48,23.83 30.66,23.83 30.39,24.11 29.9,24.11 29.67,23.88 29.01,23.88 28.84,24.06 28.48,24.06 28.25,23.83 26.68,23.83 v1(26.17,23.32)
N2766701: length 1.3
  TOP w0.254: R400.1 65.53,28.27 D3.A
N2766729: length 49.5
  L07_SIG3 w0.089: v1(27.06,23.32) 27.95,22.43 27.95,21.8 25.79,19.64 23.25,19.64 22.29,18.68 v1(22.29,18.11)
  L14_SIG5 w0.081: v1(27.06,23.32) 27.26,23.12 35.26,23.12 35.61,23.46 43.35,23.46 43.85,23.95 47.84,23.95 48.57,23.22 50.83,23.22 53.47,25.86 59.44,25.86 60.46,26.88 62.87,26.88 63.13,26.62 63.13,25.73 v1(63.66,25.2)
N2766737: length 1.4
  TOP w0.254: D6.A 65.91,24.46 R401.1
N2801539: length 45.4
  L14_SIG5 w0.081: v1(16.14,35.93) 17.47,35.93 18.57,34.83 22.08,34.83 22.51,35.26 26.02,35.26 26.58,34.7 30.61,34.7 32.93,37.01 33.81,37.01 34.93,38.13 38.11,38.13 39.02,39.04 42.2,39.04 44.89,41.73 44.89,42.62 45.75,43.49 45.75,43.84 47.1,45.19 47.1,46.23 48.19,47.32 48.78,47.32 51.44,49.99 52.71,49.99 52.84,49.86 v1(52.97,49.86)
N2801547: length 1.9
  TOP w0.254: D4.A 54.35,48.39 R402.1
N2801575: length 48.9
  L14_SIG5 w0.081: v1(52.33,46.18) 51.95,46.18 46.26,40.49 44.36,40.49 42.17,38.31 39.25,38.31 38.49,37.54 35.08,37.54 33.86,36.33 32.83,36.33 30.61,34.11 18.17,34.11 17.3,34.98 16.16,34.98 14.46,36.68 14.46,39.3 v1(12.83,40.93)
N2801583: length 1.5
  TOP w0.254: D7.A 54.35,45.34 R403.1
N2830778: length 0.8
  BOTTOM w0.149: R79.1 34.87,76.57 34.78,76.66 34.19,76.66 v1(34.18,76.65)
N2830869: length 8.5
  TOP w0.149: v1(23.76,66.69) 23.95,66.69 24.68,67.42 24.68,72.88 24.95,73.15 25.68,73.15 U5.J11
N2830873: length 6.5
  BOTTOM w0.149: v1(26.18,72.65) 25.68,72.15 25.68,67.54 R70.2
N2830995: length 6
  BOTTOM w0.149: R52.1 25.68,84.11 25.68,83.35 25.88,83.15 26.28,83.15 26.68,82.75 26.68,80.15 v1(27.18,79.65)
N2830997: length 2.5
  BOTTOM w0.149: v1(33.18,82.65) 33.66,83.14 34.74,83.14 R54.1
N2831098: length 3.2
  BOTTOM w0.149: R53.1 20.71,84.08 20.71,83.39 20.96,83.14 21.69,83.14 v1(22.18,82.65)
N2831570: length 4.2
  TOP w0.149: U5.K14 25.68,70.15 25.68,66.8 v1(25.79,66.69)
N2975570:
  vias: v1(50.07,106.76) v1(50.09,106.19) v1(50.09,102.95) v1(50.07,102.44)
N2979144:
  vias: v1(176.74,107.6)
N3089983: length 1.1
  TOP w0.149: R473.2 C624.1
N4269052: length 0.9
  TOP w0.149: U8.J47 U8.K48
N5229121: length 3.5
  TOP w0.254: C977.1 R742.1 R743.1 64.02,72.21 64.14,72.09 U80.3
N5229137: length 1.3
  TOP w0.254: C981.1 61.79,68.16 U80.6
N5229211: length 2.5
  TOP w0.254: v1(63.64,67.39) U80.7
  BOTTOM w0.254: R620.2 R609.1 v1(63.64,67.39)
N5238722: length 3.5
  TOP w0.254: U81.3 64.14,64.21 64.02,64.34 R746.1 R745.1 C983.1
N5238738: length 1.3
  TOP w0.254: C987.1 61.79,60.28 U81.6
N5254399: length 4.6
  BOTTOM w0.254: 7.63,44.86 U25.5
  BOTTOM w0.305: 7.63,44.86 6.95,44.19 6.95,43.97 6.55,43.56
  BOTTOM w0.381: 6.55,43.56 C417.1 C413.2 FB37.2
N5254403: length 5.4
  BOTTOM w0.254: 6.79,44.71 7.13,45.05 U25.6
  BOTTOM w0.305: 6.33,44.25 6.79,44.71
  BOTTOM w0.381: FB38.2 C414.2 C418.1 4.77,43.3 5.72,44.25 6.33,44.25
N5254415: length 3.9
  BOTTOM w0.254: U25.31 10.98,46.71
  BOTTOM w0.305: 10.98,46.71 12.24,46.71 C990.1
  BOTTOM w0.381: C990.1 C988.2 FB39.2
N5402274: length 1.1
  BOTTOM w0.149: C1003.2 R766.1
N5872472: length 1.4
  BOTTOM w0.149: R358.1 U88.9
N5919185: length 1.6
  BOTTOM w0.149: U91.4 57.71,97.76 59.3,97.76 R123.1
N5919260: length 1.9
  BOTTOM w0.149: R839.1 55.7,96.47 U91.1
N6052446: length 3.8
  BOTTOM w0.149: R88.1 17.15,105.93 17.15,103.2
N6060143: length 13
  BOTTOM w0.149: v1(87.43,44.45) 86.47,44.45 85.09,45.83 84.06,45.83 83.6,45.37 82.56,45.37 82.1,45.83 80.88,45.83 80.27,46.43 R845.1
N6228318: length 4.3
  TOP w0.149: U93.C1 v1(46.3,90.31)
  BOTTOM w0.149: R6833.1 R637.2 R6835.2 44.97,91.65 v1(46.3,90.31)
N6231213: length 19
  TOP w0.254: L11.1 46.87,76.79 46.62,76.53 43.57,76.53 43.23,76.19 R6883.2
  TOP w0.381: U93.F9 v1(53.5,87.91)
  L12_SIG4 w0.508: v1(53.5,87.91) 53.5,87.56 55.13,85.93 55.13,83.01 52.83,80.71 v1(48.7,80.71)
N6231502: length 18.7
  TOP w0.254: R6853.2 57.37,76.19 57.03,76.53 53.98,76.53 53.73,76.79 L10.1
  TOP w0.381: U93.C10 v1(54.3,90.31)
  L12_SIG4 w0.508: v1(54.3,90.31) 54.94,90.31 56.65,88.6 56.65,84.28 56.27,83.9 56.27,82.68 v1(54.3,80.71)
  BOTTOM w0.305: v1(54.3,90.31) 54.62,90.31 C1080.2
N6293185: length 4.5
  TOP w0.149: U93.C2 v1(47.1,90.31)
  BOTTOM w0.149: R852.2 49.08,92.52 R6836.2 47.1,91.1 v1(47.1,90.31)
N6294472: length 7.1
  TOP w0.149: U93.E3 v1(47.9,88.71)
  L07_SIG3 w0.089: v1(47.9,88.71) 47.5,88.31 47.5,87.45 47.25,87.2 43.76,87.2 v1(42.87,88.09)
N6295710: length 28.4
  TOP w0.254: R6853.1 59.63,76.19 R6851.2 60.1,76.13 60.36,75.87 60.78,75.87 61.22,76.31 61.22,79.2 v1(60.97,79.45) ; U93.B6 v1(51.1,91.11)
  L16_SIG6 w0.203: v1(51.1,91.11) 50.77,91.11 50.55,90.9 50.55,88.42 51.72,87.25 53.97,87.25 55.43,85.79 55.43,85.33 56.4,84.36 61.3,84.36 62.06,83.59 62.06,80.09 61.64,79.67 61.18,79.67 v1(60.97,79.45)
N6295719: length 30.1
  TOP w0.254: U93.A6 v1(51.1,91.91) ; R6852.1 59.63,75.17 R6851.1 60.18,75.24 60.43,75.49 60.94,75.49 61.6,76.15 61.6,79.58 v1(60.97,80.22)
  L16_SIG6 w0.203: v1(51.1,91.91) 50.22,91.04 50.22,88.28 51.58,86.92 53.83,86.92 55.1,85.65 55.1,85.19 56.27,84.03 61.16,84.03 61.73,83.46 61.73,80.23 61.5,80 61.18,80 v1(60.97,80.22)
N6295800: length 137.8
  TOP w0.254: U93.A9 v1(53.5,91.91)
  L05_SIG2 w0.203: v1(62.11,32.97) 62.39,33.25 62.86,33.25 63.25,33.65 63.25,34.58 62.58,35.25 47.54,35.25 46.23,33.94 45.14,33.94 v1(44.97,34.11)
  L07_SIG3 w0.203: v1(40.49,60.28) 40.49,60.01 41.76,58.74 41.76,46.37 43.25,44.88 44.43,44.88 45.69,43.63 45.87,43.63 47.2,42.29 47.2,40.64 46.93,40.37 46.93,36.59 44.97,34.62 v1(44.97,34.11)
  L12_SIG4 w0.203: v1(53.5,91.91) 53.73,92.15 53.73,92.44 53.49,92.69 52.49,92.69 52.18,92.38 51.52,92.38 51.21,92.69 50.91,92.69 50.53,92.31 50.53,87.81 49.66,86.95 46.64,86.95 45.3,85.6 45.3,82.86 44.46,82.02 42.88,82.02 40.34,79.48 40.34,75.41 39.53,74.59 39.53,72.24 39.09,71.8 39.09,67.02 37.97,65.9 37.97,63.45 40.29,61.12 40.29,60.48 v1(40.49,60.28)
  BOTTOM w0.229: 91.07,41.5 91.09,41.52 91.09,41.84 90.97,41.96 90.97,42.33 91.09,42.45 91.09,42.76 90.97,42.88 90.97,43.25 91.09,43.37 91.09,44
  BOTTOM w0.254: R6857.1 91.62,47.63 91.62,46.23 90.84,45.44 90.84,44.25 91.09,44 ; 91.07,41.5 90.8,41.23 90.35,41.23 89.96,40.85 81.67,40.85 80.04,39.21 77.27,39.21 76.36,38.31 68.71,38.31 63.63,33.23 62.36,33.23 v1(62.11,32.97)
N6296034: length 2.2
  TOP w0.149: U93.B1 v1(46.3,91.11)
  BOTTOM w0.149: R854.2 45.85,91.56 v1(46.3,91.11)
N6296038: length 1.4
  TOP w0.149: U93.A1 v1(46.3,91.91)
  BOTTOM w0.149: v1(46.3,91.91) 46.74,92.36 R855.2
N6296130: length 125.1
  TOP w0.254: U93.E7 v1(51.9,88.71)
  L03_SIG1 w0.203: v1(102.12,40.85) 101.99,40.85 101.78,41.05 96.48,41.05 96.04,40.61 79.78,40.61 v1(79.64,40.46)
  L07_SIG3 w0.203: v1(79.64,40.46) 79.13,39.96 75.89,39.96 73.65,37.72 55.34,37.72 50.22,42.84 50.22,43.31 48.24,45.29 48.24,46.82 49.46,48.04 49.46,49.69 49.05,50.09 47.5,50.09 46.9,50.7 46.9,56.35 44.2,59.05 43.4,59.05 v1(42.17,60.28)
  L12_SIG4 w0.203: 51.32,87.77 50.9,87.35 50.65,87.35 50.05,86.74 50.05,82.76 49.66,82.37 46.43,82.37 45.21,81.16 43.92,81.16 41.43,78.67 41.43,75.11 40.62,74.3 40.62,71.05 40.47,70.89 40.47,67.53 39.5,66.56 39.5,62.99 41.65,60.84 42.29,60.84 42.43,60.7 42.43,60.53 v1(42.17,60.28) ; 51.32,87.77 51.31,87.77 51.32,87.77 ; 51.32,87.77 51.32,88.13 v1(51.9,88.71)
  BOTTOM w0.254: v1(102.12,40.85) 102.32,41.05 102.32,43.41 101.61,44.12 101.61,45.83 102.32,46.54 102.32,47.56 R6860.2
N6296322: length 26.2
  TOP w0.254: v1(40.9,75.24) 40.96,75.17 R6855.1 ; U93.B8 v1(52.7,91.11)
  L05_SIG2 w0.203: v1(40.9,75.24) 41.77,76.11 41.77,79.29 43.59,81.1 45.09,81.1 46.03,82.04 49.78,82.04 50.38,82.64 50.38,86.79 50.58,87 50.58,90.35 50.86,90.63 52.08,90.63 52.56,91.11 v1(52.7,91.11)
N6296326: length 124
  TOP w0.254: U93.F7 51.52,87.51 v1(51.82,87.81)
  L03_SIG1 w0.203: v1(102.88,40.85) 102.75,40.85 102.22,41.38 96.34,41.38 95.9,40.94 79.34,40.94 v1(78.88,40.48)
  L07_SIG3 w0.203: v1(43.06,60.28) 43.06,59.85 43.54,59.38 44.34,59.38 47.23,56.49 47.23,50.84 47.64,50.42 49.19,50.42 49.79,49.82 49.79,47.91 48.57,46.69 48.57,45.43 50.55,43.45 50.55,42.98 55.48,38.05 73.52,38.05 75.76,40.29 78.35,40.29 78.54,40.48 v1(78.88,40.48)
  L12_SIG4 w0.203: v1(51.82,87.81) 51.04,87.02 50.79,87.02 50.38,86.61 50.38,82.62 49.8,82.04 46.57,82.04 45.35,80.83 44.06,80.83 41.76,78.53 41.76,74.97 40.95,74.16 40.95,70.91 40.8,70.76 40.8,67.39 39.83,66.42 39.83,63.12 41.79,61.17 42.43,61.17 42.76,60.84 42.76,60.58 v1(43.06,60.28)
  BOTTOM w0.254: R6859.1 102.7,47.59 102.7,46.38 101.99,45.67 101.99,44.27 102.7,43.56 102.7,41.02 v1(102.88,40.85)
N6296367: length 27.2
  TOP w0.254: U93.A8 v1(52.7,91.91) ; v1(40.9,76.13) 40.96,76.19 R6883.1
  L05_SIG2 w0.203: v1(40.9,76.13) 41.32,76.13 41.44,76.25 41.44,79.42 43.46,81.44 44.96,81.44 45.9,82.37 49.64,82.37 50.05,82.78 50.05,86.93 50.25,87.13 50.25,91.72 50.91,92.38 52.23,92.38 v1(52.7,91.91)
N6296487: length 0.6
  TOP w0.149: U93.A4 v1(49.5,91.91)
N6298711: length 6.2
  TOP w0.381: v1(55.4,88.6) 54.19,88.6 U93.E10
  BOTTOM w0.305: v1(55.4,88.6) 55.56,88.75 55.56,89.03 C1092.1 56.9,89.36 57.15,89.6 D18.2 D19.2
N6299162: length 3.4
  TOP w0.381: U93.D9 v1(53.5,88.71)
  BOTTOM w0.305: C1208.1 55.51,88.09 55.13,88.09 54.74,88.47 53.74,88.47 v1(53.5,88.71)
N6302987: length 3
  TOP w0.149: U93.D1 v1(46.3,89.51)
  BOTTOM w0.149: R6794.1 R858.1 45.94,89.87 v1(46.3,89.51)
N6302998: length 5.7
  TOP w0.149: U93.E1 v1(46.3,88.71)
  L07_SIG3 w0.089: v1(46.3,88.71) 45.87,88.71 44.27,90.31 43.31,90.31 v1(42.87,90.76)
  BOTTOM w0.149: v1(42.87,90.76) R6797.1
N6310318: length 0.9
  TOP w0.254: U94.A2 v1(194.32,58.5)
N6310354: length 5.7
  TOP w0.254: R6877.2 C1202.2 C1201.2 R868.2 191.73,56.21 192.11,56.59 U94.B1
N6310567: length 1.1
  TOP w0.254: U94.A4 v3(196.86,57.23)
  BOTTOM w0.254: R866.2 v3(196.86,57.23)
N6362776: length 2.4
  TOP w0.381: U95.H8 v2(178.95,30.69)
  BOTTOM w0.254: R869.1 179.71,31.83 179.71,31.45 179.33,31.07 179.33,30.81 C1123.2
N6365028: length 8.5
  TOP w0.381: 180.86,35.13 v2(180.22,35.77) ; 183.4,35.13 v2(184.03,35.77)
  L16_SIG6 w0.203: v2(180.22,35.77) 180.86,36.4 182.89,36.4 183.52,35.77 v2(184.03,35.77)
  BOTTOM w0.254: C1126.2 179.9,35.45 v2(180.22,35.77)
  BOTTOM w0.381: C1125.1 v2(184.03,35.77) ; R1004.2 180.82,35.77 v2(180.22,35.77)
N6365040: length 1.3
  TOP w0.254: U95.E6 U95.E7
N6365052: length 6.1
  TOP w0.381: 179.59,35.13 v2(180.22,34.5) ; U95.E5 v2(184.03,34.5)
  L16_SIG6 w0.254: v2(180.22,34.5) 180.86,33.86 U95.E5 v2(184.03,34.5)
N6365353: length 229.1
  TOP w0.254: U95.E8 v2(178.95,34.5)
  L05_SIG2 w0.203: v1(14.69,59.1) 15.28,58.51 15.28,51.98 16.26,51 16.26,43.36 18.09,41.53 18.09,36.38 17.76,36.05 17.76,31.27 18.41,30.62 18.41,29.52 19.69,28.24 32.72,28.24 34.08,26.88 34.68,26.88 35.03,26.52 42.83,26.52 43.45,27.14 47.49,27.14 47.68,26.95 50.24,26.95 50.53,26.66 50.53,26.3 51.91,24.93 59.08,24.93 59.47,24.54 59.47,22.61 63.15,18.93 63.15,17.11 63.84,16.42 65.45,16.42 66.26,15.61 66.26,14.72 66.91,14.07 83.39,14.07 84.04,13.42 126.02,13.42 126.95,14.35 131.08,14.35 137.63,20.91 146.67,20.91 147.5,20.07 161.63,20.07 164.92,23.36 164.92,26.23 171.76,33.07 173.01,33.07 173.63,33.7 174.28,33.7 174.67,34.08 174.67,35.7 175.07,36.1 178.24,36.1 178.95,35.38 v2(178.95,34.5)
  BOTTOM w0.254: v1(14.69,59.1) 15.6,58.19 17.28,58.19 19.03,59.95 20.1,59.95 21.01,60.86 21.01,62.11 22.62,63.72 22.62,64.35 22.87,64.59
N6365365: length 229.1
  TOP w0.254: U95.E9 v2(178.95,33.23)
  L05_SIG2 w0.203: v1(15.52,59.1) 15.61,59.01 15.61,52.11 16.59,51.13 16.59,43.5 18.42,41.67 18.42,36.25 18.09,35.91 18.09,31.41 18.74,30.76 18.74,29.66 19.83,28.57 32.86,28.57 34.22,27.21 34.81,27.21 35.17,26.85 42.69,26.85 43.31,27.47 47.63,27.47 47.82,27.28 50.37,27.28 50.86,26.79 50.86,26.44 52.05,25.26 59.22,25.26 59.8,24.68 59.8,22.75 63.48,19.07 63.48,17.25 63.98,16.75 65.59,16.75 66.59,15.74 66.59,14.86 67.05,14.4 83.53,14.4 84.18,13.75 125.88,13.75 126.81,14.68 130.94,14.68 137.5,21.24 146.8,21.24 147.64,20.4 161.49,20.4 164.59,23.49 164.59,26.36 171.63,33.4 172.87,33.4 173.49,34.03 174.15,34.03 174.34,34.22 174.34,35.84 174.93,36.43 178.38,36.43 179.28,35.52 179.28,34.93 179.53,34.67 179.53,33.81 v2(178.95,33.23)
  BOTTOM w0.254: 21.98,64.59 22.24,64.33 22.24,63.87 20.63,62.26 20.63,61.02 19.94,60.33 18.87,60.33 17.12,58.58 15.76,58.58 15.52,58.81 v1(15.52,59.1)
N6366094: length 0.8
  BOTTOM w0.254: ST33.2 R6879.1
N6366537: length 0.8
  BOTTOM w0.254: ST32.2 R6878.1
N6366923: length 7.2
  TOP w0.381: U95.C5 v2(182.76,35.77) ; 179.59,32.59 v2(180.22,33.23)
  L16_SIG6 w0.203: v2(180.22,33.23) 179.59,33.86 179.59,34.75 179.97,35.13 182.13,35.13 v2(182.76,35.77)
N6369590: length 0.9
  TOP w0.381: U95.C6 v2(182.76,37.04)
N6369792: length 0.9
  TOP w0.381: U95.J6 v2(181.49,29.42)
N6372269: length 4.6
  TOP w0.149: U93.D8 v1(52.7,88.71)
  BOTTOM w0.203: R1006.1 52.33,87.07 52.13,87.28 51.63,87.28 C1127.2 51.2,87.82 51.55,88.18 51.71,88.24 52.23,88.24 v1(52.7,88.71)
N6382900: length 0.6
  TOP w0.149: U93.E6 v1(51.1,88.71)
N6383007: length 0.6
  TOP w0.149: U93.B7 v1(51.9,91.11)
N6384083: length 0.6
  TOP w0.149: U93.E5 v1(49.5,88.71)
N6384284: length 0.6
  TOP w0.149: U93.A7 v1(51.9,91.91)
N6438706: length 137.8
  TOP w0.254: U93.A10 v1(54.3,91.91)
  L05_SIG2 w0.203: v1(44.97,33.43) 45.14,33.61 46.36,33.61 47.68,34.92 62.45,34.92 62.92,34.45 62.92,33.78 62.72,33.58 62.39,33.58 v1(62.11,33.86)
  L07_SIG3 w0.203: v1(44.97,33.43) 44.53,33.86 44.53,34.66 46.6,36.72 46.6,40.51 46.87,40.78 46.87,42.16 45.73,43.3 45.55,43.3 44.29,44.55 43.11,44.55 41.43,46.23 41.43,58.6 v1(39.76,60.28)
  L12_SIG4 w0.203: v1(39.76,60.28) 39.96,60.48 39.96,60.99 37.63,63.31 37.63,66.04 38.76,67.16 38.76,71.93 39.2,72.38 39.2,74.73 40.01,75.54 40.01,79.62 42.75,82.35 44.32,82.35 44.97,82.99 44.97,85.74 46.5,87.28 49.53,87.28 50.2,87.95 50.2,92.44 50.77,93.02 51.21,93.02 51.52,93.32 52.18,93.32 52.48,93.02 53.62,93.02 54.06,92.58 54.06,92.15 v1(54.3,91.91)
  BOTTOM w0.229: 90.13,43.67 90.13,43.38 90.26,43.25 90.26,42.88 90.13,42.75 90.13,42.46 90.26,42.33 90.26,41.96 90.08,41.78 90.08,41.71
  BOTTOM w0.254: v1(62.11,33.86) 62.36,33.61 63.48,33.61 68.56,38.69 76.21,38.69 77.11,39.59 79.88,39.59 81.52,41.23 89.8,41.23 90.08,41.5 90.08,41.71 ; 90.13,43.67 90.13,43.89 90.46,44.22 90.46,45.6 91.24,46.38 91.24,47.65 R6858.2
N6440564: length 19.4
  TOP w0.254: U93.A5 v1(49.5,91.11) ; v1(56.52,81.36) 56.7,81.18 56.7,79.28 57.66,78.32 Q21.1 57.94,77.25 C1220.1
  L03_SIG1 w0.203: v1(56.52,81.36) 56.4,81.49 56.4,84.1 53.55,86.95 51.52,86.95 50.17,88.29 50.17,90.44 v1(49.5,91.11)
N6440883: length 21.5
  TOP w0.254: v1(40.96,78.32) 41.27,78.32 41.85,77.74 C1221.1 ; U93.B5 v1(49.5,90.31)
  L05_SIG2 w0.203: v1(49.5,90.31) 48.71,90.31 48.27,89.87 48.27,89.23 48.6,88.9 48.6,87.53 47.61,86.54 45.83,86.54 44.97,85.68 44.97,83.39 43.95,82.37 42.32,82.37 39.91,79.96 39.91,79.14 40.33,78.72 40.56,78.72 v1(40.96,78.32)
N6626632: length 7.4
  TOP w0.149: U93.D2 v1(47.1,89.51)
  L07_SIG3 w0.089: v1(42.87,92.53) 43.3,92.1 44.46,92.1 45.27,91.29 45.27,90.48 45.83,89.91 46.7,89.91 v1(47.1,89.51)
  BOTTOM w0.149: v1(42.87,92.53) R6798.1
N6626636: length 2.9
  TOP w0.149: U93.F1 v1(46.3,87.91)
  BOTTOM w0.149: v1(46.3,87.91) 46.12,88.09 R6799.1 R6791.1
N6626640: length 6.5
  TOP w0.149: U93.E2 v1(47.1,88.71)
  L07_SIG3 w0.089: v1(42.87,88.98) 42.87,89.04 43.25,89.42 44.52,89.42 45.63,88.31 46.7,88.31 v1(47.1,88.71)
  BOTTOM w0.149: v1(42.87,88.98) R6845.1
N6626644: length 8.6
  TOP w0.149: U93.F2 v1(47.1,87.91)
  L07_SIG3 w0.089: v1(40.77,88.09) 41.22,88.53 44.65,88.53 45.73,87.45 46.64,87.45 v1(47.1,87.91)
  BOTTOM w0.149: v1(40.77,88.09) R6847.1
N6645972: length 5.8
  TOP w0.381: U96.E10 197.11,73.15 v1(197.11,72.47)
  BOTTOM w0.305: D21.2 D20.2 197.35,70.96 197.11,71.2 C1154.1
N6646134: length 4.4
  TOP w0.149: U96.D8 v1(196.46,75.4)
  BOTTOM w0.203: v1(196.46,75.4) 195.99,75.87 195.99,76.39 195.93,76.55 195.57,76.9 C1157.2 195.06,76.5 195.06,76.23 194.91,76.07 194.49,76.07 R6802.1
N6646306: length 3.4
  TOP w0.381: U96.D9 v1(196.46,74.6)
  BOTTOM w0.305: v1(196.46,74.6) 196.22,74.36 196.22,73.36 195.84,72.98 195.84,72.6 C1216.1
N6646832: length 3.3
  BOTTOM w0.305: D20.1 199.92,71.06 199.4,71.58 R6867.2 C1158.1
N6646840: length 15.9
  TOP w0.254: L12.1 183.57,74.5 183.4,74.32 183.4,71.43 R6861.2
  TOP w0.381: U96.C10 v1(198.06,73.8)
  L12_SIG4 w0.381: v1(188.46,73.8) 189.16,73.1 197.36,73.1 v1(198.06,73.8)
  BOTTOM w0.305: v1(198.06,73.8) 198.06,73.49 C1158.2
N6647874: length 218.4
  TOP w0.254: U96.A10 v1(199.66,73.8)
  L14_SIG5 w0.203: v1(222.77,25.22) 222.94,25.4 222.94,28.4 216.72,34.62 216.72,35.38 214.94,37.15 214.94,40.41 212.99,42.37 212.09,42.37 204.35,50.11 204.35,63.42 201.12,66.64 201.12,73.36 200.44,74.04 199.9,74.04 v1(199.66,73.8)
  BOTTOM w0.254: R6870.2 97.54,47.83 97.54,46.94 97.16,46.56 97.16,44.12 96.3,43.25 96.3,41.05 96.12,40.87 96.12,33.23 98.54,30.81 127.92,30.81 132.29,26.44 132.29,23.5 137.42,18.37 142.66,18.37 146.6,14.43 166.55,14.43 168.58,16.46 217.56,16.46 222.96,21.86 222.96,25.03 v1(222.77,25.22)
N6648020: length 19.4
  TOP w0.254: U96.A5 v1(198.86,78.6) ; v1(185.56,71.18) 184.62,71.18 C1222.1
  L07_SIG3 w0.203: v1(185.56,71.18) 185.94,71.55 185.94,71.85 186.55,72.47 192.62,72.47 194.7,74.55 194.7,76.66 195.97,77.93 198.19,77.93 v1(198.86,78.6)
N6648054: length 0.7
  TOP w0.149: U96.A7 199.29,76.6 199.75,76.14 v1(199.75,76.1)
N6648084: length 0.6
  TOP w0.149: U96.B7 v1(198.86,76.2)
N6648272: length 4.3
  TOP w0.254: U96.C1 v1(198.06,81.8)
  BOTTOM w0.149: v1(198.06,81.8) 199.4,83.14 R6831.2 R6808.2 R6830.1
N6648296: length 6
  BOTTOM w0.254: C1180.1 R6868.2
  BOTTOM w0.381: R6868.2 194.13,73.1 193.17,73.1 192.86,72.79 192.86,71.64 193.29,71.21 D21.1
N6648304: length 16.8
  TOP w0.305: L13.1 183.27,81.74 183.01,81.99 183.01,85.04 182.42,85.64 R6885.2
  TOP w0.381: U96.F9 v1(195.66,74.6)
  L12_SIG4 w0.381: v1(195.66,74.6) 194.29,75.97 190.61,75.97 190.15,76.43 190.15,77.71 v1(188.46,79.4)
N6648338: length 5
  TOP w0.149: U96.C2 v1(198.06,81)
  BOTTOM w0.149: v1(198.06,81) 198.85,81 R6829.2 R6809.2
N6648554: length 0.6
  TOP w0.149: U96.A4 v1(199.66,78.6)
N6649026: length 1.4
  TOP w0.149: U96.A1 v1(199.66,81.8)
  BOTTOM w0.149: R6811.2 200.09,81.54 199.93,81.54 v1(199.66,81.8)
N6649122: length 2.2
  TOP w0.149: U96.B1 v1(198.86,81.8)
  BOTTOM w0.149: v1(198.86,81.8) 199.31,82.25 R6818.2
N6649146: length 3
  TOP w0.149: U96.D1 v1(197.26,81.8)
  BOTTOM w0.149: v1(197.26,81.8) 197.62,82.16 R6819.2 R6812.1
N6649150: length 5.7
  TOP w0.149: U96.E1 v1(196.46,81.8)
  L14_SIG5 w0.081: v1(198.51,85.17) 198.03,84.69 198.03,83.8 196.46,82.23 v1(196.46,81.8)
  BOTTOM w0.149: R6813.1 R6821.1
N6649154: length 7.3
  TOP w0.149: U96.D2 v1(197.26,81)
  L03_SIG1 w0.081: v1(200.29,85.23) 199.59,85.23 198.95,84.6 198.95,83.45 197.66,82.16 197.66,81.4 v1(197.26,81)
  BOTTOM w0.149: v1(200.29,85.23) R6814.1
N6649158: length 2.9
  TOP w0.149: U96.F1 v1(195.66,81.8)
  BOTTOM w0.149: R6815.1 R6822.1 195.84,81.98 v1(195.66,81.8)
N6649162: length 6.2
  TOP w0.149: U96.E2 v1(196.46,81)
  L03_SIG1 w0.081: v1(196.73,85.23) 197.17,84.79 197.17,83.07 196.86,82.76 196.86,81.49 196.46,81.09 v1(196.46,81)
  BOTTOM w0.149: v1(196.73,85.23) R6873.1
N6649166: length 8.2
  TOP w0.149: U96.F2 v1(195.66,81)
  L14_SIG5 w0.081: v1(195.66,81) 196.07,81.41 196.07,83.37 196.27,83.57 196.27,86.9 v1(195.84,87.33)
  BOTTOM w0.149: v1(195.84,87.33) R6875.1
N6649352: length 218.5
  TOP w0.254: U96.E7 v1(196.46,76.2)
  L14_SIG5 w0.203: v1(196.46,76.2) 196.11,75.85 195.11,75.85 194.83,75.56 194.83,73.66 195.51,72.98 195.93,72.98 199.04,69.86 199.04,66 201.53,63.51 201.53,52.43 202.14,51.82 202.14,42.27 201.05,41.18 201.05,39.22 201.33,38.94 201.33,35.66 203.72,33.28 206.72,33.28 207.03,32.97 207.46,32.97 207.77,33.28 212.5,33.28 214.33,31.45 218.5,31.45 221.24,28.7 221.24,25.48 v1(221.5,25.22)
  BOTTOM w0.254: R6872.2 105.49,47.57 105.49,46.71 106.31,45.9 106.31,44.12 107.2,43.23 107.2,33.83 108.05,32.97 129.42,32.97 135.19,27.21 135.19,25.4 136.53,24.05 136.53,21.38 137.14,20.78 146.51,20.78 147,20.3 147,17.52 149.33,15.19 165.84,15.19 168.13,17.48 210.75,17.48 214.94,21.67 216.95,21.67 219.11,23.83 220.61,23.83 221.29,24.51 221.29,25.02 v1(221.5,25.22)
N6649458: length 7.7
  TOP w0.149: U96.E3 v1(196.46,80.2)
  L14_SIG5 w0.081: v1(195.84,86.12) 195.84,85.93 195.08,85.17 195.08,80.98 195.46,80.6 196.07,80.6 v1(196.46,80.2)
N6649494: length 26.3
  TOP w0.254: C1223.1 183.84,87.14 184.55,87.84 Q24.1 ; U96.B5 v1(198.06,78.6)
  L07_SIG3 w0.203: v1(184.55,88.45) 184.94,88.85 184.94,89.14 185.29,89.49 193.17,89.49 195.13,87.53 195.13,80.01 195.56,79.58 196.73,79.58 197.24,80.09 197.62,80.09 198.06,79.65 v1(198.06,78.6)
N6649576: length 0.6
  TOP w0.149: U96.E5 v1(196.46,78.6)
N6649610: length 0.6
  TOP w0.149: U96.E6 v1(196.46,77)
N6658100: length 3.4
  TOP w0.254: C865.1 R666.2 R668.1 U70.3
N6658116: length 1.9
  TOP w0.254: C869.1 210.8,35.4 U70.6
N6732170: length 1.5
  TOP w0.149: X2.7 v1(73.17,43.22)
  BOTTOM w0.149: C1199.2 73.65,43.7 v1(73.17,43.22)
N6732230: length 1.9
  TOP w0.149: R6837.1 70.94,46.12 71.64,45.42 X1.5
N6843686: length 1.9
  TOP w0.254: v1(193.05,58.5) U94.A1
  BOTTOM w0.254: v1(193.05,58.5) 192.98,58.56 R6838.2
N6844906: length 1.9
  TOP w0.254: U94.C5 v1(198.13,54.69)
  BOTTOM w0.254: 197.87,54.69 v1(198.13,54.69) R6839.1
N6923756: length 3.3
  BOTTOM w0.305: D18.1 57.04,92.16 56.52,91.65 R6849.2 C1080.1
N6924340: length 0.6
  TOP w0.149: U93.F10 v1(54.3,87.91)
N6924392: length 5.8
  BOTTOM w0.305: D19.1 56.78,85.54 56.46,85.22 55.33,85.22 55,85.55 55,86.38 R6850.2 C1081.1
N6992519: length 23.6
  TOP w0.254: R6861.1 183.56,69.48 v1(183.5,69.42) ; U96.B6 v1(198.86,77)
  L14_SIG5 w0.203: v1(198.86,77) 198.65,77.22 197.96,77.22 197.46,77.73 190.56,77.73 187.64,74.81 187.64,71.06 186.88,70.31 183.45,70.31 183.22,70.08 183.22,69.7 v1(183.5,69.42)
N6992523: length 25.1
  TOP w0.254: v1(182.61,69.42) 182.54,69.48 R6862.1 ; U96.A6 v1(199.66,77)
  L14_SIG5 w0.203: v1(182.61,69.42) 182.89,69.7 182.89,70.22 183.31,70.64 186.75,70.64 187.31,71.2 187.31,74.94 190.42,78.06 197.59,78.06 198.1,77.55 198.94,77.55 199.49,77 v1(199.66,77)
N6993090: length 33.5
  TOP w0.254: v1(182.35,88.09) 182.42,88.03 R6885.1 ; U96.A8 v1(199.66,75.4)
  L12_SIG4 w0.203: v1(199.66,75.4) 199.99,75.4 200.24,75.64 200.24,77.1 199.81,77.52 198.62,77.52 198.19,77.96 195.52,77.96 195.13,78.35 195.13,87.74 194,88.88 188.72,88.88 187.25,87.4 182.24,87.4 182.07,87.57 182.07,87.81 v1(182.35,88.09)
N6993094: length 32
  TOP w0.254: v1(181.46,88.09) 181.4,88.03 R6865.1 ; U96.B8 v1(198.86,75.4)
  L12_SIG4 w0.203: v1(198.86,75.4) 198.33,75.94 198.33,77.35 198.05,77.63 195.38,77.63 194.8,78.21 194.8,87.61 193.86,88.55 188.86,88.55 187.38,87.07 182.1,87.07 181.74,87.43 181.74,87.81 v1(181.46,88.09)
