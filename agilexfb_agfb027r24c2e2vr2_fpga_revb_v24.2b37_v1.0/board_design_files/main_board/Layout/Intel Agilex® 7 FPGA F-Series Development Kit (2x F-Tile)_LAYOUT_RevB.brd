# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM1_DQ65: length 50.7
  L14_SIG5 w0.081: v1(105.75,77.11) 105.75,77.46 106.13,77.84 106.13,82.47 106.45,82.8 106.45,85.02 106.1,85.37 106.1,86.09 105.74,86.45 105.74,86.63 105.91,86.79 106.09,86.79 106.27,86.61 106.43,86.61 106.67,86.85 107.16,86.85 107.28,86.98 107.28,87.67 107.16,87.8 106.87,87.8 106.75,87.67 106.75,87.45 106.62,87.32 106.41,87.32 106.28,87.45 106.28,87.7 106.15,87.83 105.94,87.83 105.81,87.7 105.81,87.41 105.68,87.28 104.99,87.28 104.73,87.03 104.46,87.03 104.28,87.21 104.28,87.42 104.53,87.68 104.53,87.94 104.01,88.46 103.73,88.46 103.59,88.33 103.59,88.01 103.46,87.88 103.27,87.88 103.13,88.01 103.13,88.33 103,88.46 101.07,88.46 100.57,88.96 99.47,88.96 98.49,89.94 96.55,89.94 94.45,92.04 93.07,92.04 91.31,93.8 91.31,93.94 91.45,94.08 91.45,94.22 91.31,94.36 91.31,94.82 91.53,95.04 91.53,95.25 91.31,95.48 91.31,96.64 91.43,96.76 91.59,96.76 91.71,96.64 91.71,95.6 91.83,95.48 92,95.48 92.12,95.6 92.12,96.44 92.24,96.56 92.41,96.56 92.53,96.44 92.53,96.19 92.65,96.08 92.9,96.08 93.03,96.21 93.03,96.57 92.62,96.99 92.23,96.99 92.12,97.1 92.12,99 92,99.12 91.83,99.12 91.71,99 91.71,97.28 91.59,97.16 91.43,97.16 91.31,97.28 91.31,99.11 91.74,99.54 v1(91.74,99.98)
DDR4_DIMM1_DQ66: length 50.9
  L14_SIG5 w0.081: v1(96.89,93.98) 96.89,93.66 97.86,92.69 100.78,92.69 100.9,92.81 100.9,93.06 101.01,93.18 101.17,93.18 101.28,93.06 101.28,92.81 101.4,92.69 103.28,92.69 103.39,92.81 103.39,93.03 103.51,93.14 103.86,93.14 103.97,93.03 103.97,92.81 104.09,92.69 105.75,92.69 105.86,92.81 105.86,93.06 105.97,93.18 106.33,93.18 106.44,93.06 106.44,92.81 106.55,92.69 112.41,92.69 112.53,92.58 112.53,92.43 112.65,92.31 112.79,92.31 112.91,92.43 112.91,92.58 113.03,92.69 113.48,92.69 113.87,92.3 113.87,91.94 113.99,91.82 114.21,91.82 114.32,91.71 114.32,91.54 114.21,91.42 113.99,91.42 113.87,91.3 113.87,91.13 113.99,91.01 114.21,91.01 114.32,90.89 114.32,90.72 114.21,90.61 113.99,90.61 113.87,90.49 113.87,90.32 113.99,90.2 114.21,90.2 114.32,90.08 114.32,89.91 114.21,89.79 113.99,89.79 113.87,89.67 113.87,89.51 113.99,89.39 114.21,89.39 114.32,89.27 114.32,89.1 114.21,88.98 113.99,88.98 113.87,88.86 113.87,88.69 113.99,88.57 114.21,88.57 114.32,88.45 114.32,88.29 114.21,88.17 113.99,88.17 113.87,88.05 113.87,87.88 113.99,87.76 114.21,87.76 114.32,87.64 114.32,87.47 114.21,87.35 113.99,87.35 113.87,87.24 113.87,87.07 113.99,86.95 114.21,86.95 114.32,86.83 114.32,86.66 114.21,86.54 113.99,86.54 113.87,86.42 113.87,86.25 113.99,86.14 114.21,86.14 114.32,86.02 114.32,85.85 114.21,85.73 113.99,85.73 113.87,85.61 113.87,85.43 114.18,85.13 114.18,84.9 114.05,84.77 113.91,84.77 113.73,84.95 113.57,84.95 113.47,84.85 113.47,84.67 113.62,84.52 113.62,84.33 113.48,84.2 113.29,84.2 113.14,84.35 112.95,84.35 112.81,84.21 112.81,84.02 112.96,83.87 112.96,83.68 112.83,83.54 112.64,83.54 112.48,83.69 112.29,83.69 112.06,83.46 112.06,83.2 111.77,82.91 111.51,82.91 110.95,82.35 110.95,76.96 110.62,76.63 110.32,76.63 109.87,76.19 109.61,76.19 109.19,75.77 108.67,75.77 108.29,76.15 107.97,76.15 107.47,75.65 107.27,75.65 107.06,75.56 106.83,75.33 106.67,75.26 106.41,75.26 105.75,75.92 v1(105.75,76.19)
DDR4_DIMM1_DQ67: length 50.9
  L14_SIG5 w0.081: v1(97.69,99.98) 97.59,99.98 97.47,99.86 97.47,99.49 97.82,99.14 97.82,97.66 97.92,97.56 98.31,97.56 98.41,97.46 98.41,97.32 98.31,97.23 97.92,97.23 97.82,97.13 97.82,96.38 97.92,96.28 98.18,96.28 98.28,96.18 98.28,96.05 98.18,95.95 97.92,95.95 97.82,95.85 97.82,95.63 98.13,95.33 98.13,95 97.82,94.69 97.82,94.46 98.08,94.2 98.08,93.67 98.23,93.53 113.19,93.53 114.68,92.04 114.68,84.85 111.72,81.88 111.72,76.48 111.41,76.18 111.13,76.18 110.67,75.72 109.91,75.72 109.48,75.29 108.54,75.29 106.64,74.5 106.13,74.5 105.65,74.98 105.09,74.98 104.96,75.11 v1(104.96,75.73)
DDR4_DIMM1_DQ68: length 55.9
  L14_SIG5 w0.081: v1(108.14,75.73) 107.74,75.33 106.73,74.91 106.26,74.91 105.34,75.82 105.34,76.89 105.14,77.09 104.81,77.09 104.55,77.35 104.55,82.18 102,84.73 102,84.93 102.13,85.06 102.33,85.06 103.02,84.37 103.21,84.37 103.34,84.51 103.34,84.7 101.62,86.42 101.42,86.42 101.29,86.29 101.29,86.1 101.84,85.55 101.84,85.36 101.7,85.22 101.51,85.22 100.4,86.34 100.4,87.01 100.05,87.36 98.95,87.36 98.38,87.93 98.38,88.84 98.06,89.16 96.2,89.16 94.17,91.19 92.91,91.19 90.49,93.61 90.49,94.15 90.95,94.61 90.95,98.93 90.82,99.06 90.64,99.06 90.51,98.93 90.51,97.23 90.39,97.11 90.22,97.11 90.11,97.23 90.11,98.31 89.99,98.43 89.82,98.43 89.7,98.31 89.7,96.46 89.82,96.35 90.46,96.35 90.58,96.23 90.58,96.06 90.46,95.94 89.46,95.94 89.34,95.82 89.34,95.65 89.46,95.53 90.47,95.53 90.59,95.41 90.59,95.25 90.47,95.13 89.29,95.13 89.19,95.02 89.19,94.87 89.28,94.78 90.2,94.78 90.29,94.69 90.29,94.51 90.2,94.43 89.69,94.43 v1(89.25,93.98)
DDR4_DIMM1_DQ69: length 52.7
  L14_SIG5 w0.081: v1(108.94,77.11) 108.94,77.41 109.33,77.8 109.33,82.95 110.15,83.77 110.29,83.77 110.41,83.65 110.41,83.51 110,83.1 110,82.96 110.16,82.79 110.3,82.79 111.58,84.08 111.58,84.21 111.45,84.35 111.31,84.35 111.03,84.07 110.89,84.07 110.78,84.19 110.78,84.33 113.1,86.65 113.1,88.04 112.4,88.73 112.4,91.52 111.9,92.02 97.54,92.02 96.04,93.52 96.04,93.86 95.56,94.34 95.56,94.61 96.36,95.41 96.36,98.13 96.69,98.46 96.69,98.68 95.9,99.48 95.09,99.48 94.77,99.8 94.77,100.26 94.49,100.54 93.02,100.54 92.85,100.37 92.85,100.05 92.69,99.89 92.45,99.89 92.29,100.05 92.29,100.37 92.12,100.54 91.77,100.54 91.3,100.07 91.3,99.76 91.07,99.53 90.49,99.53 v1(90.04,99.98)
DDR4_DIMM1_DQ70: length 52.4
  L14_SIG5 w0.081: v1(108.14,77.57) 108.54,77.97 108.54,82.66 110.85,84.97 110.85,85.11 110.75,85.21 110.61,85.21 110.14,84.74 110,84.74 109.9,84.83 109.9,84.97 111.19,86.26 111.33,86.26 111.42,86.16 111.42,86.02 111.05,85.64 111.05,85.5 111.14,85.4 111.28,85.4 111.82,85.94 111.82,86.79 111.95,86.91 112.14,86.91 112.26,87.03 112.26,87.19 112.14,87.3 111.83,87.3 111.72,87.41 111.72,87.57 111.83,87.69 112.11,87.69 112.22,87.8 112.22,87.96 112.11,88.07 111.8,88.07 111.39,88.48 111.39,89.76 111.48,89.86 111.62,89.86 111.72,89.76 111.72,89.06 111.82,88.97 111.96,88.97 112.06,89.06 112.06,91.31 111.96,91.4 111.82,91.4 111.72,91.31 111.72,90.36 111.62,90.26 111.48,90.26 111.39,90.36 111.39,91.4 111.1,91.69 105.97,91.69 105.86,91.58 105.86,89.73 105.75,89.62 105.59,89.62 105.48,89.73 105.48,91.58 105.36,91.69 105.2,91.69 105.09,91.58 105.09,90.33 104.98,90.22 104.82,90.22 104.7,90.33 104.7,91.58 104.59,91.69 104.43,91.69 104.32,91.58 104.32,90.43 104.2,90.32 104.04,90.32 103.93,90.43 103.93,91.58 103.82,91.69 97.39,91.69 v1(95.09,93.98)
DDR4_DIMM1_DQ71: length 55.5
  L14_SIG5 w0.081: v1(95.99,99.98) 96.44,99.54 96.84,99.54 97.31,99.07 97.31,97.94 97.46,97.79 97.46,97.58 97.34,97.46 96.8,97.46 96.7,97.36 96.7,97.21 96.8,97.11 97.37,97.11 97.46,97.02 97.46,96.87 97.33,96.74 96.91,96.74 96.81,96.64 96.81,96.49 96.91,96.39 97.32,96.39 97.45,96.26 97.45,95.87 97.36,95.78 97.21,95.78 97.12,95.69 97.12,95.53 97.21,95.44 97.32,95.44 97.43,95.34 97.43,95.2 97.32,95.1 96.94,95.1 96.84,94.99 96.84,94.47 96.42,94.06 96.42,93.64 97.7,92.36 112.06,92.36 112.75,91.66 112.75,88.96 112.87,88.85 113.03,88.85 113.14,88.96 113.14,92.17 113.25,92.29 113.41,92.29 113.52,92.17 113.52,86.58 111.87,84.93 111.87,84.74 111.97,84.64 112.15,84.64 112.92,85.4 113.09,85.4 113.21,85.28 113.21,85.1 110.12,82.01 110.12,77.29 109.99,77.17 109.61,77.17 108.94,76.5 v1(108.94,76.19)
DDR4_DIMM1_DQS_N0: length 83.7
  L07_SIG3 w0.076: v1(100.18,79.41) 100.43,79.56 100.46,79.66 100.43,79.71 arc(100.39,79.86) 100.43,80.02 100.5,80.15 arc(100.55,80.34) 100.49,80.53 100.46,80.57 arc(100.41,80.79) 100.46,81 100.53,81.13 arc(100.56,81.26) 100.52,81.38 100.5,81.42 arc(100.41,81.69) 100.48,81.96 100.54,82.05 100.54,82.37 100.4,82.51 100.39,82.51 100.38,82.52
  L07_SIG3 w0.089: 100.38,82.52 99.63,83.27 96.62,83.27 95.26,84.63 79.72,84.63 75.3,80.21 75.3,79.43 73.36,77.49 71.26,77.49 70.97,77.21 69.49,77.21 69.05,76.77 68.49,76.77 68.04,77.22 67.17,77.22 63.64,80.75 63.17,80.75 62.34,81.58 61.53,81.58 61.24,81.87 61.24,82.66 61.12,82.78 60.5,82.78 60.22,83.06 60.22,83.76 60.47,84.01 61.18,84.01 61.27,84.1 61.27,84.44 61.18,84.53 57.79,84.53 57.4,84.91 57.4,91.99 56.65,92.75 56.65,94.06 56.25,94.46 56.25,94.88 55.71,95.42 54.07,95.42 53.82,95.67 53.82,96.16 54.05,96.4 55.08,96.4 55.17,96.48 55.17,98.13 54.82,98.49 54.82,98.79 55.12,99.09 55.42,99.09 56.26,98.25 56.26,96.22 56.36,96.12 56.59,96.12 56.68,96.21 56.68,98.48 56.39,98.78 56.39,99.64 v1(56.04,99.98)
DDR4_DIMM1_DQS_N1: length 78.5
  L07_SIG3 w0.089: v1(108.14,82.17) 108.37,82.04 108.49,82.07 108.61,82.28 108.61,82.61 105.34,85.89 104.04,85.89 103.37,86.56 103.37,88.56 100.95,90.97 86.76,90.97 86.1,90.31 77.36,90.31 77.12,90.07 76.8,90.07 76.55,90.32 75.76,90.32 75.49,90.05 75.12,90.05 74.86,90.31 74.23,90.31 73.53,91.01 72.68,91.01 72.15,91.54 68.53,91.54 67.62,90.63 67.17,90.63 66.96,90.84 66.96,91.31 67.95,92.3 67.95,92.45 67.55,92.85 67.35,92.85 67.23,92.73 67.23,92.27 66.9,91.94 66.66,91.94 66.24,91.52 65.92,91.52 65.57,91.86 65.57,92.23 66.49,93.15 66.49,94.37 66.56,94.44 66.56,95.17 66.4,95.33 65.23,95.33 64.88,95.67 64.74,95.67 64.56,95.49 64.13,95.49 63.95,95.67 63.71,95.67 63.44,95.95 63.44,96.35 63.66,96.56 64.37,96.56 64.48,96.68 64.48,96.9 64.37,97.02 63.77,97.02 63.48,97.31 63.48,97.65 63.77,97.93 64.12,97.93 64.25,98.06 64.25,98.84 64.45,99.04 64.89,99.04 65.09,98.84 65.09,97.61 65.34,97.36 65.34,96.36 65.49,96.21 65.62,96.21 65.78,96.37 65.78,97.3 66.06,97.58 67.68,97.58 67.85,97.75 67.85,97.93 67.7,98.08 66.04,98.08 65.74,98.38 65.74,98.84 65.56,99.02 65.56,99.2 65.74,99.38 65.74,99.64 v1(65.39,99.98)
DDR4_DIMM1_DQS_N2: length 83.5
  L07_SIG3 w0.089: v1(74.74,99.98) 75.01,99.71 75.01,99.38 75.25,99.14 75.56,99.14 76.3,99.89 76.3,100.36 75.93,100.73 75.31,100.73 75.13,100.9 75.13,101.17 75.31,101.35 75.79,101.35 76.02,101.59 76.02,101.71 76.18,101.87 76.18,102.42 75.82,102.78 75.82,102.99 75.99,103.17 76.22,103.17 76.7,102.69 76.99,102.69 77.4,103.1 77.4,103.43 76.94,103.9 76.94,104.15 77.11,104.32 77.36,104.32 77.75,103.93 78.09,103.93 78.68,104.52 78.68,105.27 78.81,105.39 79.02,105.39 79.15,105.27 79.15,104.52 79.39,104.28 79.76,104.28 80,104.52 80,105.25 80.13,105.38 80.33,105.38 80.46,105.25 80.46,104.52 80.7,104.28 81.3,104.28 81.62,104.59 89.18,104.59 89.48,104.3 90.13,104.3 90.76,104.93 108.1,104.93 108.86,104.16 111.54,104.16 113.16,102.54 113.16,102.11 113.7,101.57 113.7,101.31 113.37,100.98 113.37,99.55 113.65,99.28 114.09,99.28 114.29,99.48 114.29,100.68 114.51,100.89 114.69,100.89 115.09,100.49 115.09,95.06 115.63,94.53 115.75,94.53 116.22,94.06 116.22,92.58 118.92,89.88 118.92,86.6 118.79,86.47 118.62,86.47 118.42,86.27 118.42,85.74 118.62,85.55 119.44,85.55 119.57,85.42 119.57,85.18 119.44,85.05 118.67,85.05 118.43,84.81 118.43,84.41 118.67,84.18 119.43,84.18 119.55,84.05 119.55,83.81 119.43,83.68 118.67,83.68 118.43,83.44 118.43,82.45 118.05,82.07 117.93,82.04 v1(117.7,82.17)
DDR4_DIMM1_DQS_N3: length 56.6
  L07_SIG3 w0.089: v1(84.09,99.98) 84.45,99.63 84.45,99.37 84.64,99.18 84.64,99.03 84.51,98.9 83.58,98.9 83.31,98.62 83.31,98.16 83.58,97.88 85.26,97.88 85.51,98.13 85.51,98.64 85.69,98.82 86.09,98.82 86.27,98.65 86.27,97.5 86.51,97.25 86.94,97.25 87.18,97.5 87.18,98.74 87.37,98.93 87.71,98.93 87.89,98.75 87.89,97.02 88.17,96.74 88.55,96.74 88.83,97.02 88.83,98.02 88.98,98.17 89.31,98.17 89.47,98.02 89.47,97.37 89.71,97.13 90.28,97.13 90.52,97.37 90.52,98.05 90.65,98.18 91.08,98.18 91.21,98.05 91.21,97.4 91.47,97.14 91.95,97.14 92.23,97.42 92.23,97.71 92.4,97.88 92.71,97.88 92.85,97.74 92.85,97.32 93.09,97.08 93.99,97.08 94.23,97.32 94.23,97.64 94.35,97.75 95.74,97.75 96.41,97.08 97.34,97.08 97.66,96.76 100.17,96.76 100.62,97.22 102.26,97.22 102.72,97.68 103.29,97.68 103.75,97.22 105.64,97.22 106.67,96.18 106.67,94.63 106.44,94.4 106.44,92.83 106.8,92.47 107.68,92.47 111.99,88.16 111.99,85.94 113.38,84.55 113.38,82.22 113.29,82.07 113.15,82.04 v1(112.92,82.17)
DDR4_DIMM1_DQS_N4: length 56.6
  L16_SIG6 w0.081: v1(139.34,99.98) 139.6,99.98 139.68,99.9 139.68,99.33 140.26,98.75 140.26,98.36 140.15,98.25 137.35,98.25 137.1,98 137.1,97.65 137.35,97.4 139.32,97.4 139.46,97.25 139.46,97.05 139.32,96.91 137.68,96.91 137.43,96.66 137.43,96.3 137.68,96.06 139.32,96.06 139.46,95.91 139.46,95.54 139.32,95.4 138.9,95.4 137.11,93.6 133.8,92.23 132.17,90.59 128.97,90.59 128.26,89.88 117.96,89.88 117.22,89.14 108.14,89.14 107.08,88.08 107.08,86.39 103.76,83.07 103.76,82.13 103.73,82.06 103.6,82.03 v1(103.36,82.17)
DDR4_DIMM1_DQS_N5: length 76.6
  L16_SIG6 w0.076: 110.11,82.45 110.11,82.43 110.11,82.43 110.11,82.07 110.02,81.91 arc(109.96,81.67) 110.02,81.44 110.07,81.36 arc(110.1,81.22) 110.07,81.09 110.01,80.98 arc(109.96,80.76) 110.03,80.55 110.09,80.46 arc(110.13,80.34) 110.1,80.21 109.99,80.03 arc(109.95,79.88) 109.99,79.73 110.02,79.68 109.98,79.55 v1(109.74,79.41)
  L16_SIG6 w0.081: 110.11,82.45 110.11,82.65 110.78,83.33 124.11,83.33 126.37,81.06 132.27,81.06 133.27,80.06 143.52,80.06 143.82,80.37 143.82,86.62 144.66,87.46 144.66,88.47 145.37,89.18 145.37,90.48 146.63,91.74 147.11,91.74 147.51,92.14 149.07,92.14 149.27,92.34 149.27,92.61 148.96,92.92 148.96,93.37 150.18,94.59 150.18,94.86 149.99,95.05 149.1,95.05 148.83,95.33 148.83,96.17 149.08,96.42 150.4,96.42 150.64,96.18 150.64,96.01 150.82,95.84 151.78,95.84 152,96.05 152,96.85 151.87,96.97 149.02,96.97 148.77,97.22 148.77,97.68 149.02,97.93 151.88,97.93 152.02,98.08 152.02,98.28 151.88,98.42 149.28,98.42 149.01,98.7 149.01,99.66 v1(148.69,99.98)
DDR4_DIMM1_DQS_N6: length 74.4
  L03_SIG1 w0.076: v4(104.96,79.41) 105.21,79.56 arc(105.25,79.6) 105.24,79.66 105.2,79.73 arc(105.16,79.91) 105.25,80.09 arc(105.26,80.1) 105.27,80.12 arc(105.32,80.26) 105.32,80.42 arc(105.31,80.46) 105.29,80.49 arc(105.24,80.59) 105.21,80.7 arc(105.2,80.89) 105.26,81.07 arc(105.31,81.23) 105.28,81.39 arc(105.22,81.57) 105.2,81.74 arc(105.22,81.88) 105.28,81.99 arc(105.33,82.07) 105.36,82.16 arc(105.36,82.21) 105.36,82.25 105.36,82.26 105.36,82.46 105.65,82.75 106.05,82.75 106.05,82.75 106.07,82.75
  L03_SIG1 w0.081: v4(158.04,99.98) 158.28,99.74 158.28,99.39 157.8,98.91 154.54,98.91 149.18,93.55 145.68,93.55 145.17,93.05 141.79,93.05 141.1,92.36 136.48,92.36 132.67,88.55 132.67,84.79 132.54,84.66 132.2,84.66 132.08,84.79 132.08,86.51 131.84,86.74 131.36,86.74 131.12,86.51 131.12,84.76 130.99,84.64 130.66,84.64 130.53,84.76 130.53,86.51 130.3,86.74 129.81,86.74 129.58,86.51 129.58,84.84 129.42,84.69 129.09,84.69 128.28,85.5 112.21,85.5 110.41,83.7 107.78,83.7 106.82,82.75 106.07,82.75
DDR4_DIMM1_DQS_N7: length 71.7
  L12_SIG4 w0.076: v1(114.52,79.41) 114.77,79.56 114.8,79.66 114.76,79.72 arc(114.73,79.85) 114.76,79.97 114.86,80.19 arc(114.89,80.33) 114.86,80.46 114.78,80.62 arc(114.74,80.85) 114.82,81.06 114.85,81.11 arc(114.89,81.21) 114.87,81.31 114.81,81.45 arc(114.76,81.71) 114.83,81.96 114.96,82.19 114.95,82.2 114.96,82.22
  L12_SIG4 w0.089: 114.96,82.22 115.05,82.38 117.17,84.5 123.68,84.5 125.9,86.71 125.9,87.99 130.79,92.89 130.79,94.45 132.3,95.95 132.83,95.95 133.23,95.56 133.74,95.56 134.28,96.1 134.84,96.1 137.46,98.71 160.44,98.71 160.63,98.91 164.21,98.91 164.89,98.23 165.68,98.23 167.84,96.06 168.48,96.06 169.03,96.61 169.03,97.09 167.82,98.3 167.82,99.8 167.65,99.98 v1(167.39,99.98)
DDR4_DIMM1_DQS_N8: length 55.4
  L14_SIG5 w0.076: v1(106.55,77.57) 106.86,77.39 106.94,77.4 106.95,77.42 106.95,77.42 106.99,77.47 arc(107,77.54) 106.98,77.61 106.86,77.76 arc(106.76,77.95) 106.73,78.16 106.73,79.54 arc(106.77,79.86) 106.88,80.16 106.89,80.18 arc(106.92,80.34) 106.88,80.49 106.82,80.6 arc(106.77,80.82) 106.84,81.04 106.89,81.12 arc(106.93,81.22) 106.91,81.33 106.85,81.45 arc(106.79,81.69) 106.84,81.93 106.88,82 arc(106.91,82.08) 106.92,82.17 106.92,82.5 106.92,82.5 106.92,82.51
  L14_SIG5 w0.081: v1(93.44,99.98) 93.78,99.65 93.78,99.37 94.38,98.77 95.54,98.77 95.7,98.61 95.7,98.39 95.54,98.23 94.04,98.23 93.26,99.01 92.9,99.01 92.61,98.72 92.61,97.69 92.97,97.33 95.55,97.33 95.71,97.17 95.71,96.95 95.55,96.79 94.1,96.79 93.84,96.53 93.84,96.15 94.1,95.89 95.5,95.89 95.62,95.76 95.62,95.62 95.35,95.34 93.98,95.34 93.72,95.6 92.8,95.6 92.25,95.05 92.25,94.57 92.01,94.33 92.01,93.76 93.26,92.51 94.67,92.51 96.78,90.4 98.94,90.4 99.89,89.44 100.82,89.44 101.29,88.98 104.16,88.98 104.85,88.29 108.14,88.29 108.34,88.09 108.34,86.53 108.19,86.37 106.87,86.37 106.61,86.11 106.61,85.58 106.87,85.32 108.28,85.32 108.43,85.17 108.43,84.88 108.23,84.68 107.21,84.68 106.92,84.38 106.92,82.51
DDR4_DIMM1_DQS_P0: length 83.7
  L07_SIG3 w0.076: v1(100.97,79.87) 100.72,79.72 100.61,79.75 100.58,79.8 arc(100.57,79.86) 100.58,79.93 100.66,80.06 arc(100.73,80.35) 100.64,80.63 100.61,80.66 arc(100.58,80.79) 100.62,80.91 100.69,81.04 arc(100.74,81.27) 100.67,81.48 100.64,81.52 arc(100.59,81.69) 100.63,81.87 100.72,82 100.72,82.44 100.53,82.63 100.53,82.64 100.52,82.66
  L07_SIG3 w0.089: v1(56.89,99.98) 56.58,99.66 56.58,99.5 56.73,99.34 56.73,99.17 56.58,99.02 56.58,98.86 56.87,98.56 56.87,96.13 56.67,95.93 56.28,95.93 56.07,96.14 56.07,98.17 55.34,98.9 55.19,98.9 55.01,98.71 55.01,98.56 55.36,98.21 55.36,96.41 55.16,96.21 54.13,96.21 54.01,96.08 54.01,95.75 54.14,95.61 55.79,95.61 56.44,94.96 56.44,94.54 56.84,94.14 56.84,92.82 57.6,92.07 57.6,84.99 57.87,84.72 61.26,84.72 61.46,84.52 61.46,84.02 61.26,83.82 60.55,83.82 60.41,83.68 60.41,83.14 60.58,82.97 61.19,82.97 61.43,82.74 61.43,81.95 61.61,81.77 62.42,81.77 63.25,80.94 63.72,80.94 67.25,77.41 68.12,77.41 68.57,76.96 68.97,76.96 69.41,77.4 70.89,77.4 71.18,77.68 73.28,77.68 75.11,79.51 75.11,80.29 79.64,84.82 95.34,84.82 96.7,83.46 99.71,83.46 100.52,82.66
DDR4_DIMM1_DQS_P1: length 78.5
  L07_SIG3 w0.089: v1(108.94,81.71) 108.71,81.84 108.67,81.99 108.81,82.23 108.81,82.69 105.42,86.08 104.12,86.08 103.56,86.64 103.56,88.64 101.03,91.16 86.68,91.16 86.02,90.5 77.28,90.5 77.04,90.26 76.88,90.26 76.63,90.51 75.68,90.51 75.41,90.24 75.2,90.24 74.94,90.5 74.31,90.5 73.61,91.2 72.76,91.2 72.23,91.73 68.45,91.73 67.54,90.82 67.25,90.82 67.15,90.92 67.15,91.23 68.14,92.23 68.14,92.53 67.63,93.04 67.27,93.04 67.04,92.81 67.04,92.35 66.82,92.13 66.58,92.13 66.16,91.71 66,91.71 65.76,91.94 65.76,92.15 66.68,93.07 66.68,94.29 66.75,94.36 66.75,95.25 66.48,95.52 65.31,95.52 64.96,95.86 64.66,95.86 64.48,95.68 64.21,95.68 64.03,95.86 63.79,95.86 63.63,96.02 63.63,96.27 63.73,96.37 64.45,96.37 64.68,96.6 64.68,96.98 64.45,97.21 63.84,97.21 63.67,97.38 63.67,97.57 63.84,97.74 64.2,97.74 64.44,97.98 64.44,98.76 64.53,98.85 64.81,98.85 64.9,98.76 64.9,97.53 65.15,97.28 65.15,96.28 65.41,96.02 65.69,96.02 65.97,96.29 65.97,97.22 66.14,97.39 67.76,97.39 68.04,97.67 68.04,98.01 67.78,98.27 66.12,98.27 65.93,98.46 65.93,99.66 v1(66.24,99.98)
DDR4_DIMM1_DQS_P2: length 83.7
  L07_SIG3 w0.089: v1(118.5,81.71) 118.27,81.84 118.23,81.98 118.62,82.37 118.62,83.36 118.75,83.49 119.51,83.49 119.75,83.73 119.75,84.13 119.51,84.37 118.75,84.37 118.62,84.49 118.62,84.73 118.75,84.86 119.52,84.86 119.76,85.1 119.76,85.5 119.52,85.74 118.69,85.74 118.61,85.82 118.61,86.2 118.7,86.28 118.87,86.28 119.11,86.52 119.11,89.96 116.41,92.66 116.41,94.14 115.83,94.72 115.7,94.72 115.28,95.14 115.28,100.57 114.77,101.09 114.43,101.09 114.1,100.76 114.1,99.56 114.01,99.47 113.73,99.47 113.56,99.63 113.56,100.9 113.89,101.23 113.89,101.65 113.35,102.19 113.35,102.62 111.62,104.35 108.94,104.35 108.18,105.12 90.69,105.12 90.06,104.49 89.56,104.49 89.26,104.78 81.54,104.78 81.22,104.47 80.78,104.47 80.65,104.59 80.65,105.33 80.41,105.57 80.05,105.57 79.81,105.33 79.81,104.59 79.68,104.47 79.47,104.47 79.34,104.59 79.34,105.34 79.1,105.58 78.73,105.58 78.49,105.34 78.49,104.59 78.01,104.12 77.83,104.12 77.44,104.51 77.03,104.51 76.74,104.23 76.74,103.82 77.21,103.35 77.21,103.18 76.92,102.88 76.78,102.88 76.3,103.36 75.91,103.36 75.63,103.07 75.63,102.7 75.99,102.34 75.99,101.94 75.83,101.79 75.83,101.66 75.71,101.54 75.23,101.54 74.94,101.25 74.94,100.83 75.23,100.54 75.85,100.54 76.11,100.28 76.11,99.96 75.48,99.33 75.33,99.33 75.2,99.46 75.2,99.59 v1(75.59,99.98)
DDR4_DIMM1_DQS_P3: length 56.7
  L07_SIG3 w0.089: v1(113.72,81.71) 113.49,81.84 113.46,81.98 113.57,82.17 113.57,84.63 112.18,86.01 112.18,88.24 107.76,92.66 106.87,92.66 106.63,92.91 106.63,94.32 106.86,94.55 106.86,96.26 105.71,97.41 103.83,97.41 103.37,97.87 102.64,97.87 102.18,97.41 100.55,97.41 100.09,96.95 97.74,96.95 97.42,97.27 96.49,97.27 95.82,97.95 94.27,97.95 94.04,97.72 94.04,97.4 93.91,97.27 93.17,97.27 93.04,97.4 93.04,97.82 92.79,98.07 92.32,98.07 92.04,97.79 92.04,97.5 91.87,97.33 91.55,97.33 91.4,97.48 91.4,98.13 91.16,98.37 90.57,98.37 90.33,98.13 90.33,97.45 90.2,97.32 89.79,97.32 89.66,97.45 89.66,98.1 89.39,98.36 88.9,98.36 88.64,98.1 88.64,97.1 88.47,96.93 88.24,96.93 88.08,97.1 88.08,98.83 87.79,99.12 87.29,99.12 86.99,98.82 86.99,97.57 86.86,97.44 86.59,97.44 86.46,97.57 86.46,98.73 86.17,99.01 85.61,99.01 85.32,98.72 85.32,98.21 85.18,98.07 83.66,98.07 83.5,98.24 83.5,98.54 83.66,98.71 84.59,98.71 84.83,98.95 84.83,99.25 84.64,99.45 84.64,99.67 v1(84.94,99.98)
DDR4_DIMM1_DQS_P4: length 56.6
  L16_SIG6 w0.081: v1(140.19,99.98) 139.86,99.65 139.86,99.41 140.44,98.82 140.44,98.29 140.22,98.07 137.42,98.07 137.28,97.92 137.28,97.72 137.42,97.58 139.39,97.58 139.64,97.33 139.64,96.98 139.39,96.73 137.76,96.73 137.62,96.58 137.62,96.38 137.76,96.24 139.39,96.24 139.64,95.99 139.64,95.46 139.39,95.21 138.98,95.21 137.21,93.44 133.9,92.07 132.24,90.41 129.04,90.41 128.33,89.7 118.04,89.7 117.3,88.96 108.22,88.96 107.26,88.01 107.26,86.31 103.95,82.99 103.95,82.08 103.88,81.97 103.92,81.85 v1(104.16,81.71)
DDR4_DIMM1_DQS_P5: length 76.6
  L16_SIG6 w0.076: 110.29,82.45 110.29,82.43 110.29,82.43 110.29,82.02 110.18,81.83 arc(110.14,81.67) 110.18,81.52 110.22,81.44 arc(110.28,81.22) 110.23,81 110.17,80.9 arc(110.14,80.77) 110.18,80.65 110.24,80.56 arc(110.31,80.34) 110.25,80.13 110.15,79.94 arc(110.13,79.88) 110.15,79.81 110.18,79.76 110.29,79.73 v1(110.53,79.87)
  L16_SIG6 w0.081: 110.29,82.45 110.29,82.58 110.85,83.14 124.03,83.14 126.29,80.88 132.19,80.88 133.19,79.88 143.59,79.88 144,80.29 144,86.55 144.84,87.38 144.84,88.4 145.55,89.11 145.55,90.4 146.71,91.56 147.19,91.56 147.58,91.95 149.15,91.95 149.45,92.26 149.45,92.68 149.15,92.99 149.15,93.29 150.36,94.51 150.36,94.93 150.06,95.23 149.18,95.23 149.01,95.4 149.01,96.1 149.15,96.24 150.33,96.24 150.46,96.11 150.46,95.94 150.74,95.66 151.86,95.66 152.18,95.97 152.18,96.92 151.95,97.15 149.1,97.15 148.96,97.3 148.96,97.61 149.1,97.75 151.95,97.75 152.2,98 152.2,98.36 151.95,98.61 149.36,98.61 149.19,98.77 149.19,99.05 149.31,99.17 149.31,99.37 149.19,99.49 149.19,99.63 v1(149.54,99.98)
DDR4_DIMM1_DQS_P6: length 74.4
  L03_SIG1 w0.076: v4(105.75,79.87) 105.5,79.72 arc(105.44,79.71) 105.39,79.75 105.35,79.81 arc(105.34,79.89) 105.37,79.96 arc(105.4,79.99) 105.42,80.03 arc(105.5,80.24) 105.49,80.46 arc(105.47,80.52) 105.45,80.58 arc(105.41,80.66) 105.38,80.74 arc(105.37,80.87) 105.41,80.99 arc(105.48,81.22) 105.44,81.47 arc(105.39,81.6) 105.38,81.74 arc(105.39,81.82) 105.43,81.89 arc(105.51,82.06) 105.54,82.26 105.54,82.39 105.72,82.57 106.05,82.57 106.05,82.57 106.07,82.57
  L03_SIG1 w0.081: 106.07,82.57 106.9,82.57 107.85,83.52 110.49,83.52 112.28,85.31 128.2,85.31 129.01,84.5 129.5,84.5 129.76,84.77 129.76,86.43 129.89,86.56 130.22,86.56 130.35,86.43 130.35,84.69 130.58,84.45 131.07,84.45 131.3,84.69 131.3,86.43 131.43,86.56 131.77,86.56 131.89,86.43 131.89,84.71 132.13,84.48 132.61,84.48 132.85,84.71 132.85,88.47 136.56,92.18 141.18,92.18 141.87,92.87 145.25,92.87 145.75,93.37 149.26,93.37 154.62,98.73 157.88,98.73 158.46,99.31 158.46,99.64 158.56,99.74 158.65,99.74 v4(158.89,99.98)
DDR4_DIMM1_DQS_P7: length 71.4
  L12_SIG4 w0.076: 115.13,82.13 115.12,82.11 115.11,82.11 114.99,81.88 arc(114.94,81.7) 114.97,81.52 115.03,81.39 arc(115.07,81.19) 115,81.01 114.97,80.96 arc(114.92,80.83) 114.94,80.7 115.02,80.54 arc(115.07,80.33) 115.02,80.11 114.92,79.9 arc(114.91,79.85) 114.92,79.81 114.95,79.75 115.06,79.72 v1(115.31,79.87)
  L12_SIG4 w0.089: v1(168.24,99.98) 168.01,99.75 168.01,98.37 169.22,97.17 169.22,96.54 168.56,95.87 167.76,95.87 165.6,98.04 164.81,98.04 164.13,98.71 160.71,98.71 160.52,98.52 137.54,98.52 134.92,95.91 134.36,95.91 133.82,95.37 133.15,95.37 132.75,95.76 132.38,95.76 130.98,94.37 130.98,92.81 126.09,87.91 126.09,86.63 123.76,84.31 117.25,84.31 115.2,82.26 115.13,82.13
DDR4_DIMM1_DQS_P8: length 55.5
  L14_SIG5 w0.076: v1(107.35,77.11) 107.13,77.23 107.11,77.33 107.14,77.38 arc(107.18,77.55) 107.12,77.71 107,77.87 arc(106.93,78.01) 106.91,78.16 106.91,79.54 arc(106.94,79.81) 107.04,80.08 107.05,80.1 arc(107.1,80.34) 107.04,80.58 106.98,80.69 arc(106.95,80.82) 106.99,80.94 107.04,81.02 arc(107.11,81.21) 107.06,81.41 107,81.53 arc(106.96,81.69) 107,81.85 107.04,81.92 arc(107.08,82.04) 107.1,82.17 107.1,82.49 107.1,82.49 107.1,82.51
  L14_SIG5 w0.081: v1(94.29,99.98) 93.96,99.65 93.96,99.45 94.45,98.95 95.62,98.95 95.88,98.69 95.88,98.32 95.62,98.05 93.96,98.05 93.19,98.82 92.97,98.82 92.79,98.64 92.79,97.76 93.04,97.51 95.62,97.51 95.89,97.25 95.89,96.87 95.62,96.61 94.18,96.61 94.02,96.45 94.02,96.23 94.18,96.07 95.57,96.07 95.81,95.83 95.81,95.54 95.42,95.16 93.91,95.16 93.65,95.42 92.87,95.42 92.43,94.98 92.43,94.49 92.19,94.25 92.19,93.84 93.34,92.69 94.75,92.69 96.86,90.58 99.01,90.58 99.97,89.62 100.9,89.62 101.36,89.16 104.24,89.16 104.92,88.47 108.22,88.47 108.53,88.16 108.53,86.45 108.27,86.19 106.95,86.19 106.8,86.04 106.8,85.66 106.95,85.5 108.36,85.5 108.62,85.25 108.62,84.81 108.31,84.5 107.29,84.5 107.1,84.31 107.1,83.62 107.2,83.53 107.2,83.27 107.1,83.17 107.1,82.51
DDR4_DIMM1_ODT0: length 77
  L05_SIG2 w0.081: v1(128.29,93.98) 128.29,93.61 128.45,93.46 129.44,93.46 129.57,93.32 129.57,93.07 129.88,92.76 130.64,92.76 131.19,92.21 131.19,89.6 131.3,89.49 131.46,89.49 131.57,89.6 131.57,92.29 131.69,92.41 131.85,92.41 131.96,92.29 131.96,87.19 131.85,87.07 131.69,87.07 131.57,87.19 131.57,88.89 131.46,89 131.3,89 131.19,88.89 131.19,86.96 131.96,86.18 131.96,83.52 131.73,83.29 131.73,78.01 130.89,77.17 126.22,77.17 124.21,79.17 124.21,81.84 122.38,83.67 112.05,83.67 111.77,83.39 111.06,83.39 110.55,82.88 109.41,82.88 109.08,82.55 107.98,82.55 107.61,82.18 107.18,82.18 106.71,81.71 106.48,81.71 106.17,81.4 106.17,76 105.95,75.78 105.66,75.78 105.34,75.47 105.34,74.64 105.02,74.32 104.76,74.32 104.34,73.9 103.99,73.9 103.64,74.25 103.13,74.25 102.75,73.87 100.86,73.87 100.43,74.3 99.96,74.3 99.59,73.94 99.11,73.94 98.77,74.28 98.4,74.28 98.06,74.63 98.06,74.99 v1(97.79,75.27)
DDR4_DIMM1_ODT1: length 76.4
  L05_SIG2 w0.081: v1(96.99,74.81) 97.22,74.58 97.22,74.23 97.59,73.85 97.94,73.85 98.37,73.43 98.68,73.43 99.19,72.92 99.51,72.92 99.92,72.51 100.27,72.51 100.74,72.98 101.1,72.98 101.48,72.6 101.99,72.6 102.37,72.98 102.75,72.98 103.26,72.47 103.51,72.47 103.91,72.08 104.36,72.08 104.8,72.51 105.18,72.51 105.64,72.97 105.91,72.97 106.36,73.42 106.75,73.42 106.94,73.61 106.94,74.63 107.08,74.76 107.46,74.76 107.76,75.07 107.76,80.53 108.05,80.81 108.35,80.81 108.77,81.23 109.1,81.23 109.61,81.74 109.99,81.74 110.37,82.12 110.76,82.12 111.26,82.63 112.02,82.63 112.35,82.96 122,82.96 123.45,81.51 123.45,78.92 125.91,76.46 131.17,76.46 132.47,77.75 132.47,82.82 132.71,83.06 132.71,86.76 132.82,86.87 132.98,86.87 133.1,86.76 133.1,83.63 133.21,83.52 133.37,83.52 133.48,83.63 133.48,92.43 132.98,92.94 132.98,93.56 132.89,93.65 132.68,93.65 132.6,93.56 132.6,93.13 132.51,93.04 132.28,93.04 132.19,93.13 132.19,93.7 132.09,93.8 131.94,93.8 v1(131.77,93.98)
DDR4_DIMM1_PAR: length 72.5
  L12_SIG4 w0.089: v1(120.64,99.98) 121.03,99.98 121.94,99.07 121.94,97.88 122.29,97.53 125.23,97.53 125.33,97.43 125.33,96.76 125.45,96.64 125.62,96.64 125.75,96.76 125.75,97.5 125.87,97.63 126.04,97.63 126.17,97.5 126.17,94.86 126.04,94.74 125.87,94.74 125.75,94.86 125.75,95.98 125.62,96.1 125.45,96.1 125.33,95.98 125.33,92.81 125.17,92.65 121.9,92.65 121.8,92.55 121.8,92.27 121.93,92.15 124.47,92.15 124.6,92.02 124.6,91.83 124.47,91.7 121.93,91.7 121.8,91.57 121.8,91.38 121.93,91.26 123.74,91.26 123.86,91.13 123.86,90.94 123.74,90.81 121.93,90.81 121.8,90.68 121.8,90.49 121.93,90.37 123.03,90.37 123.15,90.24 123.15,90.05 123.03,89.92 121.93,89.92 121.8,89.8 121.8,89.23 119.89,87.32 116.14,87.32 115.89,87.07 115.89,86.63 111.74,82.47 111.74,75.87 110.63,74.76 110.3,74.76 109.67,74.13 109.67,73.5 109.08,72.9 108.8,72.9 108.43,72.53 107.84,72.53 107.42,72.94 107.1,72.94 106.66,72.51 106.32,72.51 105.83,72.02 105.54,72.02 105.12,71.6 104.77,71.6 104.32,71.15 103.93,71.15 103.49,71.6 103.17,71.6 102.74,72.03 102.4,72.03 101.91,72.52 101.56,72.52 101.15,72.93 100.79,72.93 100.39,72.52 99.98,72.52 99.55,72.95 99.22,72.95 98.97,73.21 98.97,73.5 v1(98.58,73.89)
DDR4_DIMM1_REFCLK_N: length 88.4
  L07_SIG3 w0.081: 91.94,81.81 91.96,81.79 92.33,81.79 92.54,81.69 92.79,81.4 92.9,81.35 93.17,81.35 93.43,81.21 93.58,80.94 93.67,80.89 93.98,80.89 94.2,80.76 94.34,80.52 94.48,80.43 94.86,80.43 95.02,80.28 95.17,80.02 95.28,79.97 95.58,79.97 95.78,79.85 95.95,79.56 95.98,79.31 95.95,79.18 95.85,79.08 95.85,78.85 95.9,78.76 95.98,78.65 96.15,78.59 96.37,78.59 96.59,78.46 96.74,78.19 96.86,78.13 97.19,78.13 97.37,78.02 97.54,77.73 97.65,77.67 97.96,77.67 98.18,77.54 98.34,77.27 98.45,77.21 98.76,77.21 98.98,77.08 99.13,76.81 99.25,76.75 99.51,76.75 99.62,76.81 99.77,77.06 100.01,77.2 100.35,77.2 100.4,77.25 100.43,77.31 100.39,77.44 v1(100.18,77.57)
  L07_SIG3 w0.085: v1(63.38,41.42) 63.67,41.42 63.77,41.52 63.77,41.83 62.81,42.8 60.9,42.8 60.36,43.34 57.26,43.34 54.47,46.13 54.47,58.64 57.88,62.05 62.44,62.05 65.38,65 68.91,65 73.01,69.1 74.62,69.1 75.24,69.73 75.62,69.73 v1(75.95,70.06) 76.28,69.73 76.46,69.73 76.72,69.98 76.72,72.91 77.67,73.87 77.67,77.2 78.8,78.33 78.8,79.66 79.13,79.99 79.57,79.99 79.68,80.05 79.9,80.38 80.16,80.45 80.46,80.45 81.25,80.91 81.43,81.23 81.67,81.37 83.17,81.37 83.61,81.81 90.95,81.81 91.06,81.91 91.06,81.98 91.16,82.08 91.34,82.08 91.45,81.98 91.45,81.91 91.55,81.81 91.94,81.81
DDR4_DIMM1_REFCLK_P: length 88.3
  L07_SIG3 w0.081: 91.94,81.58 91.95,81.58 91.97,81.6 92.28,81.6 92.42,81.53 92.67,81.24 92.85,81.15 93.12,81.15 93.28,81.06 93.44,80.79 93.62,80.69 93.93,80.69 94.05,80.62 94.19,80.37 94.43,80.24 94.78,80.24 94.86,80.16 95.03,79.87 95.24,79.77 95.53,79.77 95.64,79.71 95.76,79.49 95.78,79.33 95.77,79.28 95.65,79.16 95.65,78.8 95.74,78.65 95.85,78.49 96.11,78.39 96.32,78.39 96.44,78.32 96.6,78.05 96.8,77.93 97.14,77.93 97.23,77.88 97.4,77.59 97.6,77.47 97.91,77.47 98.04,77.4 98.19,77.13 98.4,77.01 98.71,77.01 98.83,76.94 98.99,76.67 99.19,76.55 99.56,76.55 99.76,76.67 99.91,76.92 100.06,77.01 100.43,77.01 100.55,77.13 100.61,77.23 100.71,77.26 v1(100.97,77.11)
  L07_SIG3 w0.085: 91.94,81.58 83.71,81.58 83.27,81.14 81.73,81.14 81.6,81.07 81.42,80.74 80.53,80.22 80.19,80.22 80.04,80.18 79.84,79.88 79.63,79.76 79.23,79.76 79.03,79.56 79.03,78.23 77.9,77.11 77.9,73.77 76.94,72.82 76.94,69.88 76.56,69.5 76.28,69.5 v1(75.95,69.17) 75.62,69.5 75.34,69.5 74.71,68.87 73.1,68.87 72.7,68.47 72.7,68.32 72.76,68.26 72.76,68.11 72.63,67.98 72.49,67.98 72.42,68.05 72.28,68.05 69,64.77 65.48,64.77 62.53,61.83 57.98,61.83 54.7,58.55 54.7,46.23 57.36,43.57 60.45,43.57 60.99,43.03 62.9,43.03 64,41.93 64,41.51 64.09,41.42 v1(64.4,41.42)
DDR4_DIMM1_RESET_N: length 78.5
  L14_SIG5 w0.081: v1(95.39,74.81) 95.39,74.48 95.98,73.9 96.33,73.9 96.78,73.44 97.11,73.44 97.54,73.87 97.96,73.87 98.44,74.35 98.73,74.35 99.2,73.88 99.5,73.88 99.94,74.32 100.23,74.32 100.76,74.84 101.14,74.84 101.57,75.27 101.94,75.27 102.43,75.76 102.75,75.76 103.19,76.2 103.52,76.2 103.76,76.44 103.76,82.3 103.47,82.59 103.36,82.59 100.17,85.78 99.64,85.78 97.91,87.52 97.76,87.52 97.13,88.15 96.41,88.15 94.14,90.41 92.99,90.41 89.92,93.49 89.12,93.49 88.79,93.82 88.79,94.49 88.54,94.74 88.54,95.35 88.79,95.6 88.79,96.19 88.54,96.44 88.54,96.99 88.79,97.24 88.79,97.55 88.55,97.79 88.55,98.11 89.66,99.22 89.66,100.23 89.79,100.36 90.93,100.36 91.67,101.1 94.98,101.1 95.43,100.65 97.68,100.65 98.11,100.22 98.11,99.8 98.37,99.55 98.37,99.1 98.5,98.96 98.5,98.78 98.37,98.65 98.37,98.53 98.73,98.17 98.73,97.79 99.09,97.44 99.09,97.27 98.65,96.83 98.65,96.67 98.77,96.55 98.94,96.55 99.79,97.39 99.96,97.39 100.07,97.27 100.07,97.11 98.65,95.68 98.65,95.51 98.77,95.39 98.93,95.39 100.34,96.8 100.51,96.8 100.63,96.68 100.63,96.51 99.67,95.55 99.67,95.39 99.79,95.27 99.96,95.27 100.52,95.83 100.69,95.83 100.88,95.65 101.72,95.65 101.87,95.5 101.87,95.19 102.58,94.48 102.58,94.32 102.47,94.21 102.31,94.21 101.6,94.92 101.44,94.92 101.25,94.73 101.25,94.57 101.48,94.35 101.48,94.19 101.37,94.07 101.21,94.07 100.48,94.8 99.73,94.8 99.61,94.68 99.61,94.22 99.49,94.1 99.32,94.1 99.2,94.22 99.2,94.64 99.08,94.75 98.74,94.75 98.54,94.55 v1(98.54,93.98)
  BOTTOM w0.149: R140.2 98.55,94.92 R139.1
DDR4_DIMM1_SA0:
  vias: v1(172.49,95.06)
DDR4_DIMM1_SA1:
  vias: v1(173.34,93.98)
DDR4_DIMM1_SA2:
  vias: v1(134.24,99.98)
DDR4_DIMM1_TDQS_N9: length 83.7
  L07_SIG3 w0.076: v1(100.18,78.49) 100.47,78.32 100.56,78.33 100.61,78.4 arc(100.63,78.5) 100.59,78.6 100.42,78.77 arc(100.31,78.84) 100.19,78.86 100.1,78.86 arc(99.93,78.89) 99.78,78.99 99.74,79.03 arc(99.69,79.1) 99.65,79.18 arc(99.62,79.28) 99.61,79.38 arc(99.62,79.46) 99.64,79.55 99.64,79.55 arc(99.66,79.6) 99.68,79.64 99.75,79.77 99.75,79.79 arc(99.76,79.86) 99.75,79.92 99.72,80.01 99.69,80.08 arc(99.63,80.32) 99.68,80.56 99.72,80.64 arc(99.76,80.79) 99.72,80.94 99.65,81.06 arc(99.61,81.17) 99.6,81.29 arc(99.61,81.34) 99.62,81.38 arc(99.62,81.39) 99.63,81.41 99.73,81.57 arc(99.76,81.65) 99.77,81.73 arc(99.76,81.77) 99.74,81.81 99.71,81.88 arc(99.69,81.91) 99.66,81.95 arc(99.59,82.08) 99.57,82.23 99.57,82.26 99.56,82.27 99.56,82.29
  L07_SIG3 w0.089: v1(56.04,93.98) 55.72,94.31 55.72,94.58 55.49,94.8 55.19,94.8 54.46,94.08 54.46,93.48 55.21,92.74 55.21,92.35 55.5,92.07 56.15,92.07 56.65,91.56 56.65,84.15 56.95,83.86 58.61,83.86 59.05,83.42 59.05,82.11 59.85,81.31 59.85,81.17 59.65,80.97 59.65,80.58 60.02,80.21 60.39,80.21 60.82,80.64 61.67,80.64 61.84,80.81 62.08,80.81 62.4,80.5 62.4,80.27 61.34,79.22 61.34,78.83 61.72,78.45 62.13,78.45 63.28,79.61 63.59,79.61 64,79.19 64,78.94 62.84,77.78 62.84,77.38 63.2,77.03 63.75,77.03 64.82,78.1 65.03,78.1 65.23,77.9 65.23,77.69 65.05,77.52 65.05,77.15 65.29,76.91 65.66,76.91 65.93,77.18 66.11,77.18 66.36,76.93 66.36,76.62 66.79,76.19 67.91,76.19 68.08,76.01 68.08,75.71 67.93,75.55 67.16,75.55 66.94,75.34 66.94,74.79 67.19,74.54 68.32,74.54 68.53,74.76 69.15,74.76 70.84,76.44 71.18,76.44 71.55,76.81 73.75,76.81 76.06,79.12 76.06,80.03 79.97,83.94 94.99,83.94 96.32,82.6 99.36,82.6 99.56,82.4 99.56,82.29
DDR4_DIMM1_TDQS_N10: length 78.5
  L07_SIG3 w0.076: v1(108.14,80.33) 108.4,80.48 108.43,80.58 108.4,80.63 arc(108.35,80.68) 108.28,80.7 108.13,80.7 arc(108.13,80.7) 108.13,80.7 108.12,80.7 arc(107.76,80.85) 107.61,81.21 107.61,81.33 arc(107.62,81.42) 107.65,81.5 107.7,81.59 arc(107.73,81.72) 107.7,81.85 107.67,81.9 arc(107.61,82.03) 107.59,82.17 107.59,82.32 107.58,82.33 107.58,82.34
  L07_SIG3 w0.089: v1(65.39,93.98) 65.05,94.32 65.05,94.47 65.17,94.59 65.39,94.59 65.82,94.16 65.82,93.6 65.63,93.41 65.47,93.41 65.4,93.48 65.24,93.48 65.12,93.37 65.12,93.21 65.19,93.13 65.19,92.97 65.08,92.85 64.91,92.85 64.85,92.92 64.68,92.92 64.57,92.81 64.57,92.64 64.64,92.58 64.64,92.41 64.47,92.25 64.47,91.73 64.79,91.42 65.03,91.42 66.15,90.3 66.15,88.71 66.38,88.48 66.85,88.48 67.08,88.71 67.08,89.77 67.23,89.92 67.99,89.92 68.95,90.88 71.88,90.88 72.41,90.35 73.21,90.35 73.93,89.63 74.55,89.63 74.65,89.53 74.65,89.42 74.25,89.02 74.25,88.75 74.54,88.46 74.85,88.46 76.05,89.66 76.27,89.66 76.43,89.49 76.43,89.25 74.81,87.63 74.81,87.18 75.13,86.86 75.95,86.86 77.42,88.33 77.42,89.44 77.63,89.65 86.41,89.65 87.07,90.31 96.37,90.31 96.52,90.16 96.52,89.15 96.79,88.89 97.21,88.89 97.48,89.15 97.48,90.16 97.63,90.31 97.85,90.31 98,90.16 98,88.32 98.27,88.06 98.67,88.06 98.94,88.32 98.94,90.16 99.09,90.31 99.35,90.31 99.5,90.16 99.5,89.02 99.76,88.76 100.11,88.76 100.38,89.02 100.38,90.16 100.53,90.3 100.67,90.3 100.99,89.98 100.99,89.4 101.21,89.19 101.79,89.19 102.56,88.42 102.56,86.39 103.76,85.19 105.06,85.19 107.58,82.67 107.58,82.34
DDR4_DIMM1_TDQS_N11: length 85.3
  L07_SIG3 w0.076: 119.72,82.35 119.72,82.33 119.72,82.32 119.72,82.23 arc(119.69,82.07) 119.61,81.94 arc(119.47,81.84) 119.3,81.8 119.28,81.8 arc(119.14,81.78) 119.02,81.72 119.01,81.71 arc(118.95,81.67) 118.9,81.61 118.77,81.45 arc(118.67,81.37) 118.54,81.34 118.42,81.34 arc(118.28,81.31) 118.16,81.23 118,81.06 arc(117.9,80.87) 117.94,80.66 117.99,80.58 117.96,80.48 v1(117.7,80.33)
  L07_SIG3 w0.089: v1(74.74,93.98) 74.36,94.37 74.36,94.59 74.46,94.69 74.67,94.69 74.77,94.79 74.77,94.93 74.67,95.03 74.46,95.03 74.36,95.13 74.36,95.36 73.92,95.8 72.74,95.8 72.5,96.04 72.5,98.6 73,99.1 73,99.48 72.49,99.98 72.49,100.28 73.5,101.29 73.5,101.75 77.81,106.06 82.87,106.06 83,105.93 83,105.51 83.24,105.27 83.9,105.27 84.14,105.51 84.14,105.93 84.27,106.06 84.82,106.06 84.95,105.93 84.95,105.51 85.19,105.27 86.01,105.27 86.25,105.51 86.25,105.93 86.37,106.06 87.62,106.06 87.75,105.93 87.75,105.55 87.98,105.31 88.72,105.31 88.96,105.55 88.96,105.93 89.09,106.06 93.71,106.06 94.13,105.64 95.6,105.64 95.9,105.94 96.64,105.94 96.94,105.64 97.55,105.64 97.97,106.06 99.2,106.06 99.55,105.71 101.41,105.71 101.62,105.92 108.26,105.92 109.3,104.89 111.85,104.89 114.49,102.25 114.9,102.25 115.11,102.04 115.11,101.46 116.15,100.42 116.15,95.08 117.47,93.76 117.47,92.41 120.25,89.63 120.25,83.25 119.72,82.72 119.72,82.35
DDR4_DIMM1_TDQS_N12: length 57.9
  L07_SIG3 w0.076: v1(112.92,80.33) 113.18,80.48 113.21,80.58 113.18,80.63 arc(113.13,80.68) 113.06,80.7 112.9,80.7 arc(112.54,80.85) 112.39,81.21 112.39,81.33 arc(112.4,81.42) 112.43,81.5 112.48,81.59 arc(112.52,81.72) 112.48,81.85 112.45,81.9 arc(112.39,82.03) 112.37,82.16 112.37,82.24 112.37,82.25 112.37,82.26
  L07_SIG3 w0.089: 112.37,82.26 112.37,82.46 112.68,82.78 112.68,84.31 110.75,86.24 110.75,88.46 107.44,91.77 106.53,91.77 105.75,92.56 105.75,94.29 105.58,94.45 105.58,94.92 105.39,95.11 104.7,95.11 104.46,95.35 104.46,95.75 104.74,96.03 105.42,96.03 105.55,96.16 105.55,96.34 105.37,96.53 103.13,96.53 102.94,96.34 102.94,96.05 102.65,95.76 101.81,95.76 101.57,96 101.57,96.35 101.44,96.48 100.89,96.48 100.48,96.07 97.38,96.07 97.05,96.4 96.6,96.4 96.34,96.14 95.74,96.14 95.5,96.38 95.5,96.89 95.33,97.06 95,97.06 94.9,96.96 94.9,96.33 94.66,96.09 94.13,96.09 93.79,96.42 91.19,96.42 90.91,96.14 90.17,96.14 89.95,95.92 89.95,95.45 89.75,95.25 89.18,95.25 88.98,95.45 88.98,95.86 88.86,95.99 88.58,95.99 88.42,95.84 88.42,95.48 88.22,95.28 87.69,95.28 87.48,95.48 87.48,96.23 87.34,96.37 87.04,96.37 86.86,96.19 86.86,95.81 86.66,95.61 86.15,95.61 85.95,95.81 85.95,96.85 85.86,96.94 85.52,96.94 85.39,96.81 85.39,95.81 85.19,95.61 84.71,95.61 84.47,95.85 84.47,97.09 84.38,97.18 83.82,97.18 83.63,96.99 83.63,96.72 83.97,96.38 83.97,95.83 83.77,95.63 83.77,95.5 83.88,95.38 84.01,95.38 84.13,95.27 84.13,95.11 84.01,94.99 83.88,94.99 83.77,94.87 83.77,94.31 v1(84.1,93.98)
DDR4_DIMM1_TDQS_N13: length 56.6
  L16_SIG6 w0.076: 104.59,82.56 104.59,82.54 104.58,82.54 104.58,82.18 arc(104.6,82.06) 104.65,81.95 104.68,81.91 arc(104.75,81.68) 104.68,81.45 104.62,81.38 arc(104.58,81.25) 104.62,81.11 104.64,81.09 arc(104.73,80.81) 104.64,80.53 104.57,80.42 arc(104.42,80.28) 104.22,80.24 104,80.24 arc(103.87,80.27) 103.76,80.37 103.73,80.44 103.61,80.47 v1(103.36,80.33)
  L16_SIG6 w0.081: 104.59,82.56 104.59,82.66 108.37,86.45 108.37,88.07 108.6,88.31 109.39,88.31 109.56,88.14 109.56,87.56 109.83,87.29 110.22,87.29 110.49,87.56 110.49,88.14 110.66,88.31 113.37,88.31 113.54,88.14 113.54,87.52 113.81,87.25 114.2,87.25 114.47,87.52 114.47,88.14 114.64,88.31 116.77,88.31 117.14,87.94 117.55,87.94 118.16,88.55 118.66,88.55 118.91,88.8 119.13,88.8 119.38,88.55 119.96,88.55 120.09,88.42 120.09,87.74 120.32,87.52 120.67,87.52 120.99,87.83 120.99,88.84 121.16,89.01 121.55,89.01 121.71,88.84 121.71,88.58 121.99,88.31 122.37,88.31 122.65,88.58 122.65,88.84 122.81,89.01 123.05,89.01 123.22,88.84 123.22,87.59 123.56,87.25 124.33,87.25 124.57,87.49 124.57,87.94 124.15,88.35 124.15,88.84 124.32,89.01 124.55,89.01 124.72,88.84 124.72,88.53 124.99,88.26 125.38,88.26 125.66,88.53 125.66,88.84 125.82,89.01 126.06,89.01 126.22,88.84 126.22,88.58 126.5,88.31 126.8,88.31 127.15,87.95 127.56,87.95 127.79,88.19 127.79,88.52 127.6,88.7 127.6,88.88 127.73,89.01 127.91,89.01 128.1,88.82 128.45,88.82 129.39,89.76 132.51,89.76 134.17,91.43 138.99,93.42 139.11,93.6 139.11,93.74 v1(139.34,93.98)
DDR4_DIMM1_TDQS_N14: length 74.9
  L16_SIG6 w0.076: 109.15,82.56 109.15,82.55 109.15,82.54 109.15,82.11 109.29,81.84 arc(109.32,81.68) 109.27,81.53 109.23,81.45 arc(109.17,81.26) 109.22,81.06 109.29,80.93 arc(109.32,80.79) 109.29,80.66 109.23,80.55 arc(109.18,80.3) 109.26,80.05 109.3,80 arc(109.34,79.87) 109.3,79.75 109.24,79.64 arc(109.17,79.4) 109.22,79.14 109.25,79.09 arc(109.41,78.92) 109.63,78.86 109.8,78.86 arc(109.87,78.84) 109.94,78.8 110.12,78.64 arc(110.15,78.59) 110.15,78.53 110.12,78.47 110.04,78.45 v1(109.74,78.49)
  L16_SIG6 w0.081: 109.15,82.56 109.15,82.82 110.33,84.01 125.81,84.01 126.12,83.7 126.12,82.86 126.29,82.69 126.52,82.69 126.69,82.86 126.69,83.99 126.92,84.23 127.39,84.23 127.62,83.99 127.62,81.94 127.79,81.77 128.03,81.77 128.19,81.94 128.19,83.51 128.47,83.79 128.85,83.79 129.13,83.51 129.13,81.94 129.3,81.77 129.53,81.77 129.7,81.94 129.7,83.51 129.97,83.79 130.36,83.79 130.63,83.51 130.63,81.94 130.8,81.77 131.03,81.77 131.2,81.94 131.2,83.51 131.47,83.79 133.76,83.79 134.03,83.52 134.03,83.12 133.79,82.89 132.68,82.89 132.36,82.57 132.36,82.03 132.8,81.58 142.25,81.58 142.5,81.83 142.5,84.36 143.13,84.99 143.13,86.88 143.95,87.7 143.95,90.69 144.83,91.57 145.29,91.57 145.58,91.87 145.58,92.48 146.03,92.93 147,92.93 147.17,93.1 147.17,94.13 147.75,94.71 148.16,94.71 148.44,94.44 148.44,94.23 v1(148.69,93.98)
DDR4_DIMM1_TDQS_N15: length 74.6
  L03_SIG1 w0.076: v4(104.96,78.49) 105.21,78.34 arc(105.27,78.33) 105.32,78.37 105.35,78.43 arc(105.49,78.57) 105.69,78.6 arc(105.78,78.6) 105.87,78.62 arc(105.96,78.67) 106.04,78.74 arc(106.06,78.77) 106.09,78.81 arc(106.28,78.98) 106.53,79.04 arc(106.73,79.08) 106.88,79.22 arc(107.07,79.41) 107.32,79.48 arc(107.52,79.54) 107.67,79.68 arc(107.73,79.77) 107.8,79.84 arc(107.83,79.86) 107.86,79.88 arc(108,79.94) 108.16,79.95 arc(108.33,80) 108.46,80.13 arc(108.66,80.35) 108.94,80.42 arc(109.13,80.46) 109.26,80.6 arc(109.44,80.79) 109.7,80.88 arc(109.9,80.94) 110.05,81.08 110.09,81.12 arc(110.26,81.27) 110.48,81.33 110.54,81.34 arc(110.72,81.39) 110.87,81.51 110.94,81.61 arc(111.02,81.68) 111.11,81.74 arc(111.15,81.76) 111.19,81.77 arc(111.21,81.77) 111.22,81.77 arc(111.28,81.78) 111.34,81.79 arc(111.53,81.84) 111.66,82 arc(111.68,82.05) 111.71,82.1 111.94,82.42 111.94,82.64 111.94,82.64 111.94,82.66
  L03_SIG1 w0.081: 111.94,82.66 111.94,82.98 112.98,84.01 125.83,84.01 126.75,83.09 130.26,83.09 130.49,82.85 130.49,82.37 130.26,82.13 127.6,82.13 127.47,82 127.47,81.67 127.6,81.54 131.29,81.54 131.42,81.67 131.42,82.85 131.66,83.09 133.23,83.09 134.4,84.25 134.4,88.2 136.51,90.31 137.82,90.85 139.71,90.85 141.58,90.07 148.78,90.07 149.27,90.56 150.48,90.56 151.26,91.34 151.26,92.61 152.05,93.4 152.39,93.4 153.66,94.67 153.66,95.09 154.34,95.77 156.83,95.77 157.71,94.9 157.71,94.32 v4(158.04,93.98)
DDR4_DIMM1_TDQS_N16: length 68.6
  L12_SIG4 w0.076: 116.77,82.37 116.75,82.35 116.75,82.34 116.49,82.08 116.38,81.9 arc(116.3,81.82) 116.19,81.79 116.1,81.79 arc(115.84,81.72) 115.66,81.52 115.64,81.48 arc(115.59,81.22) 115.66,80.96 115.68,80.93 arc(115.72,80.79) 115.68,80.66 115.65,80.62 arc(115.56,80.39) 115.6,80.13 arc(115.61,80.1) 115.63,80.07 115.66,80.01 arc(115.7,79.88) 115.67,79.75 115.59,79.6 arc(115.54,79.38) 115.61,79.16 115.65,79.09 arc(115.69,78.95) 115.65,78.8 115.57,78.68 arc(115.47,78.6) 115.34,78.59 115.25,78.6 arc(115.06,78.57) 114.91,78.43 114.86,78.34 arc(114.83,78.32) 114.8,78.33 v1(114.52,78.49)
  L12_SIG4 w0.089: v1(167.39,93.98) 167.06,94.31 167.06,95.54 166.77,95.83 166.26,95.83 165.8,95.37 165.45,95.37 165.2,95.62 165.2,95.97 165.56,96.33 165.56,96.84 165.11,97.29 164.5,97.29 163.95,96.75 163.38,96.75 162.89,97.23 161.52,97.23 160.86,97.89 138.08,97.89 134.79,94.6 132.9,94.6 132.46,94.17 132.46,93.23 127.3,88.06 127.3,86.71 124.1,83.51 117.91,83.51 116.77,82.37
DDR4_DIMM1_TDQS_N17: length 55.5
  L14_SIG5 w0.076: 107.58,82.51 107.58,82.5 107.59,82.5 107.59,82.15 arc(107.6,82.06) 107.63,81.98 107.69,81.85 arc(107.73,81.69) 107.69,81.53 107.63,81.41 arc(107.59,81.21) 107.65,81.02 107.7,80.94 arc(107.74,80.82) 107.71,80.69 107.65,80.58 arc(107.59,80.34) 107.64,80.1 107.72,79.95 arc(107.73,79.91) 107.74,79.88 arc(107.74,79.84) 107.72,79.8 107.59,79.56 arc(107.54,79.32) 107.65,79.11 107.7,79.05 arc(107.72,79.01) 107.73,78.98 arc(107.73,78.96) 107.73,78.93 arc(107.72,78.88) 107.7,78.83 107.62,78.7 arc(107.55,78.53) 107.54,78.35 107.58,78.06 arc(107.58,78.02) 107.58,77.99 107.55,77.84 arc(107.54,77.59) 107.64,77.35 107.73,77.19 arc(107.76,77.08) 107.73,76.96 107.67,76.88 arc(107.55,76.78) 107.4,76.74 107.26,76.74 arc(107.03,76.67) 106.86,76.5 106.78,76.37 arc(106.74,76.22) 106.78,76.06 106.81,76.02 106.79,75.94 v1(106.55,75.73)
  L14_SIG5 w0.081: v1(93.44,93.99) 93.16,93.99 93.08,94.06 93.08,94.4 93.26,94.58 93.54,94.58 93.99,94.13 93.99,93.99 93.88,93.88 93.88,93.74 93.98,93.64 94.12,93.64 94.23,93.75 94.37,93.75 97.08,91.04 99.82,91.04 99.99,90.88 99.99,90.39 100.27,90.11 100.8,90.11 101.06,90.37 101.06,90.86 101.21,91.01 101.5,91.01 101.65,90.86 101.65,89.92 101.91,89.66 102.34,89.66 102.6,89.92 102.6,90.86 102.76,91.01 103.04,91.01 103.19,90.86 103.19,89.92 103.45,89.66 104.44,89.66 105.14,88.96 106.27,88.96 106.53,89.22 106.53,90.86 106.69,91.02 107.01,91.02 107.16,90.86 107.16,89.19 107.39,88.96 107.9,88.96 108.16,89.22 108.16,90.89 108.31,91.04 108.83,91.04 108.98,90.89 108.98,88.63 109.29,88.32 109.76,88.32 110.04,88.61 110.04,90.89 110.19,91.04 110.58,91.04 110.73,90.89 110.73,87.82 110.58,87.67 109.74,87.67 109.48,87.41 109.48,87.04 109.74,86.78 110.28,86.78 110.43,86.63 110.43,86.41 110.28,86.26 109.51,86.26 109.2,85.95 109.2,84.33 107.58,82.72 107.58,82.51
DDR4_DIMM2_A0: length 103.5
  L16_SIG6 w0.081: v1(93,81.71) 93.17,81.87 93.17,82.6 93.34,82.78 93.34,83.56 95.18,85.39 95.18,86.77 95.27,86.87 95.41,86.87 95.51,86.77 95.51,85.59 95.61,85.49 95.75,85.49 95.85,85.59 95.85,88.63 95.75,88.73 95.61,88.73 95.51,88.63 95.51,87.39 95.41,87.29 95.27,87.29 95.18,87.39 95.18,88.8 96.73,90.35 97.79,90.35 100.11,92.67 100.64,92.67 100.74,92.77 100.74,93.48 100.64,93.58 99.91,93.58 99.83,93.66 99.83,94.56 99.93,94.66 100.52,94.66 100.62,94.76 100.62,94.89 100.52,95 99.89,95 99.79,95.1 99.79,95.23 99.89,95.33 100.52,95.33 100.62,95.43 100.62,95.57 100.52,95.67 99.27,95.67 99.17,95.77 99.17,95.95 99.27,96.05 100.58,96.05 100.69,96.16 100.69,96.33 100.58,96.43 99.24,96.43 99.13,96.54 99.13,96.72 99.23,96.83 102.23,96.83 102.32,96.92 102.32,97.06 102.23,97.16 100.23,97.16 100.13,97.26 100.13,97.4 100.23,97.5 102.32,97.5 102.42,97.59 102.42,97.74 102.52,97.84 102.66,97.84 102.76,97.74 102.76,97.59 102.86,97.5 102.99,97.5 103.09,97.59 103.09,97.97 103.19,98.07 103.33,98.07 103.43,97.97 103.43,97.59 103.53,97.5 103.66,97.5 103.76,97.59 103.76,97.71 103.86,97.81 104,97.81 104.1,97.71 104.1,97.59 104.21,97.48 110.33,97.48 110.57,97.24 112.29,97.24 113.58,98.53 113.72,98.53 113.82,98.44 113.82,98.3 113.03,97.51 113.03,97.37 113.13,97.27 113.27,97.27 114.26,98.26 114.26,98.93 114.35,99.03 114.72,99.03 114.82,99.13 114.82,99.33 114.72,99.42 114.35,99.42 114.26,99.52 114.26,100.34 114.35,100.44 114.72,100.44 114.82,100.54 114.82,100.69 114.72,100.79 114.35,100.79 114.26,100.89 114.26,101.12 114.39,101.25 116.05,101.25 116.89,102.1 116.89,103.65 116.99,103.75 117.28,103.75 117.41,103.88 117.41,105.58 117.3,105.68 116.96,105.68 116.85,105.79 116.85,105.94 116.96,106.04 117.3,106.04 117.41,106.15 117.41,106.3 117.3,106.4 116.96,106.4 116.85,106.51 116.85,106.66 116.96,106.77 117.3,106.77 117.51,106.97 118.68,106.97 118.77,107.07 118.77,107.21 118.68,107.31 117.21,107.31 117.11,107.4 117.11,108.07 117.2,108.16 117.39,108.16 117.48,108.07 117.48,107.72 117.56,107.64 118.68,107.64 118.77,107.74 118.77,107.88 118.68,107.98 117.99,107.98 117.89,108.07 117.89,108.21 117.99,108.31 120.28,108.31 120.38,108.21 120.38,108.07 120.28,107.98 119.26,107.98 119.17,107.88 119.17,107.74 119.26,107.64 120.14,107.64 120.24,107.54 120.24,107.4 120.14,107.31 119.29,107.31 119.2,107.21 119.2,107.07 119.29,106.97 120.42,106.97 120.6,106.79 120.6,106.15 121.02,105.72 121.02,105.41 120.92,105.31 120.6,105.31 120.5,105.22 120.5,105.08 120.6,104.98 121.47,104.98 121.57,104.88 121.57,104.74 121.47,104.64 120.6,104.64 120.5,104.55 120.5,104.41 120.6,104.31 121.47,104.31 121.57,104.21 121.57,104.07 121.47,103.97 120.6,103.97 120.5,103.88 120.5,103.74 120.6,103.64 121.47,103.64 121.57,103.54 121.57,103.4 121.47,103.3 120.6,103.3 120.5,103.2 120.5,103.07 120.6,102.97 121.47,102.97 121.57,102.87 121.57,102.73 121.47,102.63 120.22,102.63 120.13,102.53 120.13,102.4 120.22,102.3 120.67,102.3 120.78,102.19 120.78,102.03 120.88,101.93 121.03,101.93 121.14,102.03 121.14,102.19 121.24,102.3 121.39,102.3 121.49,102.2 v1(121.49,101.6)
DDR4_DIMM2_A1: length 104
  L16_SIG6 w0.081: v1(110.44,101.6) 110.86,101.6 111.05,101.8 111.35,101.8 111.75,101.39 111.75,100.55 111.6,100.4 111.19,100.4 111.02,100.56 110.8,100.56 110.69,100.45 110.08,100.45 109.95,100.58 109.95,101.06 109.8,101.21 109.28,101.21 109.13,101.07 109.13,100.61 108.92,100.4 108.61,100.4 108.43,100.21 108.28,100.21 108.12,100.38 108.12,100.52 108.3,100.7 108.3,101.79 108.08,102.01 107.05,102.01 106.95,102.11 106.95,102.25 107.05,102.34 107.88,102.34 107.98,102.44 107.98,102.58 107.88,102.68 107.05,102.68 106.95,102.78 106.95,102.92 107.05,103.02 107.88,103.02 107.98,103.11 107.98,103.25 107.88,103.35 107.05,103.35 106.95,103.45 106.95,103.59 107.05,103.69 107.88,103.69 107.98,103.78 107.98,103.92 107.88,104.02 106.71,104.02 106.61,103.92 106.61,102.11 106.52,102.01 106.3,102.01 106.12,101.83 106.12,101.33 105.79,101 105.79,100.73 105.58,100.52 105.58,100.3 105.79,100.09 105.79,99.73 105.65,99.58 105.23,99.58 105.03,99.38 103.9,99.38 103.81,99.48 103.81,99.62 103.9,99.72 104.86,99.72 104.96,99.81 104.96,99.95 104.86,100.05 104.22,100.05 104.12,100.15 104.12,100.29 104.22,100.39 104.86,100.39 104.95,100.48 104.95,100.62 104.86,100.72 104.03,100.72 103.74,100.43 103.56,100.43 103.26,100.13 103.26,99.59 103.11,99.44 101.81,99.44 101.71,99.54 101.71,100.32 101.61,100.41 101.47,100.41 101.37,100.32 101.37,99.13 101.27,99.03 101.14,99.03 101.04,99.13 101.04,100.12 100.94,100.22 100.8,100.22 100.7,100.12 100.7,99.04 100.46,98.81 99.07,98.81 98.96,98.7 98.96,98.4 98.86,98.3 98.71,98.3 98.6,98.4 98.6,98.7 98.5,98.81 98.23,98.81 98.06,98.63 98.06,98.3 97.76,98 97.76,96.91 97.6,96.75 97.06,96.75 96.95,96.64 96.95,96.49 97.06,96.39 97.6,96.39 97.7,96.28 97.7,95.82 97.6,95.72 97.15,95.72 97.04,95.61 97.04,95.01 96.93,94.9 96.48,94.9 96.37,94.8 96.37,94.63 96.47,94.52 96.91,94.52 97.15,94.29 97.3,94.29 97.4,94.4 97.4,95.03 97.51,95.13 97.66,95.13 97.76,95.03 97.76,94.45 98.07,94.14 98.07,92.46 97.97,92.35 97.72,92.35 97.62,92.46 97.62,93.53 97.51,93.64 97.36,93.64 97.26,93.53 97.26,91.88 97.15,91.77 96.89,91.77 96.78,91.88 96.78,93.49 96.68,93.6 96.54,93.6 96.44,93.49 96.44,91.83 96.34,91.73 96.19,91.73 96.09,91.83 96.09,93.49 95.99,93.6 95.85,93.6 95.74,93.49 95.74,91.19 95.64,91.09 95.5,91.09 95.4,91.19 95.4,93.37 95.3,93.47 95.16,93.47 95.06,93.37 95.06,90.54 94.96,90.44 94.82,90.44 94.73,90.54 94.73,93.05 94.63,93.15 94.49,93.15 94.39,93.05 94.39,89.81 94.29,89.71 94.15,89.71 94.06,89.81 94.06,93.04 93.96,93.14 93.82,93.14 93.72,93.04 93.72,89.21 93.05,88.54 93.05,86.4 93.15,86.31 93.45,86.31 93.55,86.21 93.55,86.07 93.45,85.97 93.15,85.97 93.05,85.87 93.05,85.53 92.95,85.43 92.81,85.43 92.71,85.53 92.71,87.99 92.62,88.09 92.48,88.09 92.38,87.99 92.38,84.41 92.28,84.31 92.14,84.31 92.04,84.41 92.04,85.6 91.95,85.7 91.81,85.7 91.71,85.6 91.71,83.65 91.87,83.49 91.87,82.51 v1(92.21,82.17)
