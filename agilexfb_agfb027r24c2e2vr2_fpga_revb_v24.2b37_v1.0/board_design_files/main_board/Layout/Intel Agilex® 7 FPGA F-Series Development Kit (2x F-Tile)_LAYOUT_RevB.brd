# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
FDMC8878_VER2
  rect 0.406x0.914 smd: 1(-0.975,-1.643) 2(-0.325,-1.643) 3(0.325,-1.643) 4(0.975,-1.643)
  custom 0.589x0.589 smd: 5(0,0.85)
FS1-K38-20ZA-A0
  round 1.575 hole 1.575 unplated: (-8.4,-3.55) (8.4,-3.55)
  rect 0.356x1.803 smd: 1(-7,3.82) 2(-6.2,3.82) 3(-5.4,3.82) 4(-4.6,3.82) 5(-3.8,3.82) 6(-3,3.82) 7(-2.2,3.82) 8(-1.4,3.82) 9(-0.6,3.82) 10(0.2,3.82) 11(1,3.82) 12(1.8,3.82) 13(2.6,3.82) 14(3.4,3.82) 15(4.2,3.82) 16(5,3.82) 17(5.8,3.82) 18(6.6,3.82) 19(7.4,3.82) 20(7,6.33) 21(6.2,6.33) 22(5.4,6.33) 23(4.6,6.33) 24(3.8,6.33) 25(3,6.33) 26(2.2,6.33) 27(1.4,6.33) 28(0.6,6.33) 29(-0.2,6.33) 30(-1,6.33) 31(-1.8,6.33) 32(-2.6,6.33) 33(-3.4,6.33) 34(-4.2,6.33) 35(-5,6.33) 36(-5.8,6.33) 37(-6.6,6.33) 38(-7.4,6.33)
G97R12322HR
  round 1.118 hole 1.118 unplated: (0,12.223) (0,-12.223)
  rect 1.422x0.356 smd: A1(0.575,10.8) A2(0.575,10.2) A3(0.575,9.6) A4(0.575,9) A5(0.575,8.4) A6(0.575,7.8) A7(0.575,7.2) A8(0.575,6.6) A9(0.575,6) A10(0.575,5.4) A11(0.575,4.8) A12(0.575,4.2) A13(0.575,3.6) A14(0.575,3) A15(0.575,2.4) A16(0.575,1.8) A17(0.575,1.2) A18(0.575,0.6) A19(0.575,0) A20(0.575,-0.6) A21(0.575,-1.2) A22(0.575,-1.8) A23(0.575,-2.4) A24(0.575,-3) A25(0.575,-3.6) A26(0.575,-4.2) A27(0.575,-4.8) A28(0.575,-5.4) A29(0.575,-6) A30(0.575,-6.6) A31(0.575,-7.2) A32(0.575,-7.8) A33(0.575,-8.4) A34(0.575,-9) A35(0.575,-9.6) A36(0.575,-10.2) A37(0.575,-10.8) B1(3.525,10.8) B2(3.525,10.2) B3(3.525,9.6) B4(3.525,9) B5(3.525,8.4) B6(3.525,7.8) B7(3.525,7.2) B8(3.525,6.6) B9(3.525,6) B10(3.525,5.4) B11(3.525,4.8) B12(3.525,4.2) B13(3.525,3.6) B14(3.525,3) B15(3.525,2.4) B16(3.525,1.8) B17(3.525,1.2) B18(3.525,0.6) B19(3.525,0) B20(3.525,-0.6) B21(3.525,-1.2) B22(3.525,-1.8) B23(3.525,-2.4) B24(3.525,-3) B25(3.525,-3.6) B26(3.525,-4.2) B27(3.525,-4.8) B28(3.525,-5.4) B29(3.525,-6) B30(3.525,-6.6) B31(3.525,-7.2) B32(3.525,-7.8) B33(3.525,-8.4) B34(3.525,-9) B35(3.525,-9.6) B36(3.525,-10.2) B37(3.525,-10.8)
  oval 2.108x1.118 hole 1.499x0.508: MH1(-4.325,12.75) MH2(1.775,12.75) MH3(-4.325,-12.75) MH4(1.775,-12.75)
HC_R0201
  rect 0.45x0.4 smd: 1(-0.35,0) 2(0.35,0)
HDR2X1_100MIL
  rect 1.6x1.6 hole 1.092: 1(0,0)
  round 1.6 hole 1.092: 2(2.54,0)
IFSC1008ABER1R0M01
  rect 1.372x2.261 smd: 1(-1.086,0) 2(1.086,0)
LCC12_S30_50DF25X17MA
  rect 0.279x0.787 smd: 1(-1.25,-1.494) 2(-0.75,-1.494) 3(-0.25,-1.494) 4(0.25,-1.494) 5(0.75,-1.494) 6(1.25,-1.494) 7(1.25,1.494) 8(0.75,1.494) 9(0.25,1.494) 10(-0.25,1.494) 11(-0.75,1.494) 12(-1.25,1.494)
  rect 2.616x1.422 smd: 13(0,0)
LED_0603
  rect 1.092x0.991 smd: A(-0.851,0) C(0.851,0)
LTC1981ES5_SOT23
  rect 1.22x0.62 smd: 1(-1.31,0.95) 2(-1.31,0) 3(-1.31,-0.95) 4(1.31,-0.95) 5(1.31,0.95)
LTC-LQFN-42-1571
  rect 0.508x0.254 smd: 1(-2.502,3.5) 2(-2.502,3) 3(-2.502,2.5) 4(-2.502,2) 5(-2.502,1.5) 6(-2.502,1) 7(-2.502,0.5) 8(-2.502,0) 9(-2.502,-0.5) 10(-2.502,-1) 11(-2.502,-1.5) 12(-2.502,-2) 13(-2.502,-2.5) 14(-2.502,-3) 15(-2.502,-3.5)
  rect 0.254x0.508 smd: 16(-2,-4.002) 17(-1,-4.002) 18(-0.5,-4.002) 19(0,-4.002) 20(1,-4.002) 21(1.5,-4.002) 37(1.5,4.002) 38(1,4.002) 39(0,4.002) 40(-0.5,4.002) 41(-1,4.002) 42(-2,4.002)
  rect 0.711x0.254 smd: 22(2.4,-3.5) 23(2.4,-3) 24(2.4,-2.5) 25(2.4,-2) 26(2.4,-1.5) 27(2.4,-1) 28(2.4,-0.5) 29(2.4,0) 30(2.4,0.5) 31(2.4,1) 32(2.4,1.5) 33(2.4,2) 34(2.4,2.5) 35(2.4,3) 36(2.4,3.5)
  rect 0.7x1.5 smd: 43(0.85,0)
LTC-UHG-52-1550
  oval 0.787x0.229 smd: 1(-2.494,3.2) 2(-2.494,2.8) 3(-2.494,2.4) 4(-2.494,2) 5(-2.494,1.6) 6(-2.494,1.2) 7(-2.494,0.8) 8(-2.494,0.4) 9(-2.494,0) 10(-2.494,-0.4) 11(-2.494,-0.8) 12(-2.494,-1.2) 13(-2.494,-1.6) 14(-2.494,-2) 15(-2.494,-2.4) 16(-2.494,-2.8) 17(-2.494,-3.2) 27(2.494,-3.2) 28(2.494,-2.8) 29(2.494,-2.4) 30(2.494,-2) 31(2.494,-1.6) 32(2.494,-1.2) 33(2.494,-0.8) 34(2.494,-0.4) 35(2.494,0) 36(2.494,0.4) 37(2.494,0.8) 38(2.494,1.2) 39(2.494,1.6) 40(2.494,2) 41(2.494,2.4) 42(2.494,2.8) 43(2.494,3.2)
  oval 0.229x0.787 smd: 18(-1.6,-3.994) 19(-1.2,-3.994) 20(-0.8,-3.994) 21(-0.4,-3.994) 22(0,-3.994) 23(0.4,-3.994) 24(0.8,-3.994) 25(1.2,-3.994) 26(1.6,-3.994) 44(1.6,3.994) 45(1.2,3.994) 46(0.8,3.994) 47(0.4,3.994) 48(0,3.994) 49(-0.4,3.994) 50(-0.8,3.994) 51(-1.2,3.994) 52(-1.6,3.994)
  rect 3.429x6.426 smd: 53(0,0)
MAX10_FBGA-256
  round 1.016 smd: (-9.5,-9.5) (10.389,8.611)
  round 0.533 smd: A1(-7.5,7.5) A2(-6.5,7.5) A3(-5.5,7.5) A4(-4.5,7.5) A5(-3.5,7.5) A6(-2.5,7.5) A7(-1.5,7.5) A8(-0.5,7.5) A9(0.5,7.5) A10(1.5,7.5) A11(2.5,7.5) A12(3.5,7.5) A13(4.5,7.5) A14(5.5,7.5) A15(6.5,7.5) A16(7.5,7.5) B1(-7.5,6.5) B2(-6.5,6.5) B3(-5.5,6.5) B4(-4.5,6.5) B5(-3.5,6.5) B6(-2.5,6.5) B7(-1.5,6.5) B8(-0.5,6.5) B9(0.5,6.5) B10(1.5,6.5) B11(2.5,6.5) B12(3.5,6.5) B13(4.5,6.5) B14(5.5,6.5) B15(6.5,6.5) B16(7.5,6.5) C1(-7.5,5.5) C2(-6.5,5.5) C3(-5.5,5.5) C4(-4.5,5.5) C5(-3.5,5.5) C6(-2.5,5.5) C7(-1.5,5.5) C8(-0.5,5.5) C9(0.5,5.5) C10(1.5,5.5) C11(2.5,5.5) C12(3.5,5.5) C13(4.5,5.5) C14(5.5,5.5) C15(6.5,5.5) C16(7.5,5.5) D1(-7.5,4.5) D2(-6.5,4.5) D3(-5.5,4.5) D4(-4.5,4.5) D5(-3.5,4.5) D6(-2.5,4.5) D7(-1.5,4.5) D8(-0.5,4.5) D9(0.5,4.5) D10(1.5,4.5) D11(2.5,4.5) D12(3.5,4.5) D13(4.5,4.5) D14(5.5,4.5) D15(6.5,4.5) D16(7.5,4.5) E1(-7.5,3.5) E2(-6.5,3.5) E3(-5.5,3.5) E4(-4.5,3.5) E5(-3.5,3.5) E6(-2.5,3.5) E7(-1.5,3.5) E8(-0.5,3.5) E9(0.5,3.5) E10(1.5,3.5) E11(2.5,3.5) E12(3.5,3.5) E13(4.5,3.5) E14(5.5,3.5) E15(6.5,3.5) E16(7.5,3.5) F1(-7.5,2.5) F2(-6.5,2.5) F3(-5.5,2.5) F4(-4.5,2.5) F5(-3.5,2.5) F6(-2.5,2.5) F7(-1.5,2.5) F8(-0.5,2.5) F9(0.5,2.5) F10(1.5,2.5) F11(2.5,2.5) F12(3.5,2.5) F13(4.5,2.5) F14(5.5,2.5) F15(6.5,2.5) F16(7.5,2.5) G1(-7.5,1.5) G2(-6.5,1.5) G3(-5.5,1.5) G4(-4.5,1.5) G5(-3.5,1.5) G6(-2.5,1.5) G7(-1.5,1.5) G8(-0.5,1.5) G9(0.5,1.5) G10(1.5,1.5) G11(2.5,1.5) G12(3.5,1.5) G13(4.5,1.5) G14(5.5,1.5) G15(6.5,1.5) G16(7.5,1.5) H1(-7.5,0.5) H2(-6.5,0.5) H3(-5.5,0.5) H4(-4.5,0.5) H5(-3.5,0.5) H6(-2.5,0.5) H7(-1.5,0.5) H8(-0.5,0.5) H9(0.5,0.5) H10(1.5,0.5) H11(2.5,0.5) H12(3.5,0.5) H13(4.5,0.5) H14(5.5,0.5) H15(6.5,0.5) H16(7.5,0.5) J1(-7.5,-0.5) J2(-6.5,-0.5) J3(-5.5,-0.5) J4(-4.5,-0.5) J5(-3.5,-0.5) J6(-2.5,-0.5) J7(-1.5,-0.5) J8(-0.5,-0.5) J9(0.5,-0.5) J10(1.5,-0.5) J11(2.5,-0.5) J12(3.5,-0.5) J13(4.5,-0.5) J14(5.5,-0.5) J15(6.5,-0.5) J16(7.5,-0.5) K1(-7.5,-1.5) K2(-6.5,-1.5) K3(-5.5,-1.5) K4(-4.5,-1.5) K5(-3.5,-1.5) K6(-2.5,-1.5) K7(-1.5,-1.5) K8(-0.5,-1.5) K9(0.5,-1.5) K10(1.5,-1.5) K11(2.5,-1.5) K12(3.5,-1.5) K13(4.5,-1.5) K14(5.5,-1.5) K15(6.5,-1.5) K16(7.5,-1.5) L1(-7.5,-2.5) L2(-6.5,-2.5) L3(-5.5,-2.5) L4(-4.5,-2.5) L5(-3.5,-2.5) L6(-2.5,-2.5) L7(-1.5,-2.5) L8(-0.5,-2.5) L9(0.5,-2.5) L10(1.5,-2.5) L11(2.5,-2.5) L12(3.5,-2.5) L13(4.5,-2.5) L14(5.5,-2.5) L15(6.5,-2.5) L16(7.5,-2.5) M1(-7.5,-3.5) M2(-6.5,-3.5) M3(-5.5,-3.5) M4(-4.5,-3.5) M5(-3.5,-3.5) M6(-2.5,-3.5) M7(-1.5,-3.5) M8(-0.5,-3.5) M9(0.5,-3.5) M10(1.5,-3.5) M11(2.5,-3.5) M12(3.5,-3.5) M13(4.5,-3.5) M14(5.5,-3.5) M15(6.5,-3.5) M16(7.5,-3.5) N1(-7.5,-4.5) N2(-6.5,-4.5) N3(-5.5,-4.5) N4(-4.5,-4.5) N5(-3.5,-4.5) N6(-2.5,-4.5) N7(-1.5,-4.5) N8(-0.5,-4.5) N9(0.5,-4.5) N10(1.5,-4.5) N11(2.5,-4.5) N12(3.5,-4.5) N13(4.5,-4.5) N14(5.5,-4.5) N15(6.5,-4.5) N16(7.5,-4.5) P1(-7.5,-5.5) P2(-6.5,-5.5) P3(-5.5,-5.5) P4(-4.5,-5.5) P5(-3.5,-5.5) P6(-2.5,-5.5) P7(-1.5,-5.5) P8(-0.5,-5.5) P9(0.5,-5.5) P10(1.5,-5.5) P11(2.5,-5.5) P12(3.5,-5.5) P13(4.5,-5.5) P14(5.5,-5.5) P15(6.5,-5.5) P16(7.5,-5.5) R1(-7.5,-6.5) R2(-6.5,-6.5) R3(-5.5,-6.5) R4(-4.5,-6.5) R5(-3.5,-6.5) R6(-2.5,-6.5) R7(-1.5,-6.5) R8(-0.5,-6.5) R9(0.5,-6.5) R10(1.5,-6.5) R11(2.5,-6.5) R12(3.5,-6.5) R13(4.5,-6.5) R14(5.5,-6.5) R15(6.5,-6.5) R16(7.5,-6.5) T1(-7.5,-7.5) T2(-6.5,-7.5) T3(-5.5,-7.5) T4(-4.5,-7.5) T5(-3.5,-7.5) T6(-2.5,-7.5) T7(-1.5,-7.5) T8(-0.5,-7.5) T9(0.5,-7.5) T10(1.5,-7.5) T11(2.5,-7.5) T12(3.5,-7.5) T13(4.5,-7.5) T14(5.5,-7.5) T15(6.5,-7.5) T16(7.5,-7.5)
MH_D125C175T_TB315
  round 8.001 hole 3.175: 1(0,0)
MH_PTH_3_8MM
  round 7 hole 4.6: 1(0,0)
MOLEX-MICRO-USB-47589-001
  rect 1.8x1.9 smd: (-1.15,0) (1.15,0)
  rect 0.406x1.346 smd: 1(1.3,-2.673) 2(0.65,-2.673) 3(0,-2.673) 4(-0.65,-2.673) 5(-1.3,-2.673)
  oval 1.05x1.25 hole 0.65x0.85: 6(-2.225,-3) 7(2.225,-3)
  rect 2.075x1.9 hole 1.3x0.6: 8(-4.175,0) 9(4.175,0)
MOLEX_70247-1051
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
MOLEX_455860005
  round 2.997 hole 2.997 unplated: (0,7.3) (12.6,7.3)
  rect 3.302x3.302 hole 1.803: 1(0,0)
  round 3.302 hole 1.803: 2(4.2,0) 3(8.4,0) 4(12.6,0) 5(0,-4.2) 6(4.2,-4.2) 7(8.4,-4.2) 8(12.6,-4.2)
MOLEX_0470533000
  round 1.245 hole 1.245 unplated: (-5.08,-2.16)
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
MSOP-8
  rect 0.406x1.778 smd: 1(-0.975,-2.271) 2(-0.325,-2.271) 3(0.325,-2.271) 4(0.975,-2.271) 5(0.975,2.271) 6(0.325,2.271) 7(-0.325,2.271) 8(-0.975,2.271)
MTH250R125
  round 6.35 hole 3.175: 1(0,0)
NFET_PSMN1R0-30YLD
  rect 0.635x1.6 smd: 1(-1.905,-2.8) 2(-0.635,-2.8) 3(0.635,-2.8) 4(1.905,-2.8)
  rect 4.674x4.775 smd: 5(0,1.213)
PANASONIC_SVPC_8X12
  rect 1.778x4.013 smd: 1(0,3.257) 2(0,-3.257)
PCIX-16PORT
  rect 0.6x3 smd: A1(0,0) A2(1,0) A3(2,0) A4(3,0) A5(4,0) A6(5,0) A7(6,0) A8(7,0) A9(8,0) A10(9,0) A11(10,0) A12(13,0) A13(14,0) A14(15,0) A15(16,0) A16(17,0) A17(18,0) A18(19,0) A19(20,0) A20(21,0) A21(22,0) A22(23,0) A23(24,0) A24(25,0) A25(26,0) A26(27,0) A27(28,0) A28(29,0) A29(30,0) A30(31,0) A31(32,0) A32(33,0) A33(34,0) A34(35,0) A35(36,0) A36(37,0) A37(38,0) A38(39,0) A39(40,0) A40(41,0) A41(42,0) A42(43,0) A43(44,0) A44(45,0) A45(46,0) A46(47,0) A47(48,0) A48(49,0) A49(50,0) A50(51,0) A51(52,0) A52(53,0) A53(54,0) A54(55,0) A55(56,0) A56(57,0) A57(58,0) A58(59,0) A59(60,0) A60(61,0) A61(62,0) A62(63,0) A63(64,0) A64(65,0) A65(66,0) A66(67,0) A67(68,0) A68(69,0) A69(70,0) A70(71,0) A71(72,0) A72(73,0) A73(74,0) A74(75,0) A75(76,0) A76(77,0) A77(78,0) A78(79,0) A79(80,0) A80(81,0) A81(82,0) A82(83,0) B1(0,0) B2(1,0) B3(2,0) B4(3,0) B5(4,0) B6(5,0) B7(6,0) B8(7,0) B9(8,0) B10(9,0) B11(10,0) B12(13,0) B13(14,0) B14(15,0) B15(16,0) B16(17,0) B17(18,0) B18(19,0) B19(20,0) B20(21,0) B21(22,0) B22(23,0) B23(24,0) B24(25,0) B25(26,0) B26(27,0) B27(28,0) B28(29,0) B29(30,0) B30(31,0) B31(32,0) B32(33,0) B33(34,0) B34(35,0) B35(36,0) B36(37,0) B37(38,0) B38(39,0) B39(40,0) B40(41,0) B41(42,0) B42(43,0) B43(44,0) B44(45,0) B45(46,0) B46(47,0) B47(48,0) B48(49,0) B49(50,0) B50(51,0) B51(52,0) B52(53,0) B53(54,0) B54(55,0) B55(56,0) B56(57,0) B57(58,0) B58(59,0) B59(60,0) B60(61,0) B61(62,0) B62(63,0) B63(64,0) B64(65,0) B65(66,0) B66(67,0) B67(68,0) B68(69,0) B69(70,0) B70(71,0) B71(72,0) B72(73,0) B73(74,0) B74(75,0) B75(76,0) B76(77,0) B77(78,0) B78(79,0) B79(80,0) B80(81,0) B81(82,0) B82(83,0)
POWER-SO8
  rect 0.635x1.6 smd: 1(-1.905,-2.8) 2(-0.635,-2.8) 3(0.635,-2.8) 4(1.905,-2.8)
  rect 4.674x4.775 smd: MB(0,1.213)
POWERFLAT_5X6
  rect 0.635x1.372 smd: 1(-1.905,-2.791) 2(-0.635,-2.791) 3(0.635,-2.791) 4(1.905,-2.791)
  custom 1.145x1.145 smd: 5(0,0)
QFN32L
  oval 0.787x0.279 smd: 1(-2.494,1.75) 2(-2.494,1.25) 3(-2.494,0.75) 4(-2.494,0.25) 5(-2.494,-0.25) 6(-2.494,-0.75) 7(-2.494,-1.25) 8(-2.494,-1.75) 17(2.494,-1.75) 18(2.494,-1.25) 19(2.494,-0.75) 20(2.494,-0.25) 21(2.494,0.25) 22(2.494,0.75) 23(2.494,1.25) 24(2.494,1.75)
  oval 0.279x0.787 smd: 9(-1.75,-2.494) 10(-1.25,-2.494) 11(-0.75,-2.494) 12(-0.25,-2.494) 13(0.25,-2.494) 14(0.75,-2.494) 15(1.25,-2.494) 16(1.75,-2.494) 25(1.75,2.494) 26(1.25,2.494) 27(0.75,2.494) 28(0.25,2.494) 29(-0.25,2.494) 30(-0.75,2.494) 31(-1.25,2.494) 32(-1.75,2.494)
  rect 3.404x3.404 smd: 33(0,0)
QFN56
  oval 0.813x0.279 smd: 1(-3.9,3.25) 2(-3.9,2.75) 3(-3.9,2.25) 4(-3.9,1.75) 5(-3.9,1.25) 6(-3.9,0.75) 7(-3.9,0.25) 8(-3.9,-0.25) 9(-3.9,-0.75) 10(-3.9,-1.25) 11(-3.9,-1.75) 12(-3.9,-2.25) 13(-3.9,-2.75) 14(-3.9,-3.25) 29(3.9,-3.25) 30(3.9,-2.75) 31(3.9,-2.25) 32(3.9,-1.75) 33(3.9,-1.25) 34(3.9,-0.75) 35(3.9,-0.25) 36(3.9,0.25) 37(3.9,0.75) 38(3.9,1.25) 39(3.9,1.75) 40(3.9,2.25) 41(3.9,2.75) 42(3.9,3.25)
  oval 0.279x0.813 smd: 15(-3.25,-3.9) 16(-2.75,-3.9) 17(-2.25,-3.9) 18(-1.75,-3.9) 19(-1.25,-3.9) 20(-0.75,-3.9) 21(-0.25,-3.9) 22(0.25,-3.9) 23(0.75,-3.9) 24(1.25,-3.9) 25(1.75,-3.9) 26(2.25,-3.9) 27(2.75,-3.9) 28(3.25,-3.9) 43(3.25,3.9) 44(2.75,3.9) 45(2.25,3.9) 46(1.75,3.9) 47(1.25,3.9) 48(0.75,3.9) 49(0.25,3.9) 50(-0.25,3.9) 51(-0.75,3.9) 52(-1.25,3.9) 53(-1.75,3.9) 54(-2.25,3.9) 55(-2.75,3.9) 56(-3.25,3.9)
  rect 5.842x5.842 smd: 57(0,0)
QFN-22
  rect 0.889x0.279 smd: 1(-1.944,2.29) 2(-1.944,1.79) 3(-1.944,1.29) 4(-1.944,0.79) 14(1.944,1.79) 15(1.944,2.29)
  rect 2.21x0.279 smd: 5(-1.284,0.29) 6(-1.284,-0.71) 7(-1.284,-1.71) 8(-1.284,-2.71) 9(1.284,-2.21) 10(1.284,-1.21) 11(1.284,-0.21) 13(1.284,1.29)
  rect 3.15x0.279 smd: 12(0.814,0.79)
  rect 0.279x0.889 smd: 16(1.5,3.195) 17(1,3.195) 18(0.5,3.195) 19(0,3.195) 20(-0.5,3.195) 21(-1,3.195) 22(-1.5,3.195)
QSFPDD_CAGE_UE36-C16221-06A3A
  round 1.575 hole 1.05: 1(0,0) 2(0,10.7) 3(0,19.7) 4(0,28.7) 5(0,37.7) 6(-19,-4.5) 7(-19,6.2) 8(-19,15.2) 9(-19,24.2) 10(-19,33.2) 11(-4.5,-20) 12(-11.7,-20)
QSH-030-01-C-D-A
  round 1.016 hole 1.016 unplated: (-10.065,2.67) (10.065,2.67)
  rect 0.279x2.286 smd: 1(-7.25,-2.865) 2(-7.25,2.865) 3(-6.75,-2.865) 4(-6.75,2.865) 5(-6.25,-2.865) 6(-6.25,2.865) 7(-5.75,-2.865) 8(-5.75,2.865) 9(-5.25,-2.865) 10(-5.25,2.865) 11(-4.75,-2.865) 12(-4.75,2.865) 13(-4.25,-2.865) 14(-4.25,2.865) 15(-3.75,-2.865) 16(-3.75,2.865) 17(-3.25,-2.865) 18(-3.25,2.865) 19(-2.75,-2.865) 20(-2.75,2.865) 21(-2.25,-2.865) 22(-2.25,2.865) 23(-1.75,-2.865) 24(-1.75,2.865) 25(-1.25,-2.865) 26(-1.25,2.865) 27(-0.75,-2.865) 28(-0.75,2.865) 29(-0.25,-2.865) 30(-0.25,2.865) 31(0.25,-2.865) 32(0.25,2.865) 33(0.75,-2.865) 34(0.75,2.865) 35(1.25,-2.865) 36(1.25,2.865) 37(1.75,-2.865) 38(1.75,2.865) 39(2.25,-2.865) 40(2.25,2.865) 41(2.75,-2.865) 42(2.75,2.865) 43(3.25,-2.865) 44(3.25,2.865) 45(3.75,-2.865) 46(3.75,2.865) 47(4.25,-2.865) 48(4.25,2.865) 49(4.75,-2.865) 50(4.75,2.865) 51(5.25,-2.865) 52(5.25,2.865) 53(5.75,-2.865) 54(5.75,2.865) 55(6.25,-2.865) 56(6.25,2.865) 57(6.75,-2.865) 58(6.75,2.865) 59(7.25,-2.865) 60(7.25,2.865)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
ROM7050PA
  rect 0.635x1.981 smd: 1(-1.27,-1.983)
  rect 0.635x1.524 smd: 2(0,-2.212) 3(1.27,-2.212) 6(1.27,2.212) 7(0,2.212) 8(-1.27,2.212)
  rect 1.549x0.838 smd: 4(3.175,-1.27) 5(3.175,1.27) 9(-3.175,1.27) 10(-3.175,-1.27)
S8
  rect 0.635x2.032 smd: 1(-1.905,-2.584) 2(-0.635,-2.584) 3(0.635,-2.584) 4(1.905,-2.584) 5(1.905,2.584) 6(0.635,2.584) 7(-0.635,2.584) 8(-1.905,2.584)
SC70-6
  rect 1.219x0.406 smd: 1(-1.01,0.65) 2(-1.01,0) 3(-1.01,-0.65) 4(1.01,-0.65) 5(1.01,0) 6(1.01,0.65)
SC70_TI
  rect 0.406x1.245 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SC75_SOT416
  rect 0.457x0.838 smd: 1(0.5,-0.869) 2(-0.5,-0.869) 3(0,0.869)
SHORT
  rect 0.305x0.406 smd: 1(0,0.254) 2(0,-0.254)
SI53254_QFN40
  oval 0.787x0.279 smd: 1(-2.994,2.25) 2(-2.994,1.75) 3(-2.994,1.25) 4(-2.994,0.75) 5(-2.994,0.25) 6(-2.994,-0.25) 7(-2.994,-0.75) 8(-2.994,-1.25) 9(-2.994,-1.75) 10(-2.994,-2.25) 21(2.994,-2.25) 22(2.994,-1.75) 23(2.994,-1.25) 24(2.994,-0.75) 25(2.994,-0.25) 26(2.994,0.25) 27(2.994,0.75) 28(2.994,1.25) 29(2.994,1.75) 30(2.994,2.25)
  oval 0.279x0.787 smd: 11(-2.25,-2.994) 12(-1.75,-2.994) 13(-1.25,-2.994) 14(-0.75,-2.994) 15(-0.25,-2.994) 16(0.25,-2.994) 17(0.75,-2.994) 18(1.25,-2.994) 19(1.75,-2.994) 20(2.25,-2.994) 31(2.25,2.994) 32(1.75,2.994) 33(1.25,2.994) 34(0.75,2.994) 35(0.25,2.994) 36(-0.25,2.994) 37(-0.75,2.994) 38(-1.25,2.994) 39(-1.75,2.994) 40(-2.25,2.994)
  rect 4.42x4.42 smd: 41(0,0)
SL1616A-R10MHF
  rect 1.956x1.905 smd: 1(-1.428,0) 2(1.428,0)
SMA_LTI-SASF546-P26-X1
  round 0.813 smd: 1(0,0)
  round 2.362 hole 1.6: 2(-2.54,2.54) 3(2.54,2.54) 4(-2.54,-2.54) 5(2.54,-2.54)
SMC0201IA
  rect 0.33x0.305 smd: 1(-0.267,0) 2(0.267,0)
SMT_OSC_3P2X5MM_4PIN
  rect 1.524x1.702 smd: 1(-1.27,-1.301) 2(1.27,-1.301) 3(1.27,1.301) 4(-1.27,1.301)
SMT_OSC_7X5MM_4PIN
  rect 1.803x2.007 smd: 1(-2.54,-2.003) 2(2.54,-2.003) 3(2.54,2.003) 4(-2.54,2.003)
SO8
  rect 2.032x0.635 smd: 1(-2.584,1.905) 2(-2.584,0.635) 3(-2.584,-0.635) 4(-2.584,-1.905) 5(2.584,-1.905) 6(2.584,-0.635) 7(2.584,0.635) 8(2.584,1.905)
SOD323
  rect 0.762x0.508 smd: 1(-1.281,0) 2(1.281,0)
SOD-80
  rect 1.194x1.778 smd: 1(-1.697,0) 2(1.697,0)
SOIC-8
  rect 2.032x0.635 smd: 1(-2.584,1.905) 2(-2.584,0.635) 3(-2.584,-0.635) 4(-2.584,-1.905) 5(2.584,-1.905) 6(2.584,-0.635) 7(2.584,0.635) 8(2.584,1.905)
SOT23
  rect 1.016x1.422 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
SOT-23-3
  rect 1.016x1.422 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
SOT-143
  rect 1.321x1.143 smd: 1(-1.06,0.762)
  rect 1.321x0.762 smd: 2(-1.06,-0.965) 3(1.06,-0.965) 4(1.06,0.965)
T-PBGA24
  round 0.406 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TSSOP16
  rect 0.406x1.651 smd: 1(-2.275,-2.876) 2(-1.625,-2.876) 3(-0.975,-2.876) 4(-0.325,-2.876) 5(0.325,-2.876) 6(0.975,-2.876) 7(1.625,-2.876) 8(2.275,-2.876) 9(2.275,2.876) 10(1.625,2.876) 11(0.975,2.876) 12(0.325,2.876) 13(-0.325,2.876) 14(-0.975,2.876) 15(-1.625,2.876) 16(-2.275,2.876)
TSSOP-14
  rect 1.499x0.406 smd: 1(-2.95,1.95) 2(-2.95,1.3) 3(-2.95,0.65) 4(-2.95,0) 5(-2.95,-0.65) 6(-2.95,-1.3) 7(-2.95,-1.95) 8(2.95,-1.95) 9(2.95,-1.3) 10(2.95,-0.65) 11(2.95,0) 12(2.95,0.65) 13(2.95,1.3) 14(2.95,1.95)
TVS_5P0SMDJ12A
  rect 2.438x3.454 smd: 1(3.378,0) 2(-3.378,0)
TX801_G320
  rect 1.321x1.092 smd: 1(-1.96,-1.221) 4(1.96,-1.221) 6(1.96,1.221) 9(-1.96,1.221)
  rect 0.66x1.397 smd: 2(-0.6,-1.074) 3(0.6,-1.074) 7(0.6,1.074) 8(-0.6,1.074)
  rect 1.321x0.66 smd: 5(1.96,0) 10(-1.96,0)
UE36-A1015-2000T
  round 1.549 hole 1.549 unplated: (-9.525,8.4) (-9.525,-8.4)
  oval 1.6x0.356 smd: 1(1.975,7) 2(1.975,6.2) 3(1.975,5.4) 4(1.975,4.6) 5(1.975,3.8) 6(1.975,3) 7(1.975,2.2) 8(1.975,1.4) 9(1.975,0.6) 10(1.975,-0.2) 11(1.975,-1) 12(1.975,-1.8) 13(1.975,-2.6) 14(1.975,-3.4) 15(1.975,-4.2) 16(1.975,-5) 17(1.975,-5.8) 18(1.975,-6.6) 19(1.975,-7.4) 20(10.765,-7) 21(10.765,-6.2) 22(10.765,-5.4) 23(10.765,-4.6) 24(10.765,-3.8) 25(10.765,-3) 26(10.765,-2.2) 27(10.765,-1.4) 28(10.765,-0.6) 29(10.765,0.2) 30(10.765,1) 31(10.765,1.8) 32(10.765,2.6) 33(10.765,3.4) 34(10.765,4.2) 35(10.765,5) 36(10.765,5.8) 37(10.765,6.6) 38(10.765,7.4) 39(4.905,7) 40(4.905,6.2) 41(4.905,5.4) 42(4.905,4.6) 43(4.905,3.8) 44(4.905,3) 45(4.905,2.2) 46(4.905,1.4) 47(4.905,0.6) 48(4.905,-0.2) 49(4.905,-1) 50(4.905,-1.8) 51(4.905,-2.6) 52(4.905,-3.4) 53(4.905,-4.2) 54(4.905,-5) 55(4.905,-5.8) 56(4.905,-6.6) 57(4.905,-7.4) 58(7.835,-7) 59(7.835,-6.2) 60(7.835,-5.4) 61(7.835,-4.6) 62(7.835,-3.8) 63(7.835,-3) 64(7.835,-2.2) 65(7.835,-1.4) 66(7.835,-0.6) 67(7.835,0.2) 68(7.835,1) 69(7.835,1.8) 70(7.835,2.6) 71(7.835,3.4) 72(7.835,4.2) 73(7.835,5) 74(7.835,5.8) 75(7.835,6.6) 76(7.835,7.4)
unnamed#2
  round 1.016 smd: 1(0,0)
unnamed#3
  round 0 smd: 1(0.02,0.198)
UQFN12
  rect 0.762x0.229 smd: 1(-0.731,0.8) 2(-0.731,0.4) 3(-0.731,0) 4(-0.731,-0.4) 5(-0.731,-0.8) 7(0.731,-0.8) 8(0.731,-0.4) 9(0.731,0) 10(0.731,0.4) 11(0.731,0.8)
  rect 0.229x0.762 smd: 6(0,-0.881) 12(0,0.881)
UQFN-16
  rect 0.203x0.889 smd: 1(-0.6,-0.843)
  rect 0.203x0.787 smd: 2(-0.2,-0.894) 3(0.2,-0.894) 4(0.6,-0.894) 9(0.6,0.894) 10(0.2,0.894) 11(-0.2,0.894) 12(-0.6,0.894)
  rect 0.787x0.203 smd: 5(1.294,-0.6) 6(1.294,-0.2) 7(1.294,0.2) 8(1.294,0.6) 13(-1.294,0.6) 14(-1.294,0.2) 15(-1.294,-0.2) 16(-1.294,-0.6)
VSON-9
  rect 0.406x0.762 smd: 1(-0.975,-1.481) 2(-0.325,-1.481) 3(0.325,-1.481) 4(0.975,-1.481) 5(0.975,1.481) 6(0.325,1.481) 7(-0.325,1.481) 8(-0.975,1.481)
  rect 2.489x1.422 smd: 9(0,0)
VSON-11
  custom 0.07x0.07 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 6(1,1.525) 7(0.5,1.525) 8(0,1.525) 9(-0.5,1.525) 10(-1,1.525)
  custom 0.412x0.412 smd: 11(0,0)
VSSOP8
  rect 0.279x1.016 smd: 1(-0.75,-1.512) 2(-0.25,-1.512) 3(0.25,-1.512) 4(0.75,-1.512) 5(0.75,1.512) 6(0.25,1.512) 7(-0.25,1.512) 8(-0.75,1.512)
WSOIC-8
  rect 0.635x2.032 smd: 1(-1.905,-3.466) 2(-0.635,-3.466) 3(0.635,-3.466) 4(1.905,-3.466) 5(1.905,3.466) 6(0.635,3.466) 7(-0.635,3.466) 8(-1.905,3.466)
WURTH_6X3P5_TACT_SWITCH
  rect 2.311x1.499 smd: 1(-3.355,0) 2(3.355,0)
XAL5030
  rect 1.651x4.699 smd: 1(-1.825,0) 2(1.825,0)
XAL6030
  rect 2.159x5.486 smd: 1(-2.179,0) 2(2.179,0)
XEL4030
  rect 1.651x3.708 smd: 1(-1.476,0) 2(1.476,0)
XTAL_FA-128
  rect 0.94x0.838 smd: 1(-0.725,-0.575) 2(0.725,-0.575) 3(0.725,0.575) 4(-0.725,0.575)
ZL30733
  round 1.016 smd: (-7.278,-8.421) (9.945,9.818)
  oval 0.838x0.279 smd: 1(-4.469,3.75) 2(-4.469,3.25) 3(-4.469,2.75) 4(-4.469,2.25) 5(-4.469,1.75) 6(-4.469,1.25) 7(-4.469,0.75) 8(-4.469,0.25) 9(-4.469,-0.25) 10(-4.469,-0.75) 11(-4.469,-1.25) 12(-4.469,-1.75) 13(-4.469,-2.25) 14(-4.469,-2.75) 15(-4.469,-3.25) 16(-4.469,-3.75) 33(4.469,-3.75) 34(4.469,-3.25) 35(4.469,-2.75) 36(4.469,-2.25) 37(4.469,-1.75) 38(4.469,-1.25) 39(4.469,-0.75) 40(4.469,-0.25) 41(4.469,0.25) 42(4.469,0.75) 43(4.469,1.25) 44(4.469,1.75) 45(4.469,2.25) 46(4.469,2.75) 47(4.469,3.25) 48(4.469,3.75)
  oval 0.279x0.838 smd: 17(-3.75,-4.469) 18(-3.25,-4.469) 19(-2.75,-4.469) 20(-2.25,-4.469) 21(-1.75,-4.469) 22(-1.25,-4.469) 23(-0.75,-4.469) 24(-0.25,-4.469) 25(0.25,-4.469) 26(0.75,-4.469) 27(1.25,-4.469) 28(1.75,-4.469) 29(2.25,-4.469) 30(2.75,-4.469) 31(3.25,-4.469) 32(3.75,-4.469) 49(3.75,4.469) 50(3.25,4.469) 51(2.75,4.469) 52(2.25,4.469) 53(1.75,4.469) 54(1.25,4.469) 55(0.75,4.469) 56(0.25,4.469) 57(-0.25,4.469) 58(-0.75,4.469) 59(-1.25,4.469) 60(-1.75,4.469) 61(-2.25,4.469) 62(-2.75,4.469) 63(-3.25,4.469) 64(-3.75,4.469)
  rect 5.105x5.105 smd: 65(0,0)
ZQSFP_CAGE_U95-T1C1-101A
  round 1.575 hole 1.05: 1(0,0) 2(0,-10.7) 3(0,9) 4(0,18) 5(0,27) 6(-19,22.5) 7(-19,13.5) 8(-19,4.5) 9(-19,-4.5) 10(-19,-15.2) 11(-4.5,-20.39) 12(-11.7,-20.39)

## Nets
0V6_DDR4_VREF_COMP: C197.1 C198.1 C243.1 C244.1 C289.1 C961.1 U15.J1 U16.J1 U17.J1 U18.J1 U19.J1 U78.6
0V6_DDR4_VREF_DIMM: C152.1 C157.1 C187.1 C191.1 C958.1 J4.146 J5.146 U77.6
0V6_DDR4_VTT_COMP: C946.2 C947.2 C948.2 C949.2 C950.2 C951.2 C957.2 C960.2 C1225.1 C1226.1 C1227.1 C1228.1 C1229.1 C1230.1 C1231.1 C1232.1 C1233.1 C1234.1 C1235.1 C1236.1 R167.1 R168.1 R169.1 R170.1 R171.1 R172.1 R174.1 R175.1 R176.1 R177.1 R178.1 R179.1 R180.1 R181.1 R182.1 R183.1 R184.1 R186.1 R187.1 R188.1 R189.1 R190.1 R191.1 R192.1 R193.1 R201.2 U8.AA21 U78.3 U78.5(VOSNS)
0V6_DDR4_VTT_DIMM: C144.2 C145.1 C153.1 C156.1 C159.1 C178.2 C179.1 C189.1 C190.1 C194.1 C939.2 C940.2 C941.2 C942.2 C943.2 C944.2 C956.2 C959.2 J4.77 J4.221 J5.77 J5.221 U8.CJ19 U8.CJ23 U8.CJ27 U8.CJ31 U77.3 U77.5(VOSNS)
1V8_SI53254_1: C420.2 C421.2 C422.2 C423.2 C424.2 C993.1 C994.1 C995.1 C996.1 C997.1 FB28.2 U26.1(VDD_DIG) U26.4 U26.9 U26.15 U26.18
1V8_SI53254_2: C432.2 C433.2 C434.2 C435.2 C436.2 C998.1 C999.1 C1000.1 C1001.1 C1002.1 FB29.2 U27.1(VDD_DIG) U27.4 U27.9 U27.15 U27.18
1V25_REF: D28.6(VOUT) R6903.2 R6905.1
2V5_DDR4_COMP: C199.1 C200.1 C201.2 C202.1 C203.1 C204.2 C245.1 C246.1 C247.2 C248.1 C249.1 C250.2 C290.1 C291.1 C292.2 C929.2 C933.2 C934.2 C935.2 R716.2 U15.B1 U15.M9 U16.B1 U16.M9 U17.B1 U17.M9 U18.B1 U18.M9 U19.B1 U19.M9 U76.1 U76.2(VOUT2)
2V5_DDR4_DIMM: C158.1 C160.2 C161.1 C162.1 C192.2 C193.1 C195.1 C196.1 C470.1 C473.2 C928.2 C930.2 C931.2 C932.2 J4.142 J4.143 J4.284 J4.286 J4.287 J5.142 J5.143 J5.284 J5.286 J5.287 R134.2 R135.2 R145.1 R150.2 R151.2 R152.2 R161.1 R376.2 R377.2 R383.2 R384.2 R385.1 R715.2 R6897.1 U38.2 U75.1 U75.2(VOUT2)
3V3_AGND: C1124.1 R1004.1 R6880.1 ST31.1 U95.C7 U95.D6 U95.F4 U95.F6 U95.F7(SGND6) U95.G6 U95.G7
3V3_QSFP: C325.2 C326.2 FB9.2 FB10.2 FB11.2 R221.1 U21.6 U21.7(OUT2)
3V3_QSFPDD: C307.1 C308.2 L1.1 L2.1 L3.1 R212.1 U20.6 U20.7(OUT2)
3V3_STBY: C64.2 C65.1 C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C98.2 C451.2 C456.2 C460.2 C487.1 C488.2 C648.1 C649.1 C650.1 C915.1 C926.1 C927.1 C938.2 C945.2 C976.1 C1018.2 C1021.2 C1105.2 C1106.2 C1107.2 C1110.2 C1111.2 C1112.2 D26.1 EU1.1(VDD) EU2.1(VDD) FB30.2 J3.4 Q18.MB R5.2 R6.1 R12.1 R55.2 R72.1 R77.1 R80.2 R81.2 R82.2 R83.1 R84.1 R85.1 R86.1 R87.1 R91.2 R92.2 R125.2 R206.2 R208.2 R241.2 R242.2 R243.2 R244.2 R245.2 R246.2 R263.2 R264.2 R326.1 R331.1 R340.2 R345.2 R399.2 R429.2 R430.2 R431.2 R432.2 R433.2 R434.2 R455.1 R460.2 R471.1 R478.2 R494.1 R495.1 R496.1 R503.1 R522.2 R523.1 R525.1 R609.2 R641.2 R663.1 R664.2 R704.1 R709.2 R717.1 R718.1 R725.1 R739.1 R741.1 R767.1 R777.1 R780.2 R808.2 R839.2 R840.2 R847.1 R848.1 R849.1 R1007.2 R6807.2 R6878.2 R6888.2 R6890.2 R6891.2 R6892.2 R6893.2 U5.C7 U5.D7 U5.D8 U5.F13 U5.G13 U5.H13 U5.J4 U5.J13 U5.N6 U5.N7 U5.N8 U6.14(V+) U7.1 U7.4(VDD) U33.19 U44.8 U45.8 U56.7 U56.9 U56.10 U57.7 U57.9 U57.10 U58.7 U58.9 U58.10 U60.5(VCC) U74.9 U74.10 U75.9 U75.10 U76.9 U76.10 U77.7 U77.10 U78.7 U78.10 U80.9 U80.10 U87.11 U88.11 U95.A1 U95.A2 U95.A3 U95.A4 U95.A5 U95.A8 U95.A9 U95.A10 U95.A11 U95.A12 U95.B1 U95.B2 U95.B3 U95.B4 U95.B5 U95.B8 U95.B9 U95.B10 U95.B11 U95.B12 U95.C1 U95.C2 U95.C3 U95.C4 U95.C9 U95.C10 U95.C11 U95.C12 U97.16(VCC)
3V3_STBY_PG: R507.1 R526.1 R869.2 U95.G8 U95.G9
3V3_SYS: C304.2 C305.2 C306.2 C322.2 C323.2 C324.2 C344.1 C345.2 C351.2 C358.2 C364.2 C366.2 C370.2 C379.2 C380.2 C386.2 C395.2 C400.2 C403.2 C406.2 C409.2 C444.1 C449.1 C471.2 C489.1 C688.1 C982.1 C1023.2 C1025.2 FB12.2 FB13.2 FB14.2 FB15.2 FB16.2 FB17.2 FB19.2 FB20.2 FB21.2 FB22.2 FB23.2 FB24.2 FB25.2 FB26.2 FB41.1 Q18.1 Q18.2 Q18.3 R211.2 R215.2 R217.2 R218.2 R220.2 R368.2 R369.2 R378.2 R379.2 R380.1 R400.2 R401.2 R402.2 R403.2 R404.2 R405.2 R406.2 R407.2 R411.2 R417.2 R422.1 R439.2 R440.2 R441.2 R744.1 R784.2 R785.2 R789.2 R6894.2 U20.2 U20.3 U21.2 U21.3 U22.14 U28.5(VCC) U31.5(VCC) U46.8 U81.7 U81.9 U81.10 U89.11 U90.11
3V3_SYS_PG: R525.2 R527.1 U60.1
3V3_USBPHY: C490.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.2 C501.2 C502.2 C503.2 FB30.1 R446.1 R451.2 R452.2 U47.4(VCC) U49.3 U49.7 U49.11 U49.17 U49.27 U49.32 U49.43 U49.55
3VBAT: BT1.1(POS) D27.1
5V0: C709.1 C727.1 C745.1 C763.1 C781.1 C1099.1 C1100.1 C1101.1 C1102.1 C1202.1 R394.2 R569.1 R577.1 R585.1 R593.1 R601.1 R6877.1 U62.28 U62.29 U63.28 U63.29 U64.28 U64.29 U65.28 U65.29 U66.28 U66.29 U94.C1 U94.D1 U94.D2 U94.E1 U94.E2(VOUT_E2)
5V0_AGND: C1093.2 C1103.1 C1200.2 C1201.1 R862.2 R864.2 R866.1 R868.1 ST30.1 U94.B4
5V0_PG: R863.2 R864.1 U94.C2 U95.F5 U95.F9
12V_AUX: C607.2 C608.2 C615.1 C616.1 C617.1 C618.1 C619.1 C620.1 D15.1(C) J11.1 J11.2 J11.3 R464.1 R472.1 U54.9 U54.10 U54.11 U54.12
12V_AUX_IN: C625.1 C626.1 C629.2 C692.1 C695.1 C702.2 C703.1 C704.1 C705.1 C706.1 C707.1 C714.1 C715.1 C716.1 C717.1 C718.1 C719.1 C720.1 C721.1 C723.2 C724.1 C725.1 C726.1 C732.1 C733.1 C734.1 C735.1 C736.1 C737.1 C738.2 C739.1 C740.1 C741.1 C743.1 C744.1 C750.1 C751.1 C752.1 C753.1 C754.1 C755.1 C756.2 C757.1 C758.1 C759.1 C760.1 C761.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C1096.1 C1097.1 C1098.2 D16.5(C) J2.2 Q16.1 Q16.2 Q16.3(S3) R468.1 R531.1 R863.1 R865.1 R6839.2 U53.2 U53.4 U54.5 U54.6 U54.7 U54.8(VOUT4) U62.20 U62.21 U62.37 U62.38 U62.43(VIN#43) U63.20 U63.21 U63.37 U63.38 U63.43(VIN#43) U64.20 U64.21 U64.37 U64.38 U64.43(VIN#43) U65.20 U65.21 U65.37 U65.38 U65.43(VIN#43) U94.D5 U94.E5
12V_PCIE_HSC: C602.1 C603.1 C606.2 D14.5(C) U50.5 U50.6 U50.7 U50.8(VOUT4) U51.1 U51.2 U51.3(S3) U52.2
12V_PCIE_IN: C295.1 C296.1 C614.1 C775.2 C776.1 C777.1 C778.1 C779.1 C780.1 C786.1 C787.1 C788.1 C789.1 C790.1 C791.1 C1084.1 C1085.1 C1086.1 C1087.1 C1091.1 C1115.1 C1116.1 C1117.1 C1118.1 C1120.2 C1121.2 C1122.1 C1159.1 C1160.1 C1161.1 C1162.1 C1164.2 C1165.2 C1176.1 C1205.2 C1206.2 J6.1 J6.60 Q16.5 R131.1 R132.1 R147.1 R148.1 R1005.1 R1006.2 R6802.2 U51.5 U52.1 U52.6(VDD) U53.8 U66.20 U66.21 U66.37 U66.38 U66.43(VIN#43) U93.B9 U93.B10 U93.G6 U93.G7 U93.G8 U93.G9 U93.G10 U93.H1 U93.H2 U93.H6 U93.H7 U93.J1 U93.J2 U93.J6 U93.J7 U93.K1 U93.K2 U93.K6 U93.K7 U93.L1 U93.L2 U93.L6 U93.L7 U93.M1 U93.M2 U93.M6 U93.M7 U95.J2 U95.J3 U95.J4 U95.J9 U95.J10 U95.J11 U95.K2 U95.K3 U95.K4 U95.K9 U95.K10 U95.K11 U95.L2 U95.L3 U95.L4 U95.L5 U95.L6 U95.L7 U95.L8 U95.L9 U95.L10 U95.L11 U95.M2 U95.M3 U95.M4 U95.M5 U95.M6 U95.M7 U95.M8 U95.M9 U95.M10 U95.M11 U96.B9 U96.B10 U96.G6 U96.G7 U96.G8 U96.G9 U96.G10 U96.H1 U96.H2 U96.H6 U96.H7 U96.J1 U96.J2 U96.J6 U96.J7 U96.K1 U96.K2 U96.K6 U96.K7 U96.L1 U96.L2 U96.L6 U96.L7 U96.M1 U96.M2 U96.M6 U96.M7
GND: BT1.2 C37.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.1 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.1 C93.2 C94.2 C95.2 C96.2 C97.2 C98.1 C99.1 C100.1 C101.1 C107.1 C108.1 C109.2 C110.1 C111.2 C112.1 C113.1 C114.1 C115.1 C116.2 C117.2 C118.1 C119.2 C120.2 C121.1 C123.1 C124.2 C125.2 C126.2 C127.2 C128.1 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.1 C145.2 C146.1 C147.1 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.1 C161.2 C162.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.1 C179.2 C180.1 C181.1 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.1 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.1 C202.2 C203.2 C204.1 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.1 C223.1 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.1 C248.2 C249.2 C250.1 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.1 C269.1 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.1 C293.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.1 C305.1 C306.1 C307.2 C308.1 C309.2 C310.1 C311.1 C312.1 C313.2 C314.1 C315.1 C316.1 C317.2 C318.1 C319.1 C320.1 C321.2 C322.1 C323.1 C324.1 C325.1 C326.1 C327.1 C328.1 C329.1 C330.1 C331.1 C332.1 C333.1 C334.1 C335.1 C336.1 C337.1 C338.1 C339.2 C344.2 C345.1 C346.1 C351.1 C352.1 C353.1 C354.1 C355.1 C356.1 C357.1 C358.1 C359.1 C360.1 C361.1 C362.1 C363.1 C364.1 C365.1 C366.1 C367.1 C368.1 C369.1 C370.1 C371.1 C372.1 C373.1 C374.1 C375.1 C376.1 C377.1 C378.1 C379.1 C380.1 C381.1 C382.1 C383.1 C384.1 C385.1 C386.1 C394.1 C395.1 C397.1 C398.1 C399.1 C400.1 C401.1 C402.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.1 C410.2 C411.2 C412.1 C413.1 C414.1 C415.2 C416.2 C417.2 C418.2 C420.1 C421.1 C422.1 C423.1 C424.1 C432.1 C433.1 C434.1 C435.1 C436.1 C444.2 C449.2 C451.1 C456.1 C460.1 C461.1 C466.2 C467.1 C470.2 C471.1 C472.2 C473.1 C482.1 C483.1 C484.2 C485.1 C486.1 C487.2 C488.1 C489.2 C490.1 C491.2 C492.2 C493.2 C494.2 C495.1 C496.1 C497.1 C498.1 C499.1 C500.1 C501.1 C502.1 C503.1 C504.2 C505.2 C506.2 C507.2 C508.2 C509.2 C510.2 C511.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C521.2 C522.1 C523.1 C524.2 C525.1 C526.1 C527.1 C528.1 C529.1 C530.1 C533.2 C534.2 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.1 C543.1 C544.1 C545.2 C546.2 C548.2 C549.2 C550.1 C551.1 C552.1 C561.1 C562.1 C571.1 C572.2 C573.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.1 C581.1 C582.2 C583.2 C584.2 C585.2 C586.2 C587.2 C588.1 C589.1 C590.1 C591.1 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.2 C599.1 C600.2 C601.2 C603.2 C604.2 C605.2 C607.1 C608.1 C609.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.1 C622.2 C623.2 C624.2 C626.2 C627.2 C628.2 C648.2 C649.2 C650.2 C652.1 C653.1 C654.1 C656.1 C657.1 C658.1 C660.1 C661.1 C662.1 C663.2 C664.2 C665.2 C688.2 C689.1 C690.1 C692.2 C693.2 C695.2 C702.1 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.1 C724.2 C725.2 C726.2 C727.2 C728.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.1 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C749.2 C750.2 C751.2 C752.2 C753.2 C754.2 C755.2 C756.1 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.1 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C864.2 C866.1 C867.1 C868.1 C869.2 C915.2 C921.1 C922.1 C923.1 C925.2 C926.2 C927.2 C930.1 C931.1 C932.1 C933.1 C934.1 C935.1 C936.2 C937.2 C938.1 C939.1 C940.1 C941.1 C942.1 C943.1 C944.1 C945.1 C946.1 C947.1 C948.1 C949.1 C950.1 C951.1 C952.1 C953.1 C954.1 C955.1 C956.1 C957.1 C958.2 C959.1 C960.1 C961.2 C962.2 C963.2 C966.2 C967.2 C968.2 C969.2 C970.2 C971.2 C972.2 C973.2 C974.2 C975.2 C976.2 C978.1 C979.1 C980.1 C981.2 C982.2 C984.1 C985.1 C986.1 C987.2 C988.1 C989.1 C990.2 C991.2 C992.2 C993.2 C994.2 C995.2 C996.2 C997.2 C998.2 C999.2 C1000.2 C1001.2 C1002.2 C1003.1 C1018.1 C1019.2 C1020.2 C1021.1 C1022.2 C1023.1 C1024.2 C1025.1 C1026.1 C1031.2 C1032.2 C1033.2 C1034.2 C1035.2 C1036.2 C1037.2 C1038.2 C1039.2 C1040.2 C1041.2 C1042.2 C1043.2 C1044.1 C1045.1 C1046.1 C1047.1 C1048.1 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1055.2 C1056.2 C1057.2 C1058.2 C1059.2 C1060.2 C1061.2 C1062.2 C1063.2 C1064.2 C1065.2 C1066.2 C1067.2 C1068.2 C1069.2 C1070.2 C1071.2 C1072.1 C1073.2 C1074.1 C1075.1 C1076.1 C1077.1 C1078.1 C1079.1 C1084.2 C1085.2 C1086.2 C1087.2 C1091.2 C1092.2 C1096.2 C1097.2 C1098.1 C1099.2 C1100.2 C1101.2 C1102.2 C1105.1 C1106.1 C1107.1 C1110.1 C1111.1 C1112.1 C1115.2 C1116.2 C1117.2 C1118.2 C1120.1 C1121.1 C1122.2 C1123.1 C1127.1 C1128.1 C1129.1 C1132.1 C1133.1 C1134.1 C1135.1 C1136.2 C1138.1 C1139.1 C1142.1 C1143.1 C1144.1 C1145.1 C1146.2 C1154.2 C1157.1 C1159.2 C1160.2 C1161.2 C1162.2 C1164.1 C1165.1 C1166.1 C1167.1 C1170.1 C1171.1 C1172.1 C1173.1 C1174.2 C1176.2 C1181.1 C1182.1 C1185.1 C1186.1 C1187.1 C1188.1 C1189.2 C1194.2 C1195.2 C1196.2 C1197.1 C1198.2 C1199.1 C1203.2 C1204.2 C1205.1 C1206.1 C1208.2 C1216.2 C1218.2 C1224.1 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1233.2 C1234.2 C1235.2 C1236.2 C1237.1 C1238.2 C1239.2 C1240.2 C1241.2 C1242.2 C1243.2 C1244.2 C1245.2 C1246.2 C1247.2 C1248.2 C1249.2 C1250.2 C1251.2 C1252.2 C1253.2 C1254.2 C1255.2 C1256.2 C1257.2 C1258.2 C1259.2 C1260.1 C1261.1 C1262.1 C1263.1 C1264.1 C1265.1 C1266.1 C1267.1 C1268.1 C1269.1 C1270.1 C1271.1 C1272.1 C1273.1 C1274.1 C1275.1 C1276.1 C1277.1 C1278.1 C1279.1 C1280.1 C1281.1 C1282.1 C1283.1 C1284.1 C1285.1 C1286.1 C1287.1 C1288.1 C1289.1 COUT1.2 COUT2.2 COUT3.2 COUT4.2 COUT5.2 COUT6.2 COUT7.2 COUT8.2 COUT9.2 COUT10.2 COUT11.2 COUT12.2 COUT13.2 COUT14.2 COUT15.2 COUT16.2 COUT17.2 COUT18.2 COUT19.2 COUT20.2 COUT21.2 COUT22.2 COUT23.2 COUT24.2 COUT25.2 COUT26.2 COUT27.2 COUT28.2 COUT29.2 COUT30.2 COUT31.2 COUT32.2 COUT33.2 COUT34.2 COUT35.2 COUT36.2 COUT37.2 COUT39.2 D13.2 D14.1 D14.2 D14.3 D14.4 D15.2 D16.1 D16.2 D16.3 D16.4 D28.4 D28.5 EU1.8 EU1.13 EU2.8 EU2.13 J1.A4 J1.A12 J1.A15 J1.A18 J1.A20 J1.A23 J1.A24 J1.A27 J1.A28 J1.A31 J1.A34 J1.A37 J1.A38 J1.A41 J1.A42 J1.A45 J1.A46 J1.A49 J1.A51 J1.A54 J1.A55 J1.A58 J1.A59 J1.A62 J1.A63 J1.A66 J1.A67 J1.A70 J1.A71 J1.A74 J1.A75 J1.A78 J1.A79 J1.A82 J1.B4 J1.B7 J1.B13 J1.B16 J1.B18 J1.B21 J1.B22 J1.B25 J1.B26 J1.B29 J1.B32 J1.B35 J1.B36 J1.B39 J1.B40 J1.B43 J1.B44 J1.B47 J1.B49 J1.B52 J1.B53 J1.B56 J1.B57 J1.B60 J1.B61 J1.B64 J1.B65 J1.B68 J1.B69 J1.B72 J1.B73 J1.B76 J1.B77 J1.B80 J2.1 J3.10 J4.2 J4.4 J4.6 J4.9 J4.11 J4.13 J4.15 J4.17 J4.20 J4.22 J4.24 J4.26 J4.28 J4.31 J4.33 J4.35 J4.37 J4.39 J4.42 J4.44 J4.46 J4.48 J4.50 J4.53 J4.55 J4.57 J4.94 J4.96 J4.98 J4.101 J4.103 J4.105 J4.107 J4.109 J4.112 J4.114 J4.116 J4.118 J4.120 J4.123 J4.125 J4.127 J4.129 J4.131 J4.134 J4.136 J4.138 J4.147 J4.149 J4.151 J4.154 J4.156 J4.158 J4.160 J4.162 J4.165 J4.167 J4.169 J4.171 J4.173 J4.176 J4.178 J4.180 J4.182 J4.184 J4.187 J4.189 J4.191 J4.193 J4.195 J4.198 J4.200 J4.202 J4.235 J4.239 J4.241 J4.243 J4.246 J4.248 J4.250 J4.252 J4.254 J4.257 J4.259 J4.261 J4.263 J4.265 J4.268 J4.270 J4.272 J4.274 J4.276 J4.279 J4.281 J4.283 J5.2 J5.4 J5.6 J5.9 J5.11 J5.13 J5.15 J5.17 J5.20 J5.22 J5.24 J5.26 J5.28 J5.31 J5.33 J5.35 J5.37 J5.39 J5.42 J5.44 J5.46 J5.48 J5.50 J5.53 J5.55 J5.57 J5.94 J5.96 J5.98 J5.101 J5.103 J5.105 J5.107 J5.109 J5.112 J5.114 J5.116 J5.118 J5.120 J5.123 J5.125 J5.127 J5.129 J5.131 J5.134 J5.136 J5.138 J5.147 J5.149 J5.151 J5.154 J5.156 J5.158 J5.160 J5.162 J5.165 J5.167 J5.169 J5.171 J5.173 J5.176 J5.178 J5.180 J5.182 J5.184 J5.187 J5.189 J5.191 J5.193 J5.195 J5.198 J5.200 J5.202 J5.235 J5.239 J5.241 J5.243 J5.246 J5.248 J5.250 J5.252 J5.254 J5.257 J5.259 J5.261 J5.263 J5.265 J5.268 J5.270 J5.272 J5.274 J5.276 J5.279 J5.281 J5.283 J6.61 J6.62 J6.63 J6.64(GND4) J7.1 J7.4 J7.7 J7.13 J7.16 J7.19 J7.20 J7.23 J7.26 J7.32 J7.35 J7.38 J7.39 J7.42 J7.45 J7.51 J7.54 J7.57 J7.58 J7.61 J7.64 J7.70 J7.73 J7.76 J8.1 J8.4 J8.7 J8.13 J8.16 J8.19 J8.20 J8.23 J8.26 J8.32 J8.35 J8.38 J9.A1 J9.A4 J9.A7 J9.A10 J9.A13 J9.A16 J9.A19 J9.A22 J9.A25 J9.A28 J9.A31 J9.A34 J9.A37 J9.B1 J9.B4 J9.B7 J9.B10 J9.B13 J9.B16 J9.B19 J9.B22 J9.B25 J9.B28 J9.B31 J9.B34 J9.B37 J9.MH1 J9.MH2 J9.MH3 J9.MH4 J10.5 J11.4(SENSE1) J11.5 J11.6 J11.7 J11.8 J12.2 J13.2 J14.2 J14.3 J14.4 J14.5 J15.2 J15.3 J15.4 J15.5 J105.2 J106.2 J107.2 MTH4.1(GND) MTH6.1(GND) MTH11.1(GND) Q1.2(SOURCE) Q2.3 Q3.3 Q4.2(SOURCE) Q7.2(SOURCE) Q8.2(SOURCE) Q9.2(SOURCE) Q10.2(SOURCE) Q11.2(SOURCE) Q12.2(SOURCE) Q13.2(SOURCE) Q14.2(SOURCE) Q15.2(SOURCE) Q17.2(SOURCE) Q19.2(SOURCE) Q20.2(SOURCE) R13.2 R14.2 R15.2 R16.2 R17.2 R18.2 R19.2 R20.2 R21.2 R22.2 R23.2 R28.1 R29.1 R30.1 R31.1 R56.1 R57.1 R58.1 R59.1 R73.1 R74.1 R75.1 R76.1 R78.2 R90.2 R94.2 R99.1 R100.1 R101.1 R102.1 R104.1 R108.1 R109.1 R110.1 R114.1 R115.1 R116.1 R117.2 R118.2 R136.1 R137.1 R138.1 R140.1 R141.1 R142.1 R153.1 R154.1 R156.1 R157.1 R158.1 R163.1 R164.1 R165.1 R166.1 R173.1 R196.1 R198.1 R199.2 R209.2 R210.2 R212.2 R213.2 R214.1 R219.1 R221.2 R222.2 R223.1 R224.1 R234.2 R235.2 R236.2 R237.2 R239.1 R256.1 R257.1 R258.1 R259.1 R260.1 R261.1 R262.1 R265.2 R267.2 R269.2 R270.2 R274.2 R281.2 R285.2 R287.2 R292.1 R294.1 R295.2 R296.1 R297.1 R299.2 R301.2 R307.1 R308.1 R309.1 R314.1 R316.1 R317.2 R318.1 R319.1 R321.2 R323.2 R334.2 R343.1 R352.2 R359.1 R395.1 R398.2 R417.1 R426.1 R435.1 R436.1 R437.1 R438.2 R442.2 R443.1 R444.1 R445.1 R448.1 R449.1 R450.1 R453.2 R458.2 R459.2 R461.1 R462.1 R463.2 R465.2 R470.1 R475.2 R476.2 R477.1 R479.1 R480.2 R500.2 R501.2 R502.2 R524.1 R541.1 R614.1 R668.2 R708.2 R719.2 R720.2 R723.2 R724.2 R743.2 R746.2 R753.1 R754.1 R755.2 R756.2 R757.2 R758.2 R761.1 R762.1 R769.2 R770.1 R771.1 R815.1 R816.1 R817.1 R818.1 R822.1 R823.1 R824.1 R825.1 R833.1 R834.1 R836.1 R837.1 R6840.2 R6841.2 R6858.1 R6860.1 R6870.1 R6872.1 R6879.2 R6887.1 R6889.1 R6896.1 R6897.2 R6900.1 R6921.1 R6922.1 R6923.1 R6924.1 R6925.2 R6926.2 R6927.2 R6928.2 R6930.2 R6931.2 R6932.2 R6933.2 R6934.2 R6935.2 R6936.2 R6937.2 R6938.2 R6939.2 S1.1 S2.1 S3.1 S4.1 S6.1 ST7.1 ST8.1 ST9.1 ST10.1 ST11.1 ST14.1 ST20.2 ST30.2 ST31.2 ST34.2 SW2.2(B1) SW6.2(B1) U2.4 U3.B3 U4.B3 U5.A1 U5.A16 U5.B14 U5.C8 U5.C11 U5.D2 U5.D3 U5.D6 U5.E2 U5.E6 U5.E13 U5.F3 U5.F15 U5.G3 U5.G8 U5.G10 U5.H7 U5.H14 U5.J10 U5.K1 U5.K3 U5.K7 U5.K9 U5.K16 U5.L14 U5.M4 U5.N9 U5.N12 U5.N15 U5.P3 U5.P7 U5.R13 U5.T1 U5.T10 U5.T16 U6.6 U6.13 U7.2 U8.A3 U8.A5 U8.A51 U8.A53 U8.AA9 U8.AA11 U8.AA13 U8.AA15 U8.AA19 U8.AA25 U8.AA29 U8.AA33 U8.AA37 U8.AA39 U8.AA41 U8.AA43 U8.AA45 U8.AA47 U8.AA49 U8.AA53 U8.AA55 U8.AB18 U8.AB20 U8.AB22 U8.AB24 U8.AB26 U8.AB28 U8.AB30 U8.AB32 U8.AB34 U8.AB36 U8.AB38 U8.AB40 U8.AB44 U8.AB46 U8.AB48 U8.AB50 U8.AB54 U8.AC1 U8.AC3 U8.AC5 U8.AC7 U8.AC25 U8.AC27 U8.AC29 U8.AC31 U8.AC33 U8.AC39 U8.AC45 U8.AC51 U8.AC53 U8.AD4 U8.AD16 U8.AD20 U8.AD22 U8.AD24 U8.AD26 U8.AD28 U8.AD30 U8.AD32 U8.AD34 U8.AD36 U8.AD38 U8.AD40 U8.AD42 U8.AD44 U8.AD50 U8.AD52 U8.AE3 U8.AE5 U8.AE9 U8.AE11 U8.AE13 U8.AE15 U8.AE25 U8.AE27 U8.AE29 U8.AE31 U8.AE33 U8.AE39 U8.AE41 U8.AE45 U8.AE47 U8.AE53 U8.AE55 U8.AF2 U8.AF6 U8.AF20 U8.AF24 U8.AF28 U8.AF32 U8.AF36 U8.AF38 U8.AF40 U8.AF42 U8.AF44 U8.AF46 U8.AF48 U8.AF50 U8.AF54 U8.AG1 U8.AG3 U8.AG29 U8.AG41 U8.AG43 U8.AG47 U8.AG51 U8.AG53 U8.AH4 U8.AH6 U8.AH18 U8.AH22 U8.AH26 U8.AH30 U8.AH34 U8.AH44 U8.AH46 U8.AH50 U8.AH52 U8.AJ3 U8.AJ5 U8.AJ29 U8.AJ43 U8.AJ47 U8.AJ53 U8.AJ55 U8.AK2 U8.AK6 U8.AK8 U8.AK10 U8.AK12 U8.AK14 U8.AK16 U8.AK20 U8.AK26 U8.AK32 U8.AK38 U8.AK44 U8.AK46 U8.AK50 U8.AK54 U8.AL1 U8.AL3 U8.AL7 U8.AL9 U8.AL21 U8.AL27 U8.AL33 U8.AL39 U8.AL43 U8.AL45 U8.AL47 U8.AL51 U8.AL53 U8.AM4 U8.AM6 U8.AM22 U8.AM28 U8.AM34 U8.AM40 U8.AM44 U8.AM46 U8.AM50 U8.AM52 U8.AN3 U8.AN5 U8.AN9 U8.AN17 U8.AN23 U8.AN29 U8.AN35 U8.AN47 U8.AN49 U8.AN53 U8.AN55 U8.AP2 U8.AP6 U8.AP8 U8.AP18 U8.AP24 U8.AP30 U8.AP36 U8.AP48 U8.AP50 U8.AP54 U8.AR1 U8.AR3 U8.AR7 U8.AR9 U8.AR11 U8.AR13 U8.AR15 U8.AR19 U8.AR37 U8.AR43 U8.AR45 U8.AR47 U8.AR51 U8.AR53 U8.AT4 U8.AT6 U8.AT20 U8.AT38 U8.AT40 U8.AT48 U8.AT50 U8.AT52 U8.AU3 U8.AU5 U8.AU9 U8.AU21 U8.AU39 U8.AU47 U8.AU53 U8.AU55 U8.AV2 U8.AV6 U8.AV8 U8.AV10 U8.AV12 U8.AV14 U8.AV16 U8.AV50 U8.AV54 U8.AW1 U8.AW3 U8.AW7 U8.AW9 U8.AW15 U8.AW17 U8.AW35 U8.AW43 U8.AW45 U8.AW47 U8.AW51 U8.AW53 U8.AY4 U8.AY6 U8.AY16 U8.AY18 U8.AY36 U8.AY40 U8.AY48 U8.AY50 U8.AY52 U8.B2 U8.B4 U8.B52 U8.B54 U8.BA3 U8.BA5 U8.BA9 U8.BA19 U8.BA37 U8.BA47 U8.BA53 U8.BA55 U8.BB2 U8.BB6 U8.BB8 U8.BB16 U8.BB20 U8.BB38 U8.BB48 U8.BB50 U8.BB54 U8.BC1 U8.BC3 U8.BC7 U8.BC9 U8.BC11 U8.BC13 U8.BC21 U8.BC39 U8.BC43 U8.BC45 U8.BC47 U8.BC51 U8.BC53 U8.BD4 U8.BD6 U8.BD8 U8.BD40 U8.BD48 U8.BD50 U8.BD52 U8.BE3 U8.BE5 U8.BE7 U8.BE9 U8.BE17 U8.BE35 U8.BE47 U8.BE53 U8.BE55 U8.BF2 U8.BF6 U8.BF8 U8.BF16 U8.BF18 U8.BF36 U8.BF50 U8.BF54 U8.BG1 U8.BG3 U8.BG7 U8.BG9 U8.BG11 U8.BG13 U8.BG19 U8.BG37 U8.BG43 U8.BG45 U8.BG47 U8.BG51 U8.BG53 U8.BH4 U8.BH6 U8.BH8 U8.BH20 U8.BH38 U8.BH40 U8.BH48 U8.BH50 U8.BH52 U8.BJ3 U8.BJ5 U8.BJ7 U8.BJ9 U8.BJ21 U8.BJ39 U8.BJ47 U8.BJ49 U8.BJ53 U8.BJ55 U8.BK2 U8.BK6 U8.BK8 U8.BK16 U8.BK48 U8.BK50 U8.BK54 U8.BL1 U8.BL3 U8.BL9 U8.BL11 U8.BL13 U8.BL17 U8.BL35 U8.BL43 U8.BL45 U8.BL47 U8.BL51 U8.BL53 U8.BM4 U8.BM6 U8.BM8 U8.BM18 U8.BM36 U8.BM42 U8.BM50 U8.BM52 U8.BN3 U8.BN5 U8.BN7 U8.BN9 U8.BN19 U8.BN37 U8.BN41 U8.BN47 U8.BN49 U8.BN53 U8.BN55 U8.BP2 U8.BP6 U8.BP8 U8.BP16 U8.BP20 U8.BP38 U8.BP42 U8.BP44 U8.BP46 U8.BP48 U8.BP50 U8.BP54 U8.BR1 U8.BR3 U8.BR9 U8.BR11 U8.BR13 U8.BR21 U8.BR39 U8.BR45 U8.BR47 U8.BR51 U8.BR53 U8.BT4 U8.BT6 U8.BT8 U8.BT22 U8.BT28 U8.BT34 U8.BT40 U8.BT46 U8.BT50 U8.BT52 U8.BU3 U8.BU5 U8.BU9 U8.BU17 U8.BU23 U8.BU29 U8.BU35 U8.BU41 U8.BU43 U8.BU45 U8.BU47 U8.BU49 U8.BU53 U8.BU55 U8.BV2 U8.BV6 U8.BV8 U8.BV16 U8.BV18 U8.BV24 U8.BV30 U8.BV36 U8.BV42 U8.BV44 U8.BV46 U8.BV48 U8.BV50 U8.BV54 U8.BW1 U8.BW3 U8.BW7 U8.BW9 U8.BW11 U8.BW13 U8.BW19 U8.BW25 U8.BW31 U8.BW37 U8.BW45 U8.BW47 U8.BW51 U8.BW53 U8.BY4 U8.BY6 U8.BY10 U8.BY12 U8.BY16 U8.BY20 U8.BY26 U8.BY32 U8.BY38 U8.BY42 U8.BY50 U8.BY52 U8.C1 U8.C3 U8.C7 U8.C9 U8.C11 U8.C13 U8.C15 U8.C17 U8.C19 U8.C21 U8.C23 U8.C25 U8.C27 U8.C29 U8.C31 U8.C33 U8.C35 U8.C37 U8.C39 U8.C41 U8.C43 U8.C45 U8.C47 U8.C49 U8.C51 U8.C53 U8.C55 U8.CA3 U8.CA5 U8.CA9 U8.CA13 U8.CA39 U8.CA41 U8.CA47 U8.CA49 U8.CA53 U8.CA55 U8.CB2 U8.CB6 U8.CB10 U8.CB16 U8.CB20 U8.CB24 U8.CB28 U8.CB32 U8.CB38 U8.CB48 U8.CB50 U8.CB54 U8.CC1 U8.CC3 U8.CC9 U8.CC11 U8.CC13 U8.CC17 U8.CC35 U8.CC51 U8.CC53 U8.CD4 U8.CD6 U8.CD10 U8.CD14 U8.CD16 U8.CD18 U8.CD22 U8.CD26 U8.CD30 U8.CD34 U8.CD36 U8.CD40 U8.CD42 U8.CD44 U8.CD46 U8.CD52 U8.CE3 U8.CE5 U8.CE9 U8.CE11 U8.CE15 U8.CE17 U8.CE35 U8.CE41 U8.CE53 U8.CE55 U8.CF2 U8.CF6 U8.CF8 U8.CF10 U8.CF12 U8.CF16 U8.CF18 U8.CF20 U8.CF22 U8.CF24 U8.CF26 U8.CF28 U8.CF30 U8.CF32 U8.CF34 U8.CF36 U8.CF52 U8.CF54 U8.CG1 U8.CG3 U8.CG9 U8.CG15 U8.CG17 U8.CG35 U8.CG43 U8.CG49 U8.CG51 U8.CG53 U8.CG55 U8.CH4 U8.CH6 U8.CH8 U8.CH12 U8.CH14 U8.CH18 U8.CH20 U8.CH22 U8.CH24 U8.CH26 U8.CH28 U8.CH30 U8.CH32 U8.CH34 U8.CH36 U8.CH38 U8.CH40 U8.CH52 U8.CH54 U8.CJ3 U8.CJ5 U8.CJ7 U8.CJ11 U8.CJ13 U8.CJ17 U8.CJ35 U8.CJ37 U8.CJ39 U8.CJ43 U8.CJ45 U8.CJ47 U8.CJ49 U8.CJ51 U8.CJ55 U8.CK2 U8.CK6 U8.CK8 U8.CK54 U8.CL1 U8.CL3 U8.CL7 U8.CL9 U8.CL11 U8.CL53 U8.CL55 U8.CM4 U8.CM6 U8.CM10 U8.CM12 U8.CM14 U8.CM16 U8.CM18 U8.CM20 U8.CM22 U8.CM24 U8.CM26 U8.CM28 U8.CM30 U8.CM32 U8.CM34 U8.CM36 U8.CM38 U8.CM40 U8.CM42 U8.CM44 U8.CM46 U8.CM48 U8.CM50 U8.CM54 U8.CN3 U8.CN5 U8.CN9 U8.CN55 U8.CP2 U8.CP6 U8.CP8 U8.CP10 U8.CP52 U8.CP54 U8.CR1 U8.CR3 U8.CR7 U8.CR9 U8.CT4 U8.CT6 U8.CT10 U8.CU3 U8.CU5 U8.CU9 U8.CU11 U8.CU13 U8.CU15 U8.CU17 U8.CU19 U8.CU21 U8.CU23 U8.CU25 U8.CU27 U8.CU29 U8.CU31 U8.CU33 U8.CU35 U8.CU37 U8.CU39 U8.CU41 U8.CU43 U8.CU45 U8.CU47 U8.CU49 U8.CU51 U8.CU53 U8.CU55 U8.CV2 U8.CV6 U8.CV8 U8.CV10 U8.CW1 U8.CW3 U8.CW7 U8.CW9(GND_CW9) U8.CY2 U8.CY4 U8.CY6 U8.D2 U8.D4 U8.DA1 U8.DA3 U8.DA5 U8.DB2 U8.DB4 U8.DB6 U8.DB8 U8.DB10 U8.DB12 U8.DB14 U8.DB16 U8.DB18 U8.DB20 U8.DB22 U8.DB24 U8.DB26 U8.DB28 U8.DB30 U8.DB32 U8.DB34 U8.DB36 U8.DB38 U8.DB40 U8.DB42 U8.DB44 U8.DB46 U8.DB48 U8.DB50 U8.DB52 U8.DB54 U8.DC1 U8.DD2 U8.DE1 U8.DE51 U8.DE55 U8.DF50 U8.DF54 U8.DG1 U8.DG3 U8.DG5 U8.DG7 U8.DG9 U8.DG11 U8.DG13 U8.DG15 U8.DG17 U8.DG19 U8.DG21 U8.DG23 U8.DG25 U8.DG27 U8.DG29 U8.DG31 U8.DG33 U8.DG35 U8.DG37 U8.DG39 U8.DG41 U8.DG43 U8.DG45 U8.DG47 U8.DG49 U8.DG53 U8.DG55 U8.DH2 U8.DH4 U8.DH52 U8.DH54 U8.DJ3 U8.DJ5 U8.DJ51 U8.DJ53 U8.E1 U8.E3 U8.E55 U8.F52 U8.F54 U8.G51 U8.G53 U8.G55 U8.H2 U8.H4 U8.H6 U8.H8 U8.H10 U8.H12 U8.H14 U8.H16 U8.H18 U8.H20 U8.H22 U8.H24 U8.H26 U8.H28 U8.H30 U8.H32 U8.H34 U8.H36 U8.H38 U8.H40 U8.H42 U8.H44 U8.H46 U8.H48 U8.H50 U8.H52 U8.H54 U8.J49 U8.J53 U8.K50 U8.K54 U8.L49 U8.L51 U8.L53 U8.M50 U8.M52 U8.N1 U8.N3 U8.N5 U8.N7 U8.N9 U8.N11 U8.N13 U8.N15 U8.N17 U8.N19 U8.N21 U8.N23 U8.N25 U8.N27 U8.N29 U8.N31 U8.N33 U8.N35 U8.N37 U8.N39 U8.N41 U8.N43 U8.N45 U8.N47 U8.N49 U8.N53 U8.N55 U8.P48 U8.P50 U8.P54 U8.R47 U8.R51 U8.R53 U8.T44 U8.T46 U8.T50 U8.T52 U8.U43 U8.U45 U8.U47 U8.U49 U8.U53 U8.U55 U8.V2 U8.V4 U8.V6 U8.V8 U8.V10 U8.V12 U8.V14 U8.V16 U8.V18 U8.V20 U8.V22 U8.V24 U8.V26 U8.V28 U8.V30 U8.V32 U8.V34 U8.V36 U8.V38 U8.V40 U8.V42 U8.V44 U8.V48 U8.V50 U8.V54 U8.W43 U8.W47 U8.W51 U8.W53 U8.Y44 U8.Y46 U8.Y50 U8.Y52 U9.B3 U10.2 U12.3 U15.A2 U15.A8 U15.A9 U15.C8 U15.D1 U15.D9 U15.E1 U15.E9 U15.G1 U15.H9 U15.K1 U15.K9 U15.N1 U16.A2 U16.A8 U16.A9 U16.C8 U16.D1 U16.D9 U16.E1 U16.E9 U16.G1 U16.H9 U16.K1 U16.K9 U16.N1 U17.A2 U17.A8 U17.A9 U17.C8 U17.D1 U17.D9 U17.E1 U17.E9 U17.G1 U17.H9 U17.K1 U17.K9 U17.N1 U18.A2 U18.A8 U18.A9 U18.C8 U18.D1 U18.D9 U18.E1 U18.E9 U18.G1 U18.H9 U18.K1 U18.K9 U18.N1 U19.A2 U19.A8 U19.A9 U19.C8 U19.D1 U19.D9 U19.E1 U19.E9 U19.G1 U19.H9 U19.K1 U19.K9 U19.N1 U20.1 U20.9 U21.1 U21.9 U22.7 U23.65 U24.2 U25.8 U25.32 U25.33 U26.11 U26.12 U26.41 U27.11 U27.12 U27.41 U28.2 U31.2 U33.11 U36.1 U38.1 U39.1 U44.4 U45.4 U46.4 U47.1 U48.3(GND) U49.6 U49.10 U49.12 U49.14 U49.26 U49.28 U49.41 U49.53 U49.56 U49.57 U50.13 U52.4 U52.7 U54.13 U56.5 U56.11 U57.5 U57.11 U58.5 U58.11 U60.2 U62.7 U62.8 U62.9 U62.17 U62.18 U62.19 U62.27 U62.31 U62.39 U62.40 U62.41 U63.7 U63.8 U63.9 U63.17 U63.18 U63.19 U63.27 U63.31 U63.39 U63.40 U63.41 U64.7 U64.8 U64.9 U64.17 U64.18 U64.19 U64.27 U64.31 U64.39 U64.40 U64.41 U65.7 U65.8 U65.9 U65.17 U65.18 U65.19 U65.27 U65.31 U65.39 U65.40 U65.41 U66.7 U66.8 U66.9 U66.17 U66.18 U66.19 U66.27 U66.31 U66.39 U66.40 U66.41 U70.5 U70.11 U74.5 U74.11 U75.5 U75.11 U76.5 U76.11 U77.4 U77.8 U77.11 U78.4 U78.8 U78.11 U80.5 U80.11 U81.5 U81.11 U87.6 U88.6 U89.6 U90.6 U91.3 U93.D10 U93.G1 U93.G2 U93.G3 U93.G4 U93.G5 U93.H3 U93.H4 U93.H5 U93.H8 U93.H9 U93.H10 U93.J3 U93.J4 U93.J5 U93.J8 U93.J9 U93.J10 U93.K3 U93.K4 U93.K5 U93.K8 U93.K9 U93.K10 U93.L3 U93.L4 U93.L5 U93.L8 U93.L9 U93.L10 U93.M3 U93.M4 U93.M5 U93.M8 U93.M9 U93.M10 U94.B3 U94.C3 U94.D3 U94.D4 U94.E3 U95.A6 U95.A7 U95.B6 U95.B7 U95.D1 U95.D2 U95.D3 U95.D4 U95.D9 U95.D10 U95.D11 U95.D12 U95.E1 U95.E2 U95.E3 U95.E4 U95.E10 U95.E11 U95.E12 U95.F1 U95.F2 U95.F3 U95.F10 U95.F11 U95.F12 U95.G1 U95.G3 U95.G10 U95.G12 U95.H1 U95.H2 U95.H3 U95.H4 U95.H5 U95.H6 U95.H7 U95.H9 U95.H10 U95.H11 U95.H12 U95.J1 U95.J5 U95.J8 U95.J12 U95.K1 U95.K5 U95.K6 U95.K7 U95.K8 U95.K12 U95.L1 U95.L12 U95.M1 U95.M12 U96.D10 U96.G1 U96.G2 U96.G3 U96.G4 U96.G5 U96.H3 U96.H4 U96.H5 U96.H8 U96.H9 U96.H10 U96.J3 U96.J4 U96.J5 U96.J8 U96.J9 U96.J10 U96.K3 U96.K4 U96.K5 U96.K8 U96.K9 U96.K10 U96.L3 U96.L4 U96.L5 U96.L8 U96.L9 U96.L10 U96.M3 U96.M4 U96.M5 U96.M8 U96.M9 U96.M10 U97.8 X1.4 X2.4 X2.5 X2.10 Y1.2 Y1.4 Y2.2 Y2.4
GND_CHS: C492.1 J10.6 J10.7 J10.8 J10.9 R453.1
GND_QSFP_CAGE: B2.1 B2.2 B2.3 B2.4 B2.5 B2.6 B2.7 B2.8 B2.9(PIN9) B2.10 B2.11 B2.12 C339.1 R224.2
GND_QSFPDD_CAGE: B1.1 B1.2 B1.3 B1.4 B1.5 B1.6 B1.7 B1.8 B1.9(PIN9) B1.10 B1.11 B1.12 C321.1 R219.2
VBUS_5V: J10.1(VBUS) R447.1
VCCBAT: C1237.2 R6904.1 R6905.2 U8.CB40
VDD18_ZL30733: C371.2 C372.2 C373.2 C374.2 C375.2 FB18.1 U23.1 U23.2 U23.15 U23.37
VDD33_ZL30733: C361.2 C362.2 C367.2 C368.2 C369.2 FB17.1 U23.3 U23.14 U23.38 U23.43
VDD_ZL_OSC: C381.2 C382.2 C383.2 FB20.1 R238.2 U24.4(VDD)
VDDIO_ZL30733: C359.2 C363.2 FB16.1 U23.44
VDDO0_ZL30733: C353.2 C354.2 C355.2 FB13.1 FB42.1 U23.50
VDDO1_ZL30733: C356.2 C357.2 FB14.1 U23.53
VDDO2_ZL30733: C360.2 C365.2 FB15.1 U23.56
VDDO3_ZL30733: C377.2 C378.2 FB19.1 U23.59
VDDO4_ZL30733: C384.2 C385.2 FB21.1 U23.62
VDDO5_ZL30733: C394.2 C397.2 FB22.1 U23.19
VDDO6_ZL30733: C398.2 C399.2 FB23.1 U23.22
VDDO7_ZL30733: C401.2 C402.2 FB24.1 U23.25
VDDO8_ZL30733: C404.2 C405.2 FB25.1 U23.28
VDDO9_ZL30733: C407.2 C408.2 FB26.1 U23.31(VDDO9)
1_PPS_SCOPE1: J14.1 U8.U37
1_PPS_SCOPE2: J15.1 U8.M38
24M_XTALIN: C493.1 U49.5 Y2.1
24M_XTALOUT: C494.1 U49.4(XTALOUT) Y2.3
ADI_ALERTN: R1007.1 R6807.1 U5.A9 U93.A2 U96.A2
ASEL0: R550.1 U61.23
ASEL1: R551.1 U61.24
