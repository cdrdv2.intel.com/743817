# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Nets (continued)
AUX_HSC_ALERT_N: R478.1 U5.K15 U54.15
AUX_HSC_BST: C625.2 U54.4
AUX_HSC_FAULTB: R474.2 U54.16
AUX_HSC_ILOAD: C627.1 R480.1 U54.2
AUX_HSC_PG: R471.2 U5.C10 U54.17
AUX_HSC_ROCP: R479.2 U54.18
AUX_HSC_SMB_ID_R: R477.2 U54.20
AUX_HSC_SS: C628.1 C629.1 U54.3
AUX_VDD_1V85: C621.2 C622.1 R474.1 U54.22
BANK2C_RZQ: R108.2 U8.CT28
BANK2D_RZQ: R109.2 U8.CT16
BANK2F_RZQ: R110.2 U8.CY36
BMC_BUF_TCK: R332.1 U5.B16
BMC_BUF_TDI: R333.1 U5.E14
BMC_BUF_TDO: U5.F14 U28.3
BMC_BUF_TMS: R327.1 U5.E15
BMC_JTAG_SEL: R740.1 SW3.3 U5.N4
BUF1_Q0_N: R289.2 U26.13
BUF1_Q0_P: R288.2 U26.14
BUF1_Q1_N: R291.2 U26.16
BUF1_Q1_P: R290.2 U26.17
BUF2_Q0_N: R311.2 U27.13
BUF2_Q0_P: R310.2 U27.14
BUF2_Q1_N: R313.1 U27.16
BUF2_Q1_P: R312.1 U27.17
BUFF1_IMP_SEL: R293.1 R295.1 U26.19
BUFF1_OE0N: R298.1 R299.1 U26.31
BUFF1_OE1N: R300.1 R301.1 U26.32
BUFF1_OE2N: R303.1 U26.36
BUFF1_OE3N: R305.1 U26.37
BUFF2_IMP_SEL: R315.1 R317.1 U27.19
BUFF2_OE0N: R320.1 R321.1 U27.31
BUFF2_OE1N: R322.1 R323.1 U27.32
BUFF2_OE2N: R324.1 U27.36
BUFF2_OE3N: R325.1 U27.37
C_PTP_SAMPLE_CLK_250M_N: C390.1 R748.1 U23.24
C_PTP_SAMPLE_CLK_250M_P: C389.1 R748.2 U23.23
C_QSFP_REFCLK_N: C396.1 R750.1 U23.21
C_QSFP_REFCLK_P: C393.1 R750.2 U23.20
C_QSFPDD_REFCLK_N: C392.1 R749.1 U23.18
C_QSFPDD_REFCLK_P: C391.1 R749.2 U23.17
C_TOD_MASTER_CLK_125M_N: C388.1 R747.1 U23.54
C_TOD_MASTER_CLK_125M_P: C387.1 R747.2 U23.55
CFG_IMAGE0: Q19.1 R6887.2 U5.C5
CFG_IMAGE1: Q20.1 R6889.2 U5.B4
CIPRI_HIGH_REFCLK_N: C1030.2 R6913.1 R6922.2 U8.AH48
CIPRI_HIGH_REFCLK_P: C1029.2 R6913.2 R6921.2 U8.AJ49
CIPRI_LOW_REFCLK_N: C1028.2 R6916.2 R6928.1 U8.AU49
CIPRI_LOW_REFCLK_P: C1027.2 R6916.1 R6927.1 U8.AR49
CLK_100M_CXL_CONN_C_N: J9.B12 R226.1
CLK_100M_CXL_CONN_C_P: J9.B11 R225.1
CLK_CXL_CONN_N: R226.2 R316.2 U27.3
CLK_CXL_CONN_P: R225.2 R314.2 U27.2
CLK_CXL_EP_N: R277.1 R319.2 U27.8
CLK_CXL_EP_P: R276.1 R318.2 U27.7
CLK_FPGA_100M_N: R254.1 R6842.1
CLK_FPGA_100M_P: R253.1 R6843.1
CLK_REF4P: R6837.2 U23.4
CPU_1V2_RESETN: R819.1 U8.A45 U88.2
CPU_RESETN: R418.2 R777.2 S1.2 U5.B15 U88.10
CXL_PERSTN: J9.A11 R227.1 R358.2 R766.2 R767.2 S6.2 U12.2
CXL_PERSTX1_N: J9.A29 R227.2
CXL_PRSNTX4_N: J9.A12 R789.1 U22.13
CXL_RX_N0: J9.A3 U8.CD54
CXL_RX_N1: J9.A6 U8.CA51
CXL_RX_N2: J9.A15 U8.BY54
CXL_RX_N3: J9.A18 U8.BT54
CXL_RX_P0: J9.A2 U8.CC55
CXL_RX_P1: J9.A5 U8.CB52
CXL_RX_P2: J9.A14 U8.BW55
CXL_RX_P3: J9.A17 U8.BR55
CXL_TX_C_N0: C341.2 J9.B3
CXL_TX_C_N1: C343.2 J9.B6
CXL_TX_C_N2: C348.2 J9.B15
CXL_TX_C_N3: C350.2 J9.B18
CXL_TX_C_P0: C340.2 J9.B2
CXL_TX_C_P1: C342.2 J9.B5
CXL_TX_C_P2: C347.2 J9.B14
CXL_TX_C_P3: C349.2 J9.B17
CXL_TX_N0: C341.1 U8.BY48
CXL_TX_N1: C343.1 U8.BU51
CXL_TX_N2: C348.1 U8.BT48
CXL_TX_N3: C350.1 U8.BN51
CXL_TX_P0: C340.1 U8.BW49
CXL_TX_P1: C342.1 U8.BV52
CXL_TX_P2: C347.1 U8.BR49
CXL_TX_P3: C349.1 U8.BP52
DDR4_2V5_DIMM1_EVENT_N: J4.78 R135.1
DDR4_2V5_DIMM1_SAVE_N: J4.230 R134.1
DDR4_2V5_DIMM2_EVENT_N: J5.78 R151.1
DDR4_2V5_DIMM2_SAVE_N: J5.230 R150.1
DDR4_2V5_DIMM_SCL: J4.141 J5.141 R376.1 R384.1 U38.3 U39.6
DDR4_2V5_DIMM_SDA: J4.285 J5.285 R377.1 R383.1 U38.4 U39.5
DDR4_COMP_A0: R167.2 U8.U11 U15.L3 U16.L3 U17.L3 U18.L3 U19.L3
DDR4_COMP_A1: R168.2 U8.T12 U15.L7 U16.L7 U17.L7 U18.L7 U19.L7
DDR4_COMP_A2: R169.2 U8.W11 U15.M3 U16.M3 U17.M3 U18.M3 U19.M3
DDR4_COMP_A3: R170.2 U8.Y12 U15.K7 U16.K7 U17.K7 U18.K7 U19.K7
DDR4_COMP_A4: R171.2 U8.U9 U15.K3 U16.K3 U17.K3 U18.K3 U19.K3
DDR4_COMP_A5: R172.2 U8.T10 U15.L8 U16.L8 U17.L8 U18.L8 U19.L8
DDR4_COMP_A6: R174.2 U8.W9 U15.L2 U16.L2 U17.L2 U18.L2 U19.L2
DDR4_COMP_A7: R175.2 U8.Y10 U15.M8 U16.M8 U17.M8 U18.M8 U19.M8
DDR4_COMP_A8: R176.2 U8.U7 U15.M2 U16.M2 U17.M2 U18.M2 U19.M2
DDR4_COMP_A9: R177.2 U8.T8 U15.M7 U16.M7 U17.M7 U18.M7 U19.M7
DDR4_COMP_A10: R178.2 U8.W7 U15.J3 U16.J3 U17.J3 U18.J3 U19.J3
DDR4_COMP_A11: R179.2 U8.Y8 U15.N2 U16.N2 U17.N2 U18.N2 U19.N2
DDR4_COMP_A12: R180.2 U8.Y6 U15.J7 U16.J7 U17.J7 U18.J7 U19.J7
DDR4_COMP_A13: R181.2 U8.U3 U15.N8 U16.N8 U17.N8 U18.N8 U19.N8
DDR4_COMP_A14: R182.2 U8.T4 U15.H2 U16.H2 U17.H2 U18.H2 U19.H2
DDR4_COMP_A15: R183.2 U8.W3 U15.H7 U16.H7 U17.H7 U18.H7 U19.H7
DDR4_COMP_A16: R184.2 U8.Y4 U15.H8 U16.H8 U17.H8 U18.H8 U19.H8
DDR4_COMP_ACT_N: R192.2 U8.P12 U15.H3 U16.H3 U17.H3 U18.H3 U19.H3
DDR4_COMP_ALERT_N: R194.2 U8.U1 U15.L9 U16.L9 U17.L9 U18.L9 U19.L9
DDR4_COMP_BA0: R188.2 U8.T2 U15.K2 U16.K2 U17.K2 U18.K2 U19.K2
DDR4_COMP_BA1: R189.2 U8.W1 U15.K8 U16.K8 U17.K8 U18.K8 U19.K8
DDR4_COMP_BG0: R186.2 U8.Y2 U15.J2 U16.J2 U17.J2 U18.J2 U19.J2
DDR4_COMP_BG1: R187.2 U8.L11 U15.J8 U16.J8 U17.J8 U18.J8 U19.J8
DDR4_COMP_CK_N: R202.2 U8.M8 U15.F8 U16.F8 U17.F8 U18.F8 U19.F8
DDR4_COMP_CK_P: R200.2 U8.L7 U15.F7 U16.F7 U17.F7 U18.F7 U19.F7
DDR4_COMP_CKE: R198.2 R201.1 U8.R9 U15.G3 U16.G3 U17.G3 U18.G3 U19.G3
DDR4_COMP_CS_N: R190.2 U8.R11 U15.G7 U16.G7 U17.G7 U18.G7 U19.G7
DDR4_COMP_DBI_N0: U8.J9 U19.A7
DDR4_COMP_DBI_N1: U8.R3 U16.A7
DDR4_COMP_DBI_N2: U8.E7 U17.A7
DDR4_COMP_DBI_N3: U8.J3 U18.A7
DDR4_COMP_DBI_N4: U8.AA3 U15.A7
DDR4_COMP_DQ0: U8.F12 U19.C2
DDR4_COMP_DQ1: U8.F8 U19.B7
DDR4_COMP_DQ2: U8.G11 U19.D3
DDR4_COMP_DQ3: U8.K8 U19.D7
DDR4_COMP_DQ4: U8.J11 U19.D2
DDR4_COMP_DQ5: U8.G7 U19.D8
DDR4_COMP_DQ6: U8.K12 U19.E3
DDR4_COMP_DQ7: U8.J7 U19.E7
DDR4_COMP_DQ8: U8.M6 U16.C2
DDR4_COMP_DQ9: U8.P2 U16.B7
DDR4_COMP_DQ10: U8.L5 U16.D3
DDR4_COMP_DQ11: U8.R1 U16.D7
DDR4_COMP_DQ12: U8.P6 U16.D2
DDR4_COMP_DQ13: U8.R5 U16.D8
DDR4_COMP_DQ14: U8.M2 U16.E3
DDR4_COMP_DQ15: U8.L1 U16.E7
DDR4_COMP_DQ16: U8.A9 U17.C2
DDR4_COMP_DQ17: U8.B6 U17.B7
DDR4_COMP_DQ18: U8.E9 U17.D3
DDR4_COMP_DQ19: U8.D6 U17.D7
DDR4_COMP_DQ20: U8.D10 U17.D2
DDR4_COMP_DQ21: U8.C5 U17.D8
DDR4_COMP_DQ22: U8.B10 U17.E3
DDR4_COMP_DQ23: U8.E5 U17.E7
DDR4_COMP_DQ24: U8.F6 U18.C2
DDR4_COMP_DQ25: U8.J1 U18.B7
DDR4_COMP_DQ26: U8.F2 U18.D3
DDR4_COMP_DQ27: U8.K2 U18.D7
DDR4_COMP_DQ28: U8.K6 U18.D2
DDR4_COMP_DQ29: U8.J5 U18.D8
DDR4_COMP_DQ30: U8.G5 U18.E3
DDR4_COMP_DQ31: U8.G1 U18.E7
DDR4_COMP_DQ32: U8.AA7 U15.C2
DDR4_COMP_DQ33: U8.AD2 U15.B7
DDR4_COMP_DQ34: U8.AB2 U15.D3
DDR4_COMP_DQ35: U8.AB8 U15.D7
DDR4_COMP_DQ36: U8.AA1 U15.D2
DDR4_COMP_DQ37: U8.AE7 U15.D8
DDR4_COMP_DQ38: U8.AE1 U15.E3
DDR4_COMP_DQ39: U8.AD6 U15.E7
DDR4_COMP_DQS_N0: U8.F10 U19.B3
DDR4_COMP_DQS_N1: U8.M4 U16.B3
DDR4_COMP_DQS_N2: U8.B8 U17.B3
DDR4_COMP_DQS_N3: U8.F4 U18.B3
DDR4_COMP_DQS_N4: U8.AB6 U15.B3
DDR4_COMP_DQS_P0: U8.G9 U19.C3
DDR4_COMP_DQS_P1: U8.L3 U16.C3
DDR4_COMP_DQS_P2: U8.A7 U17.C3
DDR4_COMP_DQS_P3: U8.G3 U18.C3
DDR4_COMP_DQS_P4: U8.AA5 U15.C3
DDR4_COMP_ODT: R191.2 U8.L9 U15.F3 U16.F3 U17.F3 U18.F3 U19.F3
DDR4_COMP_PAR: R193.2 U8.P8 U15.N3 U16.N3 U17.N3 U18.N3 U19.N3
DDR4_COMP_REFCLK_N: R252.1 R6912.1 R6939.1 U8.T6
DDR4_COMP_REFCLK_P: R251.1 R6912.2 R6938.1 U8.U5
DDR4_COMP_RESET_N: R195.2 R196.2 U8.M12 U15.L1 U16.L1 U17.L1 U18.L1 U19.L1
DDR4_COMP_RZQ: R114.2 U8.W5
DDR4_COMP_TEN: R197.2 R199.1 U15.G9 U16.G9 U17.G9 U18.G9 U19.G9
DDR4_DIMM1_A0: J4.79 U8.CV34
DDR4_DIMM1_A1: J4.72 U8.CW35
DDR4_DIMM1_A2: J4.216 U8.CT34
DDR4_DIMM1_A3: J4.71 U8.CR35
DDR4_DIMM1_A4: J4.214 U8.CV32
DDR4_DIMM1_A5: J4.213 U8.CW33
DDR4_DIMM1_A6: J4.69 U8.CT32
DDR4_DIMM1_A7: J4.211 U8.CR33
DDR4_DIMM1_A8: J4.68 U8.CV30
DDR4_DIMM1_A9: J4.66 U8.CW31
DDR4_DIMM1_A10: J4.225 U8.CT30
DDR4_DIMM1_A11: J4.210 U8.CR31
DDR4_DIMM1_A12: J4.65 U8.CR29
DDR4_DIMM1_A13: J4.232 U8.CV26
DDR4_DIMM1_A14: J4.228(WE_N/A14) U8.CW27
DDR4_DIMM1_A15: J4.86 U8.CT26
DDR4_DIMM1_A16: J4.82 U8.CR27
DDR4_DIMM1_A17: J4.234 U8.CV24
DDR4_DIMM1_ACT_N: J4.62 U8.CL35
DDR4_DIMM1_ALERT_N: J4.208 R143.1 U8.CP24
DDR4_DIMM1_BA0: J4.81 U8.CW25
DDR4_DIMM1_BA1: J4.224 U8.CT24
DDR4_DIMM1_BG0: J4.63 U8.CR25
DDR4_DIMM1_BG1: J4.207 U8.CP34
DDR4_DIMM1_C0: J4.93 U8.CP28
DDR4_DIMM1_C1: J4.237 U8.CN29
DDR4_DIMM1_CK_N0: J4.75 U8.CN31
DDR4_DIMM1_CK_N1: J4.219 U8.CL25
DDR4_DIMM1_CK_P0: J4.74 U8.CP30
DDR4_DIMM1_CK_P1: J4.218 U8.CK24
DDR4_DIMM1_CKE0: J4.60 R141.2 U8.CK32
DDR4_DIMM1_CKE1: J4.203 R142.2 U8.CL33
DDR4_DIMM1_CS_N0: J4.84 U8.CK34
DDR4_DIMM1_CS_N1: J4.89 U8.CK30
DDR4_DIMM1_DBI_N0: J4.7 U8.CY28
DDR4_DIMM1_DBI_N1: J4.18 U8.DF18
DDR4_DIMM1_DBI_N2: J4.29 U8.DF6
DDR4_DIMM1_DBI_N3: J4.40 U8.DF12
DDR4_DIMM1_DBI_N4: J4.99 U8.DF24
DDR4_DIMM1_DBI_N5: J4.110 U8.CY16
DDR4_DIMM1_DBI_N6: J4.121 U8.CY22
DDR4_DIMM1_DBI_N7: J4.132 U8.CY10
DDR4_DIMM1_DBI_N8: J4.51 U8.CT20
DDR4_DIMM1_DQ0: J4.5 U8.DC31
DDR4_DIMM1_DQ1: J4.150 U8.DD30
DDR4_DIMM1_DQ2: J4.12 U8.CY30
DDR4_DIMM1_DQ3: J4.157 U8.DA31
DDR4_DIMM1_DQ4: J4.3 U8.DA27
DDR4_DIMM1_DQ5: J4.148 U8.CY26
DDR4_DIMM1_DQ6: J4.10 U8.DC27
DDR4_DIMM1_DQ7: J4.155 U8.DD26
DDR4_DIMM1_DQ8: J4.16 U8.DF20
DDR4_DIMM1_DQ9: J4.161 U8.DJ21
DDR4_DIMM1_DQ10: J4.23 U8.DH20
DDR4_DIMM1_DQ11: J4.168 U8.DE21
DDR4_DIMM1_DQ12: J4.14 U8.DF16
DDR4_DIMM1_DQ13: J4.159 U8.DH16
DDR4_DIMM1_DQ14: J4.21 U8.DE17
DDR4_DIMM1_DQ15: J4.166 U8.DJ17
DDR4_DIMM1_DQ16: J4.27 U8.DF8
DDR4_DIMM1_DQ17: J4.172 U8.DH8
DDR4_DIMM1_DQ18: J4.34 U8.DE9
DDR4_DIMM1_DQ19: J4.179 U8.DJ9
DDR4_DIMM1_DQ20: J4.25 U8.DF2
DDR4_DIMM1_DQ21: J4.170 U8.DE3
DDR4_DIMM1_DQ22: J4.32 U8.DF4
DDR4_DIMM1_DQ23: J4.177 U8.DE5
DDR4_DIMM1_DQ24: J4.38 U8.DE15
DDR4_DIMM1_DQ25: J4.183 U8.DF14
DDR4_DIMM1_DQ26: J4.45 U8.DJ15
DDR4_DIMM1_DQ27: J4.190 U8.DH14
DDR4_DIMM1_DQ28: J4.36 U8.DF10
DDR4_DIMM1_DQ29: J4.181 U8.DH10
DDR4_DIMM1_DQ30: J4.43 U8.DJ11
DDR4_DIMM1_DQ31: J4.188 U8.DE11
DDR4_DIMM1_DQ32: J4.97 U8.DH26
DDR4_DIMM1_DQ33: J4.242 U8.DE27
DDR4_DIMM1_DQ34: J4.104 U8.DF26
DDR4_DIMM1_DQ35: J4.249 U8.DJ27
DDR4_DIMM1_DQ36: J4.95 U8.DE23
DDR4_DIMM1_DQ37: J4.240 U8.DF22
DDR4_DIMM1_DQ38: J4.102 U8.DJ23
DDR4_DIMM1_DQ39: J4.247 U8.DH22
DDR4_DIMM1_DQ40: J4.108 U8.DC19
DDR4_DIMM1_DQ41: J4.253 U8.DD18
DDR4_DIMM1_DQ42: J4.115 U8.CY18
DDR4_DIMM1_DQ43: J4.260 U8.DA19
DDR4_DIMM1_DQ44: J4.106 U8.CY14
DDR4_DIMM1_DQ45: J4.251 U8.DA15
DDR4_DIMM1_DQ46: J4.113 U8.DC15
DDR4_DIMM1_DQ47: J4.258 U8.DD14
DDR4_DIMM1_DQ48: J4.119 U8.CY24
DDR4_DIMM1_DQ49: J4.264 U8.DD24
DDR4_DIMM1_DQ50: J4.126 U8.DC25
DDR4_DIMM1_DQ51: J4.271 U8.DA25
DDR4_DIMM1_DQ52: J4.117 U8.CY20
DDR4_DIMM1_DQ53: J4.262 U8.DC21
DDR4_DIMM1_DQ54: J4.124 U8.DA21
DDR4_DIMM1_DQ55: J4.269 U8.DD20
DDR4_DIMM1_DQ56: J4.130 U8.CY12
DDR4_DIMM1_DQ57: J4.275 U8.DC13
DDR4_DIMM1_DQ58: J4.137 U8.DA13
DDR4_DIMM1_DQ59: J4.282 U8.DD12
DDR4_DIMM1_DQ60: J4.128 U8.DC9
DDR4_DIMM1_DQ61: J4.273 U8.DA9
DDR4_DIMM1_DQ62: J4.135 U8.CY8
DDR4_DIMM1_DQ63: J4.280 U8.DD8
DDR4_DIMM1_DQ64: J4.49 U8.CW23
DDR4_DIMM1_DQ65: J4.194 U8.CV22
DDR4_DIMM1_DQ66: J4.56 U8.CT22
DDR4_DIMM1_DQ67: J4.201 U8.CR23
DDR4_DIMM1_DQ68: J4.47 U8.CR19
DDR4_DIMM1_DQ69: J4.192 U8.CV18
DDR4_DIMM1_DQ70: J4.54 U8.CW19
DDR4_DIMM1_DQ71: J4.199 U8.CT18
DDR4_DIMM1_DQS_N0: J4.152 U8.DC29
DDR4_DIMM1_DQS_N1: J4.163 U8.DJ19
DDR4_DIMM1_DQS_N2: J4.174 U8.DJ7
DDR4_DIMM1_DQS_N3: J4.185 U8.DJ13
DDR4_DIMM1_DQS_N4: J4.244 U8.DJ25
DDR4_DIMM1_DQS_N5: J4.255 U8.DC17
DDR4_DIMM1_DQS_N6: J4.266 U8.DC23
DDR4_DIMM1_DQS_N7: J4.277 U8.DC11
DDR4_DIMM1_DQS_N8: J4.196 U8.CW21
DDR4_DIMM1_DQS_P0: J4.153 U8.DD28
DDR4_DIMM1_DQS_P1: J4.164 U8.DH18
DDR4_DIMM1_DQS_P2: J4.175 U8.DH6
DDR4_DIMM1_DQS_P3: J4.186 U8.DH12
DDR4_DIMM1_DQS_P4: J4.245 U8.DH24
DDR4_DIMM1_DQS_P5: J4.256 U8.DD16
DDR4_DIMM1_DQS_P6: J4.267 U8.DD22
DDR4_DIMM1_DQS_P7: J4.278 U8.DD10
DDR4_DIMM1_DQS_P8: J4.197 U8.CV20
DDR4_DIMM1_ODT0: J4.87 U8.CP32
DDR4_DIMM1_ODT1: J4.91 U8.CN33
DDR4_DIMM1_PAR: J4.222 U8.CL31
DDR4_DIMM1_REFCLK_N: R248.1 R6908.1 R6931.1 U8.CW29
DDR4_DIMM1_REFCLK_P: R247.1 R6908.2 R6930.1 U8.CV28
DDR4_DIMM1_RESET_N: J4.58 R139.1 R140.2 U8.CN35
DDR4_DIMM1_SA0: J4.139 R136.2
DDR4_DIMM1_SA1: J4.140 R137.2
DDR4_DIMM1_SA2: J4.238 R138.2
DDR4_DIMM1_TDQS_N9: J4.8 U8.DA29
DDR4_DIMM1_TDQS_N10: J4.19 U8.DE19
DDR4_DIMM1_TDQS_N11: J4.30 U8.DE7
DDR4_DIMM1_TDQS_N12: J4.41 U8.DE13
DDR4_DIMM1_TDQS_N13: J4.100 U8.DE25
DDR4_DIMM1_TDQS_N14: J4.111 U8.DA17
DDR4_DIMM1_TDQS_N15: J4.122 U8.DA23
DDR4_DIMM1_TDQS_N16: J4.133 U8.DA11
DDR4_DIMM1_TDQS_N17: J4.52 U8.CR21
DDR4_DIMM2_A0: J5.79 U8.DH38
DDR4_DIMM2_A1: J5.72 U8.DJ39
DDR4_DIMM2_A2: J5.216 U8.DF38
DDR4_DIMM2_A3: J5.71 U8.DE39
DDR4_DIMM2_A4: J5.214 U8.DH36
DDR4_DIMM2_A5: J5.213 U8.DJ37
DDR4_DIMM2_A6: J5.69 U8.DF36
DDR4_DIMM2_A7: J5.211 U8.DE37
DDR4_DIMM2_A8: J5.68 U8.DH34
DDR4_DIMM2_A9: J5.66 U8.DJ35
DDR4_DIMM2_A10: J5.225 U8.DF34
DDR4_DIMM2_A11: J5.210 U8.DE35
DDR4_DIMM2_A12: J5.65 U8.DA37
DDR4_DIMM2_A13: J5.232 U8.DD34
DDR4_DIMM2_A14: J5.228(WE_N/A14) U8.DC35
DDR4_DIMM2_A15: J5.86 U8.CY34
DDR4_DIMM2_A16: J5.82 U8.DA35
DDR4_DIMM2_A17: J5.234 U8.DD32
DDR4_DIMM2_ACT_N: J5.62 U8.DA43
DDR4_DIMM2_ALERT_N: J5.208 R159.1 U8.DH28
DDR4_DIMM2_BA0: J5.81 U8.DC33
DDR4_DIMM2_BA1: J5.224 U8.CY32
DDR4_DIMM2_BG0: J5.63 U8.DA33
DDR4_DIMM2_BG1: J5.207 U8.DD42
DDR4_DIMM2_C0: J5.93 U8.DH32
DDR4_DIMM2_C1: J5.237 U8.DJ33
DDR4_DIMM2_CK_N0: J5.75 U8.DC39
DDR4_DIMM2_CK_N1: J5.219 U8.DE29
DDR4_DIMM2_CK_P0: J5.74 U8.DD38
DDR4_DIMM2_CK_P1: J5.218 U8.DF28
DDR4_DIMM2_CKE0: J5.60 R157.2 U8.CY40
DDR4_DIMM2_CKE1: J5.203 R158.2 U8.DA41
DDR4_DIMM2_CS_N0: J5.84 U8.CY42
DDR4_DIMM2_CS_N1: J5.89 U8.CY38
DDR4_DIMM2_DBI_N0: J5.7 U8.CK44
DDR4_DIMM2_DBI_N1: J5.18 U8.CY46
DDR4_DIMM2_DBI_N2: J5.29 U8.CK50
DDR4_DIMM2_DBI_N3: J5.40 U8.CT44
DDR4_DIMM2_DBI_N4: J5.99 U8.CT50
DDR4_DIMM2_DBI_N5: J5.110 U8.CY52
DDR4_DIMM2_DBI_N6: J5.121 U8.CK38
DDR4_DIMM2_DBI_N7: J5.132 U8.DF48
DDR4_DIMM2_DBI_N8: J5.51 U8.CT38
DDR4_DIMM2_DQ0: J5.5 U8.CK46
DDR4_DIMM2_DQ1: J5.150 U8.CL47
DDR4_DIMM2_DQ2: J5.12 U8.CN47
DDR4_DIMM2_DQ3: J5.157 U8.CP46
DDR4_DIMM2_DQ4: J5.3 U8.CL43
DDR4_DIMM2_DQ5: J5.148 U8.CK42
DDR4_DIMM2_DQ6: J5.10 U8.CN43
DDR4_DIMM2_DQ7: J5.155 U8.CP42
DDR4_DIMM2_DQ8: J5.16 U8.DA45
DDR4_DIMM2_DQ9: J5.161 U8.DC45
DDR4_DIMM2_DQ10: J5.23 U8.DD44
DDR4_DIMM2_DQ11: J5.168 U8.CY44
DDR4_DIMM2_DQ12: J5.14 U8.DA49
DDR4_DIMM2_DQ13: J5.159 U8.CY48
DDR4_DIMM2_DQ14: J5.21 U8.DD48
DDR4_DIMM2_DQ15: J5.166 U8.DC49
DDR4_DIMM2_DQ16: J5.27 U8.CN49
DDR4_DIMM2_DQ17: J5.172 U8.CP48
DDR4_DIMM2_DQ18: J5.34 U8.CL49
DDR4_DIMM2_DQ19: J5.179 U8.CK48
DDR4_DIMM2_DQ20: J5.25 U8.CM52
DDR4_DIMM2_DQ21: J5.170 U8.CT52
DDR4_DIMM2_DQ22: J5.32 U8.CN53
DDR4_DIMM2_DQ23: J5.177 U8.CR53
DDR4_DIMM2_DQ24: J5.38 U8.CR47
DDR4_DIMM2_DQ25: J5.183 U8.CT46
DDR4_DIMM2_DQ26: J5.45 U8.CV46
DDR4_DIMM2_DQ27: J5.190 U8.CW47
DDR4_DIMM2_DQ28: J5.36 U8.CW43
DDR4_DIMM2_DQ29: J5.181 U8.CV42
DDR4_DIMM2_DQ30: J5.43 U8.CR43
DDR4_DIMM2_DQ31: J5.188 U8.CT42
DDR4_DIMM2_DQ32: J5.97 U8.CV48
DDR4_DIMM2_DQ33: J5.242 U8.CT48
DDR4_DIMM2_DQ34: J5.104 U8.CW49
DDR4_DIMM2_DQ35: J5.249 U8.CR49
DDR4_DIMM2_DQ36: J5.95 U8.CW53
DDR4_DIMM2_DQ37: J5.240 U8.CV52
DDR4_DIMM2_DQ38: J5.102 U8.CW55
DDR4_DIMM2_DQ39: J5.247 U8.CV54
DDR4_DIMM2_DQ40: J5.108 U8.CY50
DDR4_DIMM2_DQ41: J5.253 U8.DC51
DDR4_DIMM2_DQ42: J5.115 U8.DA51
DDR4_DIMM2_DQ43: J5.260 U8.DD50
DDR4_DIMM2_DQ44: J5.106 U8.CY54
DDR4_DIMM2_DQ45: J5.251 U8.DA55
DDR4_DIMM2_DQ46: J5.113 U8.DD54
DDR4_DIMM2_DQ47: J5.258 U8.DC55
DDR4_DIMM2_DQ48: J5.119 U8.CL41
DDR4_DIMM2_DQ49: J5.264 U8.CN41
DDR4_DIMM2_DQ50: J5.126 U8.CK40
DDR4_DIMM2_DQ51: J5.271 U8.CP40
DDR4_DIMM2_DQ52: J5.117 U8.CK36
DDR4_DIMM2_DQ53: J5.262 U8.CN37
DDR4_DIMM2_DQ54: J5.124 U8.CL37
DDR4_DIMM2_DQ55: J5.269 U8.CP36
DDR4_DIMM2_DQ56: J5.130 U8.DF46
DDR4_DIMM2_DQ57: J5.275 U8.DE47
DDR4_DIMM2_DQ58: J5.137 U8.DH46
DDR4_DIMM2_DQ59: J5.282 U8.DJ47
DDR4_DIMM2_DQ60: J5.128 U8.DE53
DDR4_DIMM2_DQ61: J5.273 U8.DF52
DDR4_DIMM2_DQ62: J5.135 U8.DG51
DDR4_DIMM2_DQ63: J5.280 U8.DH50
DDR4_DIMM2_DQ64: J5.49 U8.CW41
DDR4_DIMM2_DQ65: J5.194 U8.CV40
DDR4_DIMM2_DQ66: J5.56 U8.CR41
DDR4_DIMM2_DQ67: J5.201 U8.CT40
DDR4_DIMM2_DQ68: J5.47 U8.CR37
DDR4_DIMM2_DQ69: J5.192 U8.CV36
DDR4_DIMM2_DQ70: J5.54 U8.CW37
DDR4_DIMM2_DQ71: J5.199 U8.CT36
DDR4_DIMM2_DQS_N0: J5.152 U8.CN45
DDR4_DIMM2_DQS_N1: J5.163 U8.DC47
DDR4_DIMM2_DQS_N2: J5.174 U8.CN51
DDR4_DIMM2_DQS_N3: J5.185 U8.CW45
DDR4_DIMM2_DQS_N4: J5.244 U8.CW51
DDR4_DIMM2_DQS_N5: J5.255 U8.DC53
DDR4_DIMM2_DQS_N6: J5.266 U8.CN39
DDR4_DIMM2_DQS_N7: J5.277 U8.DJ49
DDR4_DIMM2_DQS_N8: J5.196 U8.CW39
DDR4_DIMM2_DQS_P0: J5.153 U8.CP44
DDR4_DIMM2_DQS_P1: J5.164 U8.DD46
DDR4_DIMM2_DQS_P2: J5.175 U8.CP50
DDR4_DIMM2_DQS_P3: J5.186 U8.CV44
DDR4_DIMM2_DQS_P4: J5.245 U8.CV50
DDR4_DIMM2_DQS_P5: J5.256 U8.DD52
DDR4_DIMM2_DQS_P6: J5.267 U8.CP38
DDR4_DIMM2_DQS_P7: J5.278 U8.DH48
DDR4_DIMM2_DQS_P8: J5.197 U8.CV38
DDR4_DIMM2_ODT0: J5.87 U8.DD40
DDR4_DIMM2_ODT1: J5.91 U8.DC41
DDR4_DIMM2_PAR: J5.222 U8.DA39
DDR4_DIMM2_REFCLK_N: R250.1 R6909.2 R6933.1 U8.DC37
DDR4_DIMM2_REFCLK_P: R249.1 R6909.1 R6932.1 U8.DD36
DDR4_DIMM2_RESET_N: J5.58 R155.1 R156.2 U8.DC43
DDR4_DIMM2_SA0: J5.139 R152.1
DDR4_DIMM2_SA1: J5.140 R153.2
DDR4_DIMM2_SA2: J5.238 R154.2
DDR4_DIMM2_TDQS_N9: J5.8 U8.CL45
DDR4_DIMM2_TDQS_N10: J5.19 U8.DA47
DDR4_DIMM2_TDQS_N11: J5.30 U8.CL51
DDR4_DIMM2_TDQS_N12: J5.41 U8.CR45
DDR4_DIMM2_TDQS_N13: J5.100 U8.CR51
DDR4_DIMM2_TDQS_N14: J5.111 U8.DA53
DDR4_DIMM2_TDQS_N15: J5.122 U8.CL39
DDR4_DIMM2_TDQS_N16: J5.133 U8.DE49
DDR4_DIMM2_TDQS_N17: J5.52 U8.CR39
EN_5V0: C1093.1 R862.1 R865.2 U94.A3
EN_G0: R75.2 R528.1 U5.H16
EN_G1: R74.2 R535.2 R542.2 R567.1 R568.1 R575.1 R576.1 R583.1 R584.1 R591.1 R592.1 R599.1 R600.1 R620.1 R637.1 U5.D16 U61.20
EN_G2: R73.2 R6808.1 U5.C16
EN_G3: R76.2 R852.1 R6809.1 U5.H11 U74.7
EXT_JTAG_TCK: J3.1 R94.1 U5.A3 U6.1
EXT_JTAG_TDI: J3.9 R85.2 U5.B3 U6.8
EXT_JTAG_TDO: J3.3 R83.2 U5.A4 U6.11
EXT_JTAG_TMS: J3.5 R84.2 U5.A2 U6.4
EXT_PROC_RSTN: J3.6 R847.2 U5.A5
F_CLK_FPGA_100M_N: R6841.1 R6842.2 R6929.1 U8.CL19
F_CLK_FPGA_100M_P: R6840.1 R6843.2 R6929.2 U8.CK18
FAN_CTRL: J2.4 R91.1 U5.J5
FAN_TACH: R89.2 R92.1 U5.J1
FLASH0_1V8_CLK: R52.2 R770.2 U4.B2
FLASH0_1V8_CSN: R38.1 U4.C2 U5.E3
FLASH0_1V8_DATA0: U4.D3 U5.F5
FLASH0_1V8_DATA1: U4.D2 U5.C4
FLASH0_1V8_DATA2: R32.1 U4.C4(W#/DQ2) U5.F4
FLASH0_1V8_DATA3: R33.1 U4.D4 U5.C3
FLASH0_1V8_RESETN: R39.1 U4.A4 U5.G5
FLASH1_1V8_CLK: R54.2 R771.2 U3.B2
FLASH1_1V8_CSN: R36.1 U3.C2 U5.E1
FLASH1_1V8_DATA0: U3.D3 U5.F2
FLASH1_1V8_DATA1: U3.D2 U5.G2
FLASH1_1V8_DATA2: R34.1 U3.C4(W#/DQ2) U5.C2
FLASH1_1V8_DATA3: R35.1 U3.D4 U5.F1
FLASH1_1V8_RESETN: R37.1 U3.A4 U5.B1
FLASH_IMAGE_SEL0: J105.1 R848.2 U5.J15
FLASH_IMAGE_SEL1: J106.1 R849.2 U5.J16
FPGA_1V2_AVSTX16_CLK: R71.2 U8.B44
FPGA_1V2_AVSTX16_D0: U5.P14 U8.A35
FPGA_1V2_AVSTX16_D1: U5.T14 U8.B36
FPGA_1V2_AVSTX16_D2: U5.R14 U8.E35
FPGA_1V2_AVSTX16_D3: U5.T15 U8.D36
FPGA_1V2_AVSTX16_D4: U5.L11 U8.A37
FPGA_1V2_AVSTX16_D5: U5.L12 U8.B38
FPGA_1V2_AVSTX16_D6: U5.N14 U8.E37
FPGA_1V2_AVSTX16_D7: U5.M15 U8.D38
FPGA_1V2_AVSTX16_D8: U5.P15 U8.B40
FPGA_1V2_AVSTX16_D9: U5.M14 U8.E39
FPGA_1V2_AVSTX16_D10: U5.N16 U8.D40
FPGA_1V2_AVSTX16_D11: U5.R15 U8.A41
FPGA_1V2_AVSTX16_D12: U5.P16 U8.B42
FPGA_1V2_AVSTX16_D13: U5.R16 U8.E41
FPGA_1V2_AVSTX16_D14: U5.K11 U8.D42
FPGA_1V2_AVSTX16_D15: U5.K12 U8.A43
FPGA_1V2_AVSTX16_READY: U5.L15 U8.E49
FPGA_1V2_AVSTX16_VALID: U5.M16 U8.A39
FPGA_1V2_LED0: R818.2 U8.B50 U87.2
FPGA_1V2_LED1: R817.2 U8.A49 U87.3
FPGA_1V2_LED2: R816.2 U8.D48 U87.4
FPGA_1V2_LED3: R815.2 U8.E47 U87.5
FPGA_1V2_SCL: R381.1 U8.K44 U39.3
FPGA_1V2_SDA: R382.1 U8.J43 U39.4
FPGA_1V8_ASX4_CLK: R103.2 R769.1 U9.B2
FPGA_1V8_ASX4_CS0N_MSEL0: R105.1 U8.CC45 U9.C2
FPGA_1V8_ASX4_D0: U8.CG45 U9.D3
FPGA_1V8_ASX4_D1: U8.CA45 U9.D2
FPGA_1V8_ASX4_D2: R772.1 U8.CF46 U9.C4(W#/DQ2)
FPGA_1V8_ASX4_D3: R773.1 U8.CH46 U9.D4
FPGA_1V8_ASX4_RESETN: R106.1 U8.CB44 U9.A4
FPGA_1V8_CATTRIPN: R764.1 U5.L10 U8.CD48
FPGA_1V8_CONF_DONE: Q15.1 U5.L9 U8.CH44
FPGA_1V8_CVP_CONF_DONE: U5.M11 U8.BY46
FPGA_1V8_INIT_DONE: R762.2 U5.P12 U8.CA43
FPGA_1V8_JTAG_TCK: R761.2 U5.P11 U8.CF44
FPGA_1V8_JTAG_TDI: R760.1 U5.R12 U8.CC43
FPGA_1V8_JTAG_TDO: U5.P10 U8.CC49
FPGA_1V8_JTAG_TMS: R759.1 U5.R11 U8.CE43
FPGA_1V8_MSEL1: R97.1 SW3.1 U5.P13 U8.CR55
FPGA_1V8_MSEL2: R98.1 SW3.2 U5.T12 U8.CF48
FPGA_1V8_NCONFIG: R96.1 U5.M10 U8.CC47
FPGA_1V8_NSTATUS: R95.1 U5.T13 U8.CE47
FPGA_1V8_SVID_SCL: R366.1 U8.CG47 U36.3
FPGA_1V8_SVID_SDA: R367.1 U8.CB46 U36.4
FPGA_3V3_LED0: Q7.1 R822.2 U87.10
FPGA_3V3_LED1: Q12.1 R823.2 U87.9
FPGA_3V3_LED2: Q13.1 R824.2 U87.8
FPGA_3V3_LED3: Q14.1 R825.2 U87.7
FPGA_3V3_SCL: J7.11 J8.11 R379.1 U38.6 U46.6 U97.14
FPGA_3V3_SDA: J7.12 J8.12 R378.1 U38.5 U46.5 U97.15
FPGA_3V3_SVID_SCL: R369.1 R530.1 R539.1 R6907.2 U36.6 U61.15
FPGA_3V3_SVID_SDA: R368.1 R529.1 R538.1 R6906.2 U36.5 U61.16
FPGA_CXL_PERSTN: R126.1 R127.2 U8.BR43
FPGA_CXL_PRSNTX4_N: R786.1 U8.F50 U22.2
FPGA_CXL_RSTN: R820.1 U8.D44 U88.3
FPGA_GNDSENSE: C122.1 R534.1 U8.BC19
FPGA_OSC_CLK1: R107.2 U8.CB42
FPGA_RCVD_CLK1_REFOUT_N: C1009.1 R232.1 U8.AE49
FPGA_RCVD_CLK1_REFOUT_P: C1008.1 R232.2 U8.AG49
FPGA_RCVD_CLK2_REFOUT_N: C1011.1 R233.1 U8.V46
FPGA_RCVD_CLK2_REFOUT_P: C1010.1 R233.2 U8.W45
FPGA_TEMP0AN: R338.2 U8.CD50
FPGA_TEMP0AP: R337.2 U8.CE49
FPGA_TEMP3N: R341.2 U8.CA11
FPGA_TEMP3P: R339.2 U8.CB12
FPGA_TEMP4N: R344.2 U8.AJ45
FPGA_TEMP4P: R342.2 U8.AG45
FPGA_TEMPDIODE0CN: R347.2 U8.AE43
FPGA_TEMPDIODE0CP: R346.2 U8.AC43
FPGA_VCC: C504.1 C505.1 C506.1 C507.1 C508.1 C509.1 C510.1 C511.1 C512.1 C513.1 C514.1 C515.1 C516.1 C517.1 C518.1 C519.1 C520.1 C521.1 C1032.1 C1033.1 C1034.1 C1035.1 C1036.1 C1037.1 C1038.1 C1039.1 C1040.1 C1041.1 C1042.1 C1043.1 C1044.2 C1238.1 C1239.1 C1240.1 C1241.1 C1242.1 C1243.1 C1244.1 C1245.1 C1246.1 C1247.1 C1248.1 C1249.1 C1250.1 C1251.1 C1252.1 C1253.1 C1254.1 C1255.1 C1256.1 C1257.1 C1258.1 C1259.1 C1260.2 C1261.2 C1262.2 C1263.2 C1264.2 C1265.2 C1266.2 C1267.2 C1268.2 C1269.2 C1270.2 C1271.2 C1272.2 C1273.2 C1274.2 C1275.2 C1276.2 C1277.2 C1278.2 C1279.2 C1280.2 C1281.2 C1282.2 C1283.2 C1284.2 C1285.2 C1286.2 C1287.2 C1288.2 C1289.2 COUT1.1 COUT2.1 COUT3.1 COUT4.1 COUT5.1 COUT6.1 COUT7.1 COUT8.1 COUT9.1 COUT10.1 COUT11.1 COUT12.1 COUT13.1 COUT14.1 COUT15.1 COUT16.1 COUT17.1 COUT18.1 COUT19.1 COUT20.1 COUT21.1 COUT22.1 COUT23.1 COUT24.1 COUT25.1 COUT26.1 COUT27.1 COUT28.1 COUT29.1 COUT30.1 COUT31.1 COUT32.1 FB2.2 L5.2 L6.2 L7.2 L8.2 R532.2 U8.AC19 U8.AD18 U8.AE19 U8.AF18 U8.AG19 U8.AG21 U8.AG23 U8.AG25 U8.AG27 U8.AG31 U8.AG33 U8.AG35 U8.AG37 U8.AG39 U8.AH38 U8.AH40 U8.AJ17 U8.AJ19 U8.AJ21 U8.AJ23 U8.AJ25 U8.AJ27 U8.AJ31 U8.AJ33 U8.AJ35 U8.AJ37 U8.AJ39 U8.AK18 U8.AK22 U8.AK24 U8.AK28 U8.AK30 U8.AK34 U8.AK36 U8.AK40 U8.AL17 U8.AL19 U8.AL23 U8.AL25 U8.AL29 U8.AL31 U8.AL35 U8.AL37 U8.AM18 U8.AM20 U8.AM24 U8.AM26 U8.AM30 U8.AM32 U8.AM36 U8.AM38 U8.AN19 U8.AN21 U8.AN25 U8.AN27 U8.AN31 U8.AN33 U8.AN37 U8.AN39 U8.AP20 U8.AP22 U8.AP26 U8.AP28 U8.AP32 U8.AP34 U8.AP38 U8.AR17 U8.AR21 U8.AR23 U8.AR25 U8.AR27 U8.AR29 U8.AR31 U8.AR33 U8.AR35 U8.AR39 U8.AT18 U8.AT22 U8.AT34 U8.AT36 U8.AU17 U8.AU19 U8.AU35 U8.AU37 U8.AV18 U8.AV20 U8.AV22 U8.AV34 U8.AV36 U8.AV38 U8.AW19 U8.AW21 U8.AW37 U8.AW39 U8.AY20 U8.AY22 U8.AY34 U8.AY38 U8.BA17 U8.BA21 U8.BA35 U8.BA39 U8.BB18 U8.BB22 U8.BB34 U8.BB36 U8.BC17 U8.BC35 U8.BC37 U8.BD18 U8.BD20 U8.BD22 U8.BD34 U8.BD36 U8.BD38 U8.BE21 U8.BE37 U8.BE39 U8.BF20 U8.BF22 U8.BF34 U8.BF38 U8.BG17 U8.BG21 U8.BG35 U8.BG39 U8.BH18 U8.BH22 U8.BH34 U8.BH36 U8.BJ17 U8.BJ19 U8.BJ35 U8.BJ37 U8.BK18 U8.BK20 U8.BK22 U8.BK34 U8.BK36 U8.BK38 U8.BK40 U8.BL19 U8.BL21 U8.BL37 U8.BL39 U8.BM20 U8.BM22 U8.BM34 U8.BM38 U8.BM40 U8.BN17 U8.BN21 U8.BN35 U8.BN39 U8.BP18 U8.BP22 U8.BP34 U8.BP36 U8.BP40 U8.BR17 U8.BR19 U8.BR23 U8.BR25 U8.BR27 U8.BR29 U8.BR31 U8.BR33 U8.BR35 U8.BR37 U8.BT18 U8.BT20 U8.BT24 U8.BT26 U8.BT30 U8.BT32 U8.BT36 U8.BT38 U8.BU19 U8.BU21 U8.BU25 U8.BU27 U8.BU31 U8.BU33 U8.BU37 U8.BU39 U8.BV20 U8.BV22 U8.BV26 U8.BV28 U8.BV32 U8.BV34 U8.BV38 U8.BV40 U8.BW17 U8.BW21 U8.BW23 U8.BW27 U8.BW29 U8.BW33 U8.BW35 U8.BW39 U8.BY18 U8.BY22 U8.BY24 U8.BY28 U8.BY30 U8.BY34 U8.BY36 U8.BY40 U8.CA17 U8.CA19 U8.CA21 U8.CA23 U8.CA25 U8.CA27 U8.CA29 U8.CA31 U8.CA33 U8.CA35 U8.CA37 U8.CB36 U8.CC19 U8.CC21 U8.CC23 U8.CC25 U8.CC27 U8.CC29 U8.CC31 U8.CC33
FPGA_VCC_GND: C691.2 C694.2 C697.2 C698.2 C699.2 C700.2 C712.2 C730.2 C748.2 C766.2 C1219.2 R547.2 R550.2 R551.2 R552.2 R553.2 R554.1 R555.1 R557.1 R558.1 R572.1 R580.1 R588.1 R596.1 ST7.2 ST8.2 ST9.2 ST10.2 ST11.2 U61.53
FPGA_VCC_HSSI_GND: C784.2 R604.1 ST14.2
FPGA_VCC_HSSI_GNDSENSE: C701.1 R6900.2 U61.41(VSENSE1-)
FPGA_VCC_HSSI_GXF: C522.2 C523.2 C526.2 C527.2 C528.2 C529.2 C542.2 C543.2 C574.1 C575.1 C580.2 C581.2 C582.1 C583.1 C1047.2 C1048.2 C1074.2 C1075.2 COUT33.1 COUT34.1 COUT35.1 COUT36.1 COUT37.1 COUT39.1 FB3.2 L9.2 R6899.1 U8.AH42 U8.AJ41 U8.AK42 U8.AL41 U8.AM42 U8.AN41 U8.AP40 U8.AP42 U8.AR41 U8.AT42 U8.AU41 U8.AV40 U8.AV42 U8.AW41 U8.AY14 U8.AY42 U8.BA15 U8.BA41 U8.BB14 U8.BB40 U8.BB42 U8.BC15 U8.BC41 U8.BD14 U8.BD16 U8.BD42 U8.BE15 U8.BE41 U8.BF14 U8.BF40 U8.BF42 U8.BG15 U8.BG41 U8.BH14 U8.BH16 U8.BH42 U8.BJ15 U8.BJ41 U8.BK14 U8.BK42 U8.BL15 U8.BL41 U8.BM14 U8.BM16 U8.BN15 U8.BP14 U8.BR15 U8.BT14 U8.BT16 U8.BU15 U8.BV14 U8.BW15 U8.BY14 U8.CA15 U8.CB14 U8.CC15 U8.CC37 U8.CD38 U8.CE37 U8.CF38
FPGA_VCC_HSSI_GXF_PG: R564.2 R643.1 U61.36
FPGA_VCC_HSSI_SENSE: C701.2 R6899.2 U61.40
FPGA_VCC_PG: R563.2 R642.1 U61.11
FPGA_VCCA_PLL: C123.2 C124.1 C125.1 C548.1 C549.1 FB7.1 U8.AA23 U8.AA27 U8.AA31 U8.AA35 U8.CJ21 U8.CJ25 U8.CJ29 U8.CJ33
FPGA_VCCCLK_GXF: C107.2 C112.2 C113.2 C114.2 C115.2 C119.1 C120.1 C121.2 C1026.2 C1070.1 C1071.1 FB5.1 R119.2 R126.2 R841.2 U8.AW11 U8.AY10 U8.BM46 U8.BN45 U12.5 U91.5
FPGA_VCCERT_FGT_GXF: C576.1 C577.1 C584.1 C585.1 C588.2 C589.2 C590.2 C591.2 C1076.2 C1077.2 C1078.2 C1079.2 C1128.2 C1129.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.1 C1224.2 L10.2 R6852.2 R6857.2 U8.AN43 U8.AP44 U8.AT44 U8.AU43 U8.AV44 U8.AY44 U8.BA13 U8.BA43 U8.BB12 U8.BB44 U8.BD12 U8.BD44 U8.BE13 U8.BE43 U8.BF12 U8.BF44 U8.BH12 U8.BH44 U8.BJ13 U8.BJ43 U8.BK12 U8.BK44 U8.BM12 U8.BN13 U8.BP12 U8.BT12 U8.BU13 U8.BV12
FPGA_VCCERT_FGT_GXF_PG: R645.1 U93.C8
FPGA_VCCFUSEWR_GXF: C865.2 C866.2 C867.2 C868.2 C1072.2 C1073.1 R666.1 U8.AW13 U8.AY12 U8.BM44 U8.BN43 U70.1 U70.2(VOUT2)
FPGA_VCCFUSEWR_GXF_PG: R663.2 R667.1 U70.4
FPGA_VCCH_FGT_GXF: C126.1 C127.1 C128.2 C578.1 C579.1 C586.1 C587.1 FB6.1 FB8.1 U8.AN45 U8.AP46 U8.AT46 U8.AU45 U8.AV46 U8.AY46 U8.BA11 U8.BA45 U8.BB10 U8.BB46 U8.BD10 U8.BD46 U8.BE11 U8.BE45 U8.BF10 U8.BF46 U8.BH10 U8.BH46 U8.BJ11 U8.BJ45 U8.BK10 U8.BK46 U8.BM10 U8.BN11 U8.BP10 U8.BT10 U8.BU11 U8.BV10
FPGA_VCCH_PG: R644.1 R741.2 U80.4
FPGA_VCCH_SDM: C530.2 C977.2 C978.2 C979.2 C980.2 C1045.2 C1046.2 R742.2 U8.CE39 U80.1 U80.2(VOUT2)
FPGA_VCCIO_1V2: C132.1 C133.1 C134.1 C135.1 C136.1 C137.1 C138.1 C139.1 C140.1 C141.1 C142.1 C143.1 C146.2 C147.2 C148.1 C149.1 C150.1 C151.1 C154.1 C155.1 C166.1 C167.1 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C180.2 C181.2 C182.1 C183.1 C184.1 C185.1 C186.1 C188.1 C205.1 C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 C212.1 C213.1 C214.1 C215.1 C216.1 C217.1 C218.1 C219.1 C220.1 C221.1 C222.2 C223.2 C224.1 C225.1 C226.1 C227.1 C228.1 C229.1 C230.1 C231.1 C232.1 C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C257.1 C258.1 C259.1 C260.1 C261.1 C262.1 C263.1 C264.1 C265.1 C266.1 C267.1 C268.2 C269.2 C270.1 C271.1 C272.1 C273.1 C274.1 C275.1 C276.1 C277.1 C278.1 C279.1 C280.1 C281.1 C282.1 C283.1 C284.1 C285.1 C286.1 C287.1 C288.1 C346.2 C472.1 C533.1 C534.1 C535.1 C536.1 C537.1 C538.1 C539.1 C540.1 C952.2 C953.2 C954.2 C955.2 C966.1 C967.1 C968.1 C969.1 C970.1 C971.1 C972.1 C973.1 C974.1 C975.1 C1019.1 C1020.1 C1022.1 C1024.1 C1054.1 C1055.1 C1056.1 C1057.1 C1058.1 C1059.1 C1060.1 C1061.1 C1062.1 C1063.1 C1064.1 C1065.1 C1066.1 C1067.1 C1068.1 C1069.1 C1181.2 C1182.2 C1185.2 C1186.2 C1187.2 C1188.2 C1189.1 J4.59 J4.61 J4.64 J4.67 J4.70 J4.73 J4.76 J4.80 J4.83 J4.85 J4.88 J4.90 J4.92 J4.204 J4.206 J4.209 J4.212 J4.215 J4.217 J4.220 J4.223 J4.226 J4.229 J4.231 J4.233 J4.236 J5.59 J5.61 J5.64 J5.67 J5.70 J5.73 J5.76 J5.80 J5.83 J5.85 J5.88 J5.90 J5.92 J5.204 J5.206 J5.209 J5.212 J5.215 J5.217 J5.220 J5.223 J5.226 J5.229 J5.231 J5.233 J5.236 L13.2 R40.2 R41.2 R42.2 R43.2 R139.2 R143.2 R155.2 R159.2 R194.1 R195.1 R197.1 R381.2 R382.2 R721.2 R722.2 R786.2 R814.2 R819.2 R820.2 R821.2 R6865.2 R6871.2 R6895.2 R6898.2 U8.AC21 U8.AC23 U8.AC35 U8.AC37 U8.AE21 U8.AE23 U8.AE35 U8.AE37 U8.CC39 U8.CE19 U8.CE21 U8.CE23 U8.CE25 U8.CE27 U8.CE29 U8.CE31 U8.CE33 U8.CG19 U8.CG21 U8.CG23 U8.CG25 U8.CG27 U8.CG29 U8.CG31 U8.CG33 U15.A1 U15.B2 U15.B8 U15.C1 U15.C7 U15.C9 U15.E2 U15.E8 U15.F1 U15.F9 U15.H1 U15.J9 U15.M1 U15.N9 U16.A1 U16.B2 U16.B8 U16.C1 U16.C7 U16.C9 U16.E2 U16.E8 U16.F1 U16.F9 U16.H1 U16.J9 U16.M1 U16.N9 U17.A1 U17.B2 U17.B8 U17.C1 U17.C7 U17.C9 U17.E2 U17.E8 U17.F1 U17.F9 U17.H1 U17.J9 U17.M1 U17.N9 U18.A1 U18.B2 U18.B8 U18.C1 U18.C7 U18.C9 U18.E2 U18.E8 U18.F1 U18.F9 U18.H1 U18.J9 U18.M1 U18.N9 U19.A1 U19.B2 U19.B8 U19.C1 U19.C7 U19.C9 U19.E2 U19.E8 U19.F1 U19.F9 U19.H1 U19.J9 U19.M1 U19.N9 U22.1(VL) U22.8 U39.2 U77.2 U78.2 U87.1(VL) U87.12 U88.1(VL) U88.12 U89.1(VL) U89.12 U90.1(VL) U90.12
FPGA_VCCIO_1V2_PG: R713.1 U96.F8
FPGA_VCCIO_SDM_HPS: C101.2 C466.1 C561.2 C562.2 C571.2 C920.2 C921.2 C922.2 C923.2 FB27.1 FB28.1 FB29.1 FB37.1 FB38.1 FB39.1 FB40.1 R95.2 R96.2 R97.2 R98.2 R204.2 R205.2 R207.2 R266.2 R268.2 R271.2 R272.2 R279.2 R284.2 R286.2 R293.2 R298.2 R300.2 R302.1 R303.2 R304.1 R305.2 R306.1 R315.2 R320.2 R322.2 R324.2 R325.2 R366.2 R367.2 R706.2 R740.2 R759.2 R760.2 R763.2 R764.2 R765.2 R6896.2 R6904.2 SW4.8 U8.AC17 U8.AE17 U8.AG17 U8.CG37 U8.CG41 U8.CJ41 U10.1 U10.4(VDD) U36.2 U74.1 U74.2(VOUT2)
FPGA_VCCIO_SDM_HPS_PG: R704.2 R711.1 U74.4
FPGA_VCCLSENSE: C122.2 R533.1 U8.BE19
FPGA_VCCPLL: C116.1 C117.1 C118.2 C550.2 C551.2 C552.2 C1050.1 C1051.1 C1052.1 C1053.1 FB4.1 U8.AH16 U8.CC41 U8.CF40
FPGA_VCCPLLDIG_HPS: C108.2 C109.1 C525.2 FB2.1 U8.AF16
FPGA_VCCPLLDIG_SDM: C110.2 C111.1 C544.2 FB3.1 U8.CG39
FPGA_VCCPT: C297.1 C298.1 C299.1 C300.1 C301.1 C302.1 C524.1 C545.1 C546.1 C864.1 C1049.1 C1166.2 C1167.2 C1170.2 C1171.2 C1172.2 C1173.2 C1174.1 FB4.2 FB5.2 FB6.2 FB8.2 J6.2 J6.59 L12.2 R6862.2 R6869.2 U8.AF22 U8.AF26 U8.AF30 U8.AF34 U8.CD20 U8.CD24 U8.CD28 U8.CD32 U70.7 U70.9 U70.10
FPGA_VCCPT_PG: R665.1 U96.C8
FPGA_VCCR_CORE: C541.1 C572.1 C573.1 C1138.2 C1139.2 C1142.2 C1143.2 C1144.2 C1145.2 C1146.1 FB7.2 L11.2 R6855.2 R6859.2 U8.AH20 U8.AH24 U8.AH28 U8.AH32 U8.AH36 U8.CB18 U8.CB22 U8.CB26 U8.CB30 U8.CB34
FPGA_VCCR_CORE_PG: R712.1 U93.F8
FX2_D_N: J10.2 U48.2 U49.9
FX2_D_P: J10.3 U48.1 U49.8
FX2_FLAGA: U5.R4 U49.29
FX2_FLAGB: U5.T3 U49.30
FX2_FLAGC: U5.P5 U49.31
FX2_PA0: U5.T4 U49.33
FX2_PA1: U5.M7 U49.34
FX2_PA2: U5.T7 U49.35
FX2_PA3: U5.L8 U49.36
FX2_PA4: U5.T6 U49.37
FX2_PA5: U5.R7 U49.38
FX2_PA6: U5.T8 U49.39
FX2_PA7: U5.P6 U49.40
FX2_PB0: U5.R8 U49.18
FX2_PB1: U5.T9 U49.19
FX2_PB2: U5.P8 U49.20
FX2_PB3: U5.R9 U49.21
FX2_PB4: U5.M8 U49.22
FX2_PB5: U5.M9 U49.23
FX2_PB6: U5.T11 U49.24
FX2_PB7: U5.R10 U49.25
FX2_PD0: U6.16 U49.45
FX2_PD1: U6.3 U49.46
FX2_PD2: U6.9 U49.47
FX2_PD3: U6.12 U49.48
FX2_PD4: U5.T2 U49.49
FX2_PD5: U5.R6 U49.50
FX2_PD6: U5.T5 U49.51
FX2_PD7: U5.R5 U49.52
FX2_RESETN: R449.2 U5.M6 U47.2 U49.42
FX2_SCL: R451.1 U5.R1 U49.15
FX2_SDA: R452.1 U5.R3 U49.16
FX2_SLRDN: U5.L7 U49.1
FX2_SLWRN: U5.R2 U49.2
FX2_WAKEUP: C491.1 R446.2 R447.2 R448.2 U49.44
GFX_1ST_PERSTN: R840.1 U5.B9 U91.2
GPIO0_3V3_AC0_ZL_INT_N: R242.1 R258.2 U5.H6 U23.49
GPIO1_3V3_AC1_PTP_CLK_LOL: R243.1 R259.2 U5.J3 U23.48
GPIO2_1V2_AC2_FPGA_HPS_ZL_HO: R814.1 U5.L16 U88.5
GPIO2_3V3_AC2_FPGA_HPS_ZL_HO: R244.1 R260.2 U23.47 U88.7
GPIO4_AC4: R246.1 R262.2 U23.45
GXF_1V2_2ND_PERSTN: R821.1 U8.B46 U88.4
GXF_2ND_PERSTN: R119.1 R428.2 S4.2 U5.C1 U8.CN11 U33.6
GXF_3V3_2ND_PERSTN: R808.1 U33.15 U88.8
HPS_COLD_RESETN: R738.1 R763.1 U5.M3 U8.CE45
HPS_CON_GPIO26: J6.29 U8.AF8
HPS_CON_GPIO27: J6.30 U8.AT12
HPS_DC_PG: J6.54 R206.1 U5.K5
HPS_DC_PRSENT_N: J6.52 R208.1 U5.N1
HPS_DC_PWR_EN: J6.51 R209.1 U5.M2
HPS_DC_RST_N: J6.53 R207.1 R210.1 U5.K6
HPS_GPIO0: J6.3 U8.AC15
HPS_GPIO1: J6.4 U8.AL15
HPS_GPIO2: J6.5 U8.AJ11
HPS_GPIO3: J6.6 U8.AM16
HPS_GPIO4: J6.7 U8.AH12
HPS_GPIO5: J6.8 U8.AN15
HPS_GPIO6: J6.9 U8.AG13
HPS_GPIO7: J6.10 U8.AP16
HPS_GPIO8: J6.11 U8.AF14
HPS_GPIO9: J6.12 U8.AT16
HPS_GPIO10: J6.13 U8.AH10
HPS_GPIO11: J6.14 U8.AU15
HPS_GPIO12: J6.15 U8.AJ7
HPS_GPIO13: J6.16 U8.AL13
HPS_GPIO14: J6.17 U8.AH8
HPS_GPIO15: J6.18 U8.AM14
HPS_GPIO16: J6.19 U8.AD14
HPS_GPIO17: J6.20 U8.AN13
HPS_GPIO18: J6.21 U8.AG11
HPS_GPIO19: J6.22 U8.AP14
HPS_GPIO20: J6.23 U8.AG9
HPS_GPIO21: J6.24 U8.AT14
HPS_GPIO22: J6.25 U8.AF12
HPS_GPIO23: J6.26 U8.AU13
HPS_GPIO24: J6.27 U8.AF10
HPS_GPIO25: J6.28 U8.AU11
HPS_GPIO28: J6.31 U8.AG7
HPS_GPIO29: J6.32 U8.AP12
HPS_GPIO30: J6.33 R204.1 ST1.1 U8.AC13
HPS_GPIO31: J6.34 R203.2 R205.1 ST2.1 U8.AN11
HPS_GPIO32: J6.35 U8.AD12
HPS_GPIO33: J6.36 U8.AM12
HPS_GPIO34: J6.37 U8.AD10
HPS_GPIO35: J6.38 U8.AL11
HPS_GPIO36: J6.39 U8.AC11
HPS_GPIO37: J6.40 U8.AT10
HPS_GPIO38: J6.41 U8.AD8
HPS_GPIO39: J6.42 U8.AP10
HPS_GPIO40: J6.43 U8.AC9
HPS_GPIO41: J6.44 U8.AM10
HPS_GPIO42: J6.45 U8.AB10
HPS_GPIO43: J6.46 U8.AJ13
HPS_GPIO44: J6.47 U8.AB14
HPS_GPIO45: J6.48 U8.AH14
HPS_GPIO46: J6.49 U8.AB12
HPS_GPIO47: J6.50 U8.AJ9
HPS_JTAG_BYPASS: R765.1 SW3.4 U5.D1
HPS_RESETN: R422.2 R425.2 S2.2 U5.N5
HPS_SCL: ST2.2 U5.N3
HPS_SDA: ST1.2 U5.L6
HPS_TCK: J6.55 U5.L1
HPS_TDI: J6.56 U5.L3
HPS_TDO: J6.58 U5.K2
HPS_TMS: J6.57 U5.J6
INLET_TEMP_N: Q2.2 R349.2
INLET_TEMP_P: Q2.1(EMITTER) R348.2
IOEXP_INTN: R6895.1 U8.E43 U97.13
IREF: C711.2 C712.1 C729.2 C730.1 C747.2 C748.1 C765.2 C766.1 C783.2 C784.1 C1219.1 R543.2 R544.1 R545.1 R546.1 R547.1 R573.2 R581.2 R589.2 R597.2 R605.2 U61.33
ISENSE0: C711.1 R572.2 R573.1 U61.4 U62.33
ISENSE1: C783.1 R604.2 R605.1 U61.43 U66.33
ISENSE2: C729.1 R580.2 R581.1 U61.3 U63.33
ISENSE3: C747.1 R588.2 R589.1 U61.52 U64.33
ISENSE4: C765.1 R596.2 R597.1 U61.51 U65.33
LT_1V8_SCK: R53.2 U33.1
LT_1V8_SCSN: R737.1 U5.P1 U33.5
LT_1V8_SDI: U5.L2 U33.3
LT_1V8_SPI_ERRN: R768.1 U5.M1 U33.4
LT_3V3_SCK: R559.2 U33.20
LT_3V3_SCSN: R565.2 U33.16
LT_3V3_SDI: R556.2 U33.18
LT_3V3_SPI_ERRN: R561.2 U33.17
LT_SCL: J107.3 R6882.2
LT_SDA: J107.1(SDA) R6881.2
LT_SVID_SCL: J13.3 R530.2
LT_SVID_SDA: J13.1(SDA) R529.2
LTC_FAULT_N: R72.2 R560.2 U5.B12 U61.18 U61.19
LTC_INTVCC: C690.2 U61.31
LTC_SYNC: R540.2 U61.14
LTC_VDD25: C691.1 U61.28
LTC_VDD33: C694.1 D17.1(C) R535.1 R536.1 R537.2 R538.2 R539.2 R540.1 R543.1 R560.1 R562.1 R563.1 R564.1 R566.1 U61.30
MAX10_50MHZ_CLK: R93.2 U5.D9
MAX10_CONFIG_SEL: R77.2 R78.1 U5.F8
MAX10_FPGA_RESETN: R6898.1 U5.A13 U8.D54 U8.Y42
MAX10_JTAG_EN: R55.1 SW6.1 U5.G6
MAX10_NCONFIG: R503.2 R504.2 R505.2 R506.2 R507.2 U5.E8
MAX10_NSTATUS: R80.1 U5.F7
MAX_1V2: C52.2 C53.1 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C659.2 C660.2 C661.2 C662.2 FB1.2 R499.2 U5.D10 U5.D11 U5.F6 U5.G7 U5.G9 U5.H8 U5.H9 U5.H10 U5.J7 U5.J8 U5.J9 U5.K8(VCC_K8) U5.K10 U5.K13 U5.L13 U5.M13 U58.1 U58.2(VOUT2)
MAX_1V2_FPGA_SPARE0: R40.1 R56.2 U5.D12 U8.G47
MAX_1V2_FPGA_SPARE1: R41.1 R57.2 U5.C13 U8.K46
MAX_1V2_FPGA_SPARE2: R42.1 R58.2 U5.E11 U8.J45
MAX_1V2_FPGA_SPARE3: R43.1 R59.2 U5.C12 U8.F46
MAX_1V8: C48.2 C49.2 C50.2 C51.2 C72.1 C73.1 C99.2 C100.2 C461.2 C655.2 C656.2 C657.2 C658.2 R32.2 R33.2 R34.2 R35.2 R36.2 R37.2 R38.2 R39.2 R105.2 R106.2 R359.2 R498.2 R737.2 R738.2 R768.2 R772.2 R773.2 U3.B4 U4.B4 U5.G4 U5.H4 U5.K4 U5.L4 U5.N10 U5.N11 U9.B4 U33.2(VL) U33.10 U57.1 U57.2(VOUT2)
MAX_2V5: C92.2 C93.1 C94.1 C95.1 C96.1 C97.1 C651.2 C652.2 C653.2 C654.2 R497.2 U5.D5 U5.E5 U5.E12 U5.L5 U5.M12 U56.1 U56.2(VOUT2)
MAX_CONF_DONE: Q1.1 R81.1 U5.E7
MAX_I2C_SCL: EU1.12 EU2.12 J12.1 R69.1 R263.1 R282.1 R473.1 R6882.1 R6907.1 R6944.2 U23.36 U44.6 U50.1 U54.1 U93.B3 U96.B3
MAX_I2C_SDA: EU1.11 EU2.11 J12.3 R70.1 R264.1 R283.1 R6881.1 R6906.1 R6945.2 U23.35 U44.5 U50.19 U54.19 U93.A3 U96.A3
MAX_VCCD: C88.1 C89.1 C90.1 C91.1 FB1.1 U5.D4 U5.D13 U5.M5 U5.N13
NIOS_CLK: R79.2 U45.6
NIOS_CSN: R432.1 U5.B6 U45.1
NIOS_IO0: U5.A7 U45.5
NIOS_IO1: U5.C6 U45.2
NIOS_IO2: R433.1 U5.A6 U45.3(W\P\/IO2)
NIOS_IO3: R434.1 U5.B5 U45.7
OUTLET_TEMP_N: Q3.2 R353.2
OUTLET_TEMP_P: Q3.1(EMITTER) R351.2
OVERTEMP_LEDN: D5.C(CATHODE) R780.1 U5.G11
PCIE_3V3_AUX: C37.2 J1.B10 R3.1 R4.1 R8.2 R24.2 R25.2 R26.2 R27.2 U2.8
PCIE_3V3_EP_CLKREQN: C16.1 J1.B12
PCIE_3V3_EP_PERSTN: J1.A11 R6.2 U5.A11
PCIE_3V3_EP_PWRBRKN: C19.1 R12.2 R774.1 U5.A10
PCIE_3V3_EP_SMBCLK: J1.B5 R1.1 R3.2 R6944.1 U2.6
PCIE_3V3_EP_SMBDAT: J1.B6 R2.1 R4.2 R6945.1 U2.5
PCIE_3V3_EP_WAKEN: J1.B11(WAKE_N) R8.1
PCIE_EP_3V3: J1.A9 J1.A10 J1.B8 R1.2 R2.2 R7.2
PCIE_EP_12V: C592.1 C593.1 C594.1 C595.1 C596.1 C597.1 C598.1 D13.1(C) J1.A2 J1.A3 J1.B1 J1.B2 J1.B3 R456.1 R466.1 U50.9 U50.10 U50.11 U50.12
PCIE_EP_JTAG_TCK: J1.A5 R334.1 U31.1
PCIE_EP_JTAG_TDI: J1.A6 R331.2 U31.3
PCIE_EP_JTAG_TDO: J1.A7 R328.1
PCIE_EP_JTAG_TMS: J1.A8 R326.2 U28.1
PCIE_EP_PRSNT_N: J1.A1 SW1.1 SW1.2 SW1.3 SW1.4
PCIE_EP_PRSNT_NX1: C27.1 J1.B17 SW1.5(B4)
PCIE_EP_PRSNT_NX4: C28.1 J1.B31 SW1.6
PCIE_EP_PRSNT_NX8: C29.1 J1.B48 SW1.7
PCIE_EP_PRSNT_NX16: C30.1 J1.B81 SW1.8
PCIE_EP_RX_CN0: C2.2 J1.A17
PCIE_EP_RX_CN1: C7.2 J1.A22
PCIE_EP_RX_CN2: C9.2 J1.A26
PCIE_EP_RX_CN3: C11.2 J1.A30
PCIE_EP_RX_CN4: C13.2 J1.A36
PCIE_EP_RX_CN5: C15.2 J1.A40
PCIE_EP_RX_CN6: C20.2 J1.A44
PCIE_EP_RX_CN7: C26.2 J1.A48
PCIE_EP_RX_CN8: C32.2 J1.A53
PCIE_EP_RX_CN9: C34.2 J1.A57
PCIE_EP_RX_CN10: C36.2 J1.A61
PCIE_EP_RX_CN11: C39.2 J1.A65
PCIE_EP_RX_CN12: C41.2 J1.A69
PCIE_EP_RX_CN13: C43.2 J1.A73
PCIE_EP_RX_CN14: C45.2 J1.A77
PCIE_EP_RX_CN15: C47.2 J1.A81
PCIE_EP_RX_CP0: C1.2 J1.A16
PCIE_EP_RX_CP1: C6.2 J1.A21
PCIE_EP_RX_CP2: C8.2 J1.A25
PCIE_EP_RX_CP3: C10.2 J1.A29
PCIE_EP_RX_CP4: C12.2 J1.A35
PCIE_EP_RX_CP5: C14.2 J1.A39
PCIE_EP_RX_CP6: C18.2 J1.A43
PCIE_EP_RX_CP7: C24.2 J1.A47
PCIE_EP_RX_CP8: C31.2 J1.A52
PCIE_EP_RX_CP9: C33.2 J1.A56
PCIE_EP_RX_CP10: C35.2 J1.A60
PCIE_EP_RX_CP11: C38.2 J1.A64
PCIE_EP_RX_CP12: C40.2 J1.A68
PCIE_EP_RX_CP13: C42.2 J1.A72
PCIE_EP_RX_CP14: C44.2 J1.A76
PCIE_EP_RX_CP15: C46.2 J1.A80
PCIE_EP_RX_N0: C2.1 U8.AL5
PCIE_EP_RX_N1: C7.1 U8.AM8
PCIE_EP_RX_N2: C9.1 U8.AR5
PCIE_EP_RX_N3: C11.1 U8.AT8
PCIE_EP_RX_N4: C13.1 U8.AW5
PCIE_EP_RX_N5: C15.1 U8.AY8
PCIE_EP_RX_N6: C20.1 U8.BC5
PCIE_EP_RX_N7: C26.1 U8.BG5
PCIE_EP_RX_N8: C32.1 U8.BL5
PCIE_EP_RX_N9: C34.1 U8.BR5
PCIE_EP_RX_N10: C36.1 U8.BW5
PCIE_EP_RX_N11: C39.1 U8.CC5
PCIE_EP_RX_N12: C41.1 U8.CG5
PCIE_EP_RX_N13: C43.1 U8.CL5
PCIE_EP_RX_N14: C45.1 U8.CM8
PCIE_EP_RX_N15: C47.1 U8.CT8
PCIE_EP_RX_P0: C1.1 U8.AK4
PCIE_EP_RX_P1: C6.1 U8.AN7
PCIE_EP_RX_P2: C8.1 U8.AP4
PCIE_EP_RX_P3: C10.1 U8.AU7
PCIE_EP_RX_P4: C12.1 U8.AV4
PCIE_EP_RX_P5: C14.1 U8.BA7
PCIE_EP_RX_P6: C18.1 U8.BB4
PCIE_EP_RX_P7: C24.1 U8.BF4
PCIE_EP_RX_P8: C31.1 U8.BK4
PCIE_EP_RX_P9: C33.1 U8.BP4
PCIE_EP_RX_P10: C35.1 U8.BV4
PCIE_EP_RX_P11: C38.1 U8.CB4
PCIE_EP_RX_P12: C40.1 U8.CF4
PCIE_EP_RX_P13: C42.1 U8.CK4
PCIE_EP_RX_P14: C44.1 U8.CN7
PCIE_EP_RX_P15: C46.1 U8.CU7
PCIE_EP_TX_N0: J1.B15 U8.AG5
PCIE_EP_TX_N1: J1.B20 U8.AH2
PCIE_EP_TX_N2: J1.B24 U8.AM2
PCIE_EP_TX_N3: J1.B28 U8.AT2
PCIE_EP_TX_N4: J1.B34 U8.AY2
PCIE_EP_TX_N5: J1.B38 U8.BD2
PCIE_EP_TX_N6: J1.B42 U8.BH2
PCIE_EP_TX_N7: J1.B46 U8.BM2
PCIE_EP_TX_N8: J1.B51 U8.BT2
PCIE_EP_TX_N9: J1.B55 U8.BY2
PCIE_EP_TX_N10: J1.B59 U8.CD2
PCIE_EP_TX_N11: J1.B63 U8.CH2
PCIE_EP_TX_N12: J1.B67 U8.CM2
PCIE_EP_TX_N13: J1.B71 U8.CR5
PCIE_EP_TX_N14: J1.B75 U8.CT2
PCIE_EP_TX_N15: J1.B79 U8.CW5
PCIE_EP_TX_P0: J1.B14 U8.AF4
PCIE_EP_TX_P1: J1.B19 U8.AJ1
PCIE_EP_TX_P2: J1.B23 U8.AN1
PCIE_EP_TX_P3: J1.B27 U8.AU1
PCIE_EP_TX_P4: J1.B33 U8.BA1
PCIE_EP_TX_P5: J1.B37 U8.BE1
PCIE_EP_TX_P6: J1.B41 U8.BJ1
PCIE_EP_TX_P7: J1.B45 U8.BN1
PCIE_EP_TX_P8: J1.B50 U8.BU1
PCIE_EP_TX_P9: J1.B54 U8.CA1
PCIE_EP_TX_P10: J1.B58 U8.CE1
PCIE_EP_TX_P11: J1.B62 U8.CJ1
PCIE_EP_TX_P12: J1.B66 U8.CN1
PCIE_EP_TX_P13: J1.B70 U8.CP4
PCIE_EP_TX_P14: J1.B74 U8.CU1
PCIE_EP_TX_P15: J1.B78 U8.CV4
PCIE_HSC_ALERT_N: R460.1 U5.A12 U50.15
PCIE_HSC_BST: C602.2 U50.4
PCIE_HSC_EN: C601.1 R456.2 R458.1 R469.2 U50.14
PCIE_HSC_FAULTB: R457.2 U50.16
PCIE_HSC_ILOAD: C604.1 R463.1 U50.2
PCIE_HSC_PG: R455.2 U5.B11 U50.17
PCIE_HSC_ROCP: R462.2 U50.18
PCIE_HSC_SMB_ID_R: R461.2 U50.20
PCIE_HSC_SS: C605.1 C606.1 U50.3
PCIE_PERSTN: R123.2 R427.2 R841.1 S3.2 U8.CG13
PCIE_RSV2: C17.1 J1.A19
PCIE_RSV4: C21.1 J1.A32
PCIE_RSV5: C22.1 J1.A33
PCIE_RSV6: C23.1 J1.B82
PCIE_RSV7: C25.1 J1.A50
PCIE_VDD_1V85: C599.2 C600.1 R457.1 U50.22
PG_0V6_DDR4_VREF_COMP: R729.1 U78.9
PG_0V6_DDR4_VREF_DIMM: R728.1 U77.9
PG_2V5_DDR4_COMP: R727.1 U76.4
PG_2V5_DDR4_DIMM: R726.1 U75.4
PG_DDR4_LDO: R714.1 R725.2 R726.2 R727.2 R728.2 R729.2
PG_MAX_1V2: R496.2 R506.1 U58.4
PG_MAX_1V8: R495.2 R505.1 U57.4
PG_MAX_2V5: R494.2 R504.1 U56.4
PG_ZL70733_1V8: R744.2 U81.4
POWER_ON: C623.1 R465.1 R472.2 R475.1 SW5.5 U54.14
PPS_FPGA_CLKOUT: R845.2 U23.8
PTP_CLK_RST_N: R265.1 R739.2 U5.J2 U23.16
PTP_SAMPLE_CLK_250M_N: C390.2 R6911.2 R6937.1 U8.D46
PTP_SAMPLE_CLK_250M_P: C389.2 R6911.1 R6936.1 U8.E45
PWM0: R574.2 U61.5
PWM1: R606.2 U61.42
PWM2: R582.2 U61.2
PWM3: R590.2 U61.1
PWM4: R598.2 U61.50
PWRGD_G0: R523.2 R526.2 R527.2 U5.H12
PWRGD_G1: R641.1 R642.2 R643.2 R644.2 R645.2 U5.G14
PWRGD_G2: R664.1 R665.2 R667.2 U5.G16
PWRGD_G3: R709.1 R711.2 R712.2 R713.2 R714.2 U5.G15
PWRGD_OUT: Q4.1 R398.1 U5.F16
QSFP_1V2_LED1: U8.B48 U90.3
QSFP_1V2_LED2: U8.A47 U90.4
QSFP_3V3_INT_L: J7.28 J8.28 R217.1 R784.1 U97.5
QSFP_3V3_LPMODE: J8.31 U97.6
QSFP_3V3_MODPRS_L: J8.27 R785.1 U5.P2 U97.9
QSFP_3V3_RESET_L: J7.9 J8.9 U97.4
QSFP_3V3_SELN: J8.8 R6894.1 U97.12
QSFP_FAULT_N: R220.1 U5.C14 U21.8
QSFP_LED1: Q11.1 R837.2 U90.9
QSFP_LED2: Q10.1 R836.2 U90.8
QSFP_PWR_EN: R223.2 U5.D15 U21.4
QSFP_REFCLK_N: C396.2 R6915.2 R6926.1 U8.AV48
QSFP_REFCLK_P: C393.2 R6915.1 R6925.1 U8.AW49
QSFP_RX0_N: J8.18 U8.BM54
QSFP_RX0_P: J8.17 U8.BL55
QSFP_RX1_N: J8.21 U8.AY54
QSFP_RX1_P: J8.22 U8.AW55
QSFP_RX2_N: J8.15 U8.BG55
QSFP_RX2_P: J8.14 U8.BH54
QSFP_RX3_N: J8.24 U8.BD54
QSFP_RX3_P: J8.25 U8.BC55
QSFP_TX0_N: J8.37 U8.BM48
QSFP_TX0_P: J8.36 U8.BL49
QSFP_TX1_N: J8.2 U8.BA51
QSFP_TX1_P: J8.3 U8.BB52
QSFP_TX2_N: J8.34 U8.BK52
QSFP_TX2_P: J8.33 U8.BJ51
QSFP_TX3_N: J8.5 U8.BF52
QSFP_TX3_P: J8.6 U8.BE51
QSFP_VCC: C335.2 C336.2 C337.2 C338.2 FB11.1 J8.30
QSFP_VCCR: C331.2 C332.2 C333.2 C334.2 FB10.1 J8.10
QSFP_VCCT: C327.2 C328.2 C329.2 C330.2 FB9.1 J8.29(VCCTX)
QSFPDD_1V2_LED1: U8.G49 U89.3
QSFPDD_1V2_LED2: U8.F48 U89.4
QSFPDD_3V3_LPMODE: J7.31 U97.7
QSFPDD_3V3_MODPRS_L: J7.27 R218.1 U5.P4 U97.10
QSFPDD_3V3_SELN: J7.8 R215.1 U97.11
QSFPDD_FAULT_N: R211.1 U5.D14 U20.8
QSFPDD_LED1: Q9.1 R834.2 U89.9
QSFPDD_LED2: Q8.1 R833.2 U89.8
QSFPDD_PWR_EN: R214.2 U5.E16 U20.4
QSFPDD_REFCLK_N: C392.2 R6914.1 R6924.2 U8.AC49
QSFPDD_REFCLK_P: C391.2 R6914.2 R6923.2 U8.AD48
QSFPDD_RX0_N: J7.18 U8.AT54
QSFPDD_RX0_P: J7.17 U8.AR55
QSFPDD_RX1_N: J7.21 U8.J51
QSFPDD_RX1_P: J7.22 U8.K52
QSFPDD_RX2_N: J7.15 U8.AM54
QSFPDD_RX2_P: J7.14 U8.AL55
QSFPDD_RX3_N: J7.24 U8.N51
QSFPDD_RX3_P: J7.25 U8.P52
QSFPDD_RX4_N: J7.56 U8.AD54
QSFPDD_RX4_P: J7.55 U8.AC55
QSFPDD_RX5_N: J7.59 U8.T54
QSFPDD_RX5_P: J7.60 U8.R55
QSFPDD_RX6_N: J7.53 U8.AH54
QSFPDD_RX6_P: J7.52 U8.AG55
QSFPDD_RX7_N: J7.62 U8.Y54
QSFPDD_RX7_P: J7.63 U8.W55
QSFPDD_TX0_N: J7.37 U8.AU51
QSFPDD_TX0_P: J7.36 U8.AV52
QSFPDD_TX1_N: J7.2 U8.T48
QSFPDD_TX1_P: J7.3 U8.R49
QSFPDD_TX2_N: J7.34 U8.AP52
QSFPDD_TX2_P: J7.33 U8.AN51
QSFPDD_TX3_N: J7.5 U8.V52
QSFPDD_TX3_P: J7.6 U8.U51
QSFPDD_TX4_N: J7.75 U8.AE51
QSFPDD_TX4_P: J7.74 U8.AF52
QSFPDD_TX5_N: J7.40 U8.W49
QSFPDD_TX5_P: J7.41 U8.Y48
QSFPDD_TX6_N: J7.72 U8.AK52
QSFPDD_TX6_P: J7.71 U8.AJ51
QSFPDD_TX7_N: J7.43 U8.AB52
QSFPDD_TX7_P: J7.44 U8.AA51
QSFPDD_VCC: C317.1 C318.2 C319.2 C320.2 J7.30 J7.68 L3.2
QSFPDD_VCCR: C313.1 C314.2 C315.2 C316.2 J7.10 J7.48 L2.2
QSFPDD_VCCT: C309.1 C310.2 C311.2 C312.2 J7.29 J7.67 L1.2
R_CIPRI_HIGH_REFCLK_N: C1030.1 R842.1 U23.27
R_CIPRI_HIGH_REFCLK_P: C1029.1 R842.2 U23.26
R_CIPRI_LOW_REFCLK_N: C1028.1 R843.1 U23.30
R_CIPRI_LOW_REFCLK_P: C1027.1 R843.2 U23.29
R_CLK_FPGA_100M_N: R254.2 R6940.1 U23.51
R_CLK_FPGA_100M_P: R253.2 R6940.2 U23.52
R_DDR4_COMP_REFCLK_N: R252.2 R6943.1 U23.63
R_DDR4_COMP_REFCLK_P: R251.2 R6943.2 U23.64
R_DDR4_DIMM1_REFCLK_N: R248.2 R6941.1 U23.57
R_DDR4_DIMM1_REFCLK_P: R247.2 R6941.2 U23.58
R_DDR4_DIMM2_REFCLK_N: R250.2 R6942.1 U23.60
R_DDR4_DIMM2_REFCLK_P: R249.2 R6942.2 U23.61
REFCLK_CXL_CONN_N: R311.1 R758.1 R6920.2 U8.BF48
REFCLK_CXL_CONN_P: R310.1 R757.1 R6920.1 U8.BG49
REFCLK_CXL_EP_N: R313.2 R756.1 R6919.2 U8.BE49
REFCLK_CXL_EP_P: R312.2 R755.1 R6919.1 U8.BC49
REFCLK_CXL_RP_N: J9.B30 R280.1 R754.2
REFCLK_CXL_RP_P: J9.B29 R278.1 R753.2
REFCLK_PCIE_13A_CH2_N: R118.1 R291.1 R6918.2 U8.BU7
REFCLK_PCIE_13A_CH2_P: R117.1 R290.1 R6918.1 U8.BR7
REFCLK_PCIE_13A_CH5_N: R115.2 R289.1 R6917.1 U8.CC7
REFCLK_PCIE_13A_CH5_P: R116.2 R288.1 R6917.2 U8.CD8
REFCLK_PCIE_EP_EDGE_N: J1.A14 R294.2 U26.3
REFCLK_PCIE_EP_EDGE_P: J1.A13 R292.2 U26.2
REFCLK_PCIE_EP_N: R275.1 R297.2 U26.8
REFCLK_PCIE_EP_P: R273.1 R296.2 U26.7
SEL_CXL_REFCLK: R302.2 SW4.2 U27.20
SEL_PCIE_REFCLK: R304.2 SW4.3 U26.20
SHARE_CLK: R537.1 U61.29
SI2204_OUT0N: R275.2 U25.13
SI2204_OUT0P: R273.2 U25.12
SI2204_OUT1N: R277.2 U25.18
SI2204_OUT1P: R276.2 U25.17
SI2204_OUT2N: R280.2 U25.22
SI2204_OUT2P: R278.2 U25.21
SI52204_FS: R284.1 R285.1 U25.11
SI52204_OE0N: R266.1 R267.1 U25.14
SI52204_OE1N: R268.1 R270.1 U25.16
SI52204_OE2N: R269.1 R271.1 U25.23
SI52204_OE3N: R272.1 R274.1 U25.27
SI52204_PWRDNB: R306.2 SW4.4 U25.2
SI52204_SA: R286.1 R287.1 U25.7
SI52204_SSEN: R279.1 R281.1 SW4.1 U25.1
SVID_ENABLE: R370.1 U5.C9
SW0: L5.1 U62.1 U62.2 U62.3 U62.4 U62.5 U62.6 U62.10 U62.11 U62.12 U62.13 U62.14 U62.15 U62.16 U62.42
SW1: L9.1 U66.1 U66.2 U66.3 U66.4 U66.5 U66.6 U66.10 U66.11 U66.12 U66.13 U66.14 U66.15 U66.16 U66.42
SW2: L6.1 U63.1 U63.2 U63.3 U63.4 U63.5 U63.6 U63.10 U63.11 U63.12 U63.13 U63.14 U63.15 U63.16 U63.42
SW3: L7.1 U64.1 U64.2 U64.3 U64.4 U64.5 U64.6 U64.10 U64.11 U64.12 U64.13 U64.14 U64.15 U64.16 U64.42
SW4: L8.1 U65.1 U65.2 U65.3 U65.4 U65.5 U65.6 U65.10 U65.11 U65.12 U65.13 U65.14 U65.15 U65.16 U65.42
TEMP1_THERMN: EU1.9 R340.1 U5.G12
TEMP2_THERMN: EU2.9 R345.1 U5.C15
TOD_MASTER_CLK_125M_N: C388.2 R6910.2 R6935.1 U8.F44
TOD_MASTER_CLK_125M_P: C387.2 R6910.1 R6934.1 U8.G43
TSNS0: C708.1 C722.1 C742.1 C762.1 R548.2 U62.22 U63.22 U64.22 U65.22
TSNS1: C774.1 R549.2 U66.22
U38_VREF2: R380.2 U38.7(VREF2) U38.8
U39_VREF2: R385.2 U39.7(VREF2) U39.8
U93_AGND: C1082.2 C1149.2 C1207.2 C1209.2 C1210.2 C1211.2 C1220.2 C1221.2 Q21.2 Q21.3 Q22.2 Q22.3 R857.2 R858.2 R1008.1 R6799.2 R6835.1 R6836.1 R6846.2 R6848.2 ST20.1 U93.C3 U93.C4 U93.C5 U93.C6 U93.C7 U93.D3 U93.D4 U93.D5 U93.D6 U93.D7 U93.E4(WP)
U93_VDD25: C1207.1 R6791.2 R6794.2 R6797.2 R6798.2 R6845.2 R6847.2 U93.F3
U93_VDD33: C1082.1 D22.1(C) R854.1 R855.1 R856.2 R6833.2 R6834.2 R6844.2 U93.F4
U94_INTVCC: C1204.1 R6838.1 U94.B2 U94.C4 U94.E4
U96_AGND: C1156.2 C1178.2 C1179.2 C1191.2 C1193.2 C1217.2 C1222.2 C1223.2 Q23.2 Q23.3 Q24.2 Q24.3 R6819.1 R6821.2 R6822.2 R6829.1 R6831.1 R6832.1 R6874.2 R6876.2 ST34.1 U96.C3 U96.C4 U96.C5 U96.C6 U96.C7 U96.D3 U96.D4 U96.D5 U96.D6 U96.D7 U96.E4(WP)
U96_VDD25: C1217.1 R6812.2 R6813.2 R6814.2 R6815.2 R6873.2 R6875.2 U96.F3
U96_VDD33: C1156.1 D23.1(C) R6810.2 R6811.1 R6818.1 R6825.1 R6828.2 R6830.2 U96.F4
USB_DISABLEN: R86.2 R88.2 U5.J14 U47.3
USB_MAX_JTAG_SEL: R87.2 R90.1 SW2.1 U5.H15 U6.15
USB_MAX_TCK: U5.H3 U6.2
USB_MAX_TDI: U5.G1 U6.7
USB_MAX_TDO: U5.H1 U6.10
USB_MAX_TMS: U5.H2 U6.5
USB_T_CLK: R454.1 U5.P9
VOUT0_CFG: R552.1 U61.25
VOUT1_CFG: R553.1 U61.26
VSENSE0+: C696.2 R532.1 R533.2 U61.7
VSENSE0-: C696.1 R534.2 R541.2 U61.6
ZL30733_1V8: C376.2 C983.2 C984.2 C985.2 C986.2 FB18.2 FB42.2 R745.2 U81.1 U81.2(VOUT2)
ZL_GPIO3_AC3: R245.1 R261.2 U5.B7 U23.46
ZL_OSC_CLK: R240.2 U23.39
N93250: J4.1 J4.145 R131.2 R132.2
N96922: J4.288 R145.2
N133159: C293.1 R200.1 R202.1
N140679: R222.1 U21.5
N226751: R99.2 SW3.8
N226787: R100.2 SW3.7
N226815: R101.2 SW3.6
N226847: R102.2 SW3.5(B4)
N227760: R103.1 U8.CH48
N465030: R104.2 U8.CE51
N586023: R124.1 U8.CA7
N586027: R124.2 U8.BY8
N586139: R128.1 U8.AM48
N586147: R128.2 U8.AL49
N587132: R125.1 U12.1
N587200: R127.1 U12.4(Y)
N614425: J1.B9 R5.1 R7.1
N615469: J1.B30 R774.2
N615809: C16.2 R13.1
N615921: C17.2 R14.1
N616003: C19.2 R15.1
N616075: C21.2 R16.1
N616149: C22.2 R17.1
N616261: C23.2 R18.1
N616323: C25.2 R19.1
N616411: C27.2 R20.1
N616501: C28.2 R21.1
N616597: C29.2 R22.1
N616647: C30.2 R23.1
N617181: R24.1 R30.2 U2.3
N617185: R25.1 R31.2 U2.2
N617189: R26.1 R29.2 U2.1
N617309: R27.1 R28.2 U2.7(WP)
N631911: C410.1 U25.3 Y1.3
N632203: C412.2 C415.1 C416.1 FB27.2 U25.19 U25.29
N632477: C411.1 U25.4(XOUT) Y1.1
N632667: C989.2 C991.1 C992.1 FB40.2 U25.15 U25.24
N633145: R282.2 U25.10
N633209: R283.2 U25.9
N634717: R307.2 SW4.5(B4)
N634773: R308.2 SW4.6
N634823: R309.2 SW4.7
N744808: R213.1 U20.5
N748119: C303.1 R203.1
N754746: R327.2 U28.6
N754798: R328.2 U28.4
N754986: R332.2 U31.6
N755042: R333.2 U31.4
N756713: D8.C(CATHODE) Q7.3
N756717: D8.A R404.1
N756805: D2.C(CATHODE) Q4.3 R395.2
N756817: D2.A R394.1
N756925: D9.C(CATHODE) Q12.3
N756929: D9.A R405.1
N757065: D10.C(CATHODE) Q13.3
N757069: D10.A R406.1
N757157: D5.A R399.1
N757219: D11.C(CATHODE) Q14.3
N757223: D11.A R407.1
N757357: C482.2 R418.1
N757409: D12.C(CATHODE) Q15.3
N757413: D12.A R411.1
N757643: C483.2 R425.1
N757741: C485.2 R427.1
N757839: C486.2 R428.1
N757891: C484.1 MTH2.1(GND) MTH7.1(GND) R426.2
N760346: C450.2 EU1.3 R338.1
N760350: C450.1 EU1.2 R337.1
N760466: C452.2 EU1.5 R341.1
N760470: C452.1 EU1.4 R339.1
N760588: C453.2 EU1.7 R344.1
N760592: C453.1 EU1.6 R342.1
N760654: EU1.10 R343.2
N899386: R93.1 U7.3
N972002: C457.2 EU2.3 R347.1
N972006: C457.1 EU2.2 R346.1
N972122: C458.2 EU2.5 R349.1
N972126: C458.1 EU2.4 R348.1
N972244: C459.2 EU2.7 R353.1
N972248: C459.1 EU2.6 R351.1
N972310: EU2.10 R352.1
N1009139: J10.4 R450.2
N1009759: R454.2 U49.13
N1028872: R429.1 R435.2 U44.3
N1028876: R430.1 R436.2 U44.2
N1028880: R431.1 R437.2 U44.1
N1029030: R438.1 U44.7(WC_N)
N1063403: R163.2 U15.B9(ZQ)
N1070944: R164.2 U16.B9(ZQ)
N1083557: R165.2 U17.B9(ZQ)
N1083575: R166.2 U18.B9(ZQ)
N1137042: R439.1 R443.2 U46.3
N1137046: R440.1 R444.2 U46.2
N1137050: R441.1 R445.2 U46.1
N1137200: R442.1 U46.7(WC_N)
N1229237: U51.4 U52.3
N1229245: R459.1 U50.21
N1234667: Q16.4 R467.1
N1234809: C609.1 R467.2 U53.1
N1235245: Q17.3 R468.2 U53.5
N1235299: C614.2 R470.2 U53.6(VSS)
N1235337: Q17.1 R469.1
N1235973: R476.1 U54.21
N1428757: C689.2 Q18.4 U60.4
N1428777: R522.1 R524.2 R528.2 U60.3
N1477892: C920.1 R706.1 R708.1 U74.3
N1477908: C925.1 U74.6
N1532849: C651.1 R497.1 R500.1 U56.3
N1532865: C663.1 U56.6
N1534404: C655.1 R498.1 R501.1 U57.3
N1534420: C664.1 U57.6
N1535970: C659.1 R499.1 R502.1 U58.3
N1535986: C665.1 U58.6
N1551329: C928.1 R715.1 R719.1 U75.3
N1551333: C929.1 R716.1 R720.1 U76.3
N1551337: C936.1 U75.6
N1551419: C937.1 U76.6
N1551653: R717.2 U75.7
N1551693: R718.2 U76.7
