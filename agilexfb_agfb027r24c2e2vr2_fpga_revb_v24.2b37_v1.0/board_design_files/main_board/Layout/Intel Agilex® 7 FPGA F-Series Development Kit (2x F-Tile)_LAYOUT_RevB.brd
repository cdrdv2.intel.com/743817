# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM2_DQ26: length 67.9
  L16_SIG6 w0.081: v1(87.49,101.6) 87.15,101.6 87.05,101.5 87.05,101.02 86.14,100.11 86.14,99.79 86.25,99.68 86.25,99.34 86.01,99.1 84.22,99.1 83.75,98.63 83.75,97.62 83.58,97.44 83.04,97.44 82.94,97.34 82.94,97.08 83.04,96.97 83.67,96.97 83.77,96.87 83.77,96.72 83.67,96.61 83.04,96.61 82.94,96.51 82.94,95.94 83.31,95.57 83.31,95.06 83.18,94.92 82.86,94.92 82.72,95.06 82.72,95.52 82.59,95.66 81.82,95.66 81.69,95.79 81.69,95.99 82.52,96.83 82.52,97.15 82.42,97.25 81.84,97.25 81.74,97.36 81.74,97.87 81.84,97.97 83.22,97.97 83.32,98.07 83.32,98.45 83.22,98.55 81.77,98.55 81.22,98.01 81.22,97.75 81.12,97.65 80.17,97.65 80.06,97.54 80.06,97.34 80.17,97.24 81.12,97.24 81.22,97.13 81.22,96.47 81.09,96.33 80.18,96.33 80.04,96.19 80.04,96.01 80.18,95.88 80.38,95.88 80.49,95.77 80.49,95.03 80.59,94.92 80.81,94.92 80.91,95.03 80.91,95.77 81.01,95.88 81.19,95.88 81.32,95.74 81.32,95.34 81.48,95.18 81.88,95.18 81.99,95.08 81.99,94.88 81.88,94.77 81.25,94.77 81.14,94.66 81.14,94.48 81.25,94.38 81.88,94.38 81.99,94.27 81.99,93.5 81.88,93.39 81.17,93.39 81.07,93.5 81.07,93.95 80.96,94.05 80.81,94.05 80.71,93.95 80.71,93.5 80.6,93.39 80.38,93.39 80.28,93.29 80.28,93.07 80.38,92.96 81.93,92.96 82.03,92.86 82.03,92.63 81.93,92.53 80.29,92.53 80.19,92.43 80.19,92.29 80.29,92.18 81.93,92.18 82.03,92.08 82.03,91.9 81.93,91.8 80.2,91.8 80.1,91.7 80.1,91.51 80.2,91.41 81.93,91.41 82.04,91.31 82.04,90.87 82.42,90.49 82.42,90.11 82.56,89.97 83.38,89.97 83.49,89.86 83.49,89.71 83.38,89.61 82.7,89.61 82.59,89.5 82.59,89.35 82.7,89.25 83.38,89.25 83.49,89.14 83.49,88.99 83.38,88.89 82.7,88.89 82.59,88.78 82.59,88.53 82.7,88.43 82.88,88.43 82.99,88.32 82.99,86.35 83.2,86.13 83.2,85.88 82.99,85.67 82.99,85.42 83.2,85.21 83.2,84.96 82.99,84.74 82.99,84.12 84.64,82.47 84.64,77.83 84.89,77.57 85.25,77.57 85.72,77.11 v1(86.63,77.11)
DDR4_DIMM2_DQ27: length 68.1
  L16_SIG6 w0.081: v1(88.34,107.6) 88.09,107.6 87.71,107.22 86.84,107.22 86.5,106.87 82.29,106.87 81.66,106.24 81,106.24 80.89,106.14 80.89,105.67 80.79,105.57 80.64,105.57 80.53,105.67 80.53,106.14 80.43,106.24 80.28,106.24 80.17,106.14 80.17,105.67 80.07,105.57 79.92,105.57 79.81,105.67 79.81,106.14 79.7,106.24 79.56,106.24 79.45,106.14 79.45,105.67 79.34,105.57 79.19,105.57 79.09,105.67 79.09,106.14 78.98,106.24 78.83,106.24 78.73,106.14 78.73,105.67 78.62,105.57 78.47,105.57 78.37,105.67 78.37,106.14 78.26,106.24 78.11,106.24 78.01,106.14 78.01,105.67 77.9,105.57 77.75,105.57 77.65,105.67 77.65,106.14 77.54,106.24 77.26,106.24 77.14,106.12 77.14,105.43 77.35,105.22 78.58,105.22 78.69,105.12 78.69,104.89 78.8,104.78 78.94,104.78 79.05,104.89 79.05,105.12 79.16,105.22 79.31,105.22 79.41,105.12 79.41,104.89 79.52,104.78 79.67,104.78 79.77,104.89 79.77,105.12 79.88,105.22 80.03,105.22 80.13,105.12 80.13,104.89 80.24,104.78 80.39,104.78 80.49,104.89 80.49,105.12 80.6,105.22 81.37,105.22 81.48,105.12 81.48,104.75 81.59,104.65 81.74,104.65 81.84,104.75 81.84,105.12 81.95,105.22 82.14,105.22 82.29,105.07 82.29,104.02 82.91,103.4 86.67,103.4 87.92,102.15 87.92,100.64 87.72,100.44 87.29,100.44 87.09,100.24 87.09,99.84 86.62,99.36 86.62,99.22 86.15,98.75 84.38,98.75 84.14,98.5 84.14,95.47 83.79,95.12 83.79,94.61 83.56,94.38 82.81,94.38 82.51,94.08 82.51,92.29 82.75,92.05 83.75,92.05 83.87,91.93 83.87,91.75 83.77,91.64 82.86,91.64 82.76,91.54 82.76,91.39 82.86,91.28 83.77,91.28 83.87,91.18 83.87,91.03 83.77,90.92 82.86,90.92 82.76,90.81 82.76,90.66 82.86,90.56 83.77,90.56 83.87,90.45 83.87,84.23 85.43,82.68 85.43,77.97 v1(85.83,77.57)
DDR4_DIMM2_DQ28: length 67.1
  L16_SIG6 w0.081: v1(79.84,101.6) 78.77,101.6 78.12,102.25 76.34,102.25 75.37,101.28 75.37,100.92 75.99,100.29 75.99,97.38 75.84,97.23 75.61,97.23 75.46,97.38 75.46,99.15 75.3,99.3 75.07,99.3 74.92,99.15 74.92,97.68 74.76,97.52 74.54,97.52 74.38,97.68 74.38,99.2 74.22,99.35 74,99.35 73.84,99.2 73.84,94.98 74,94.83 74.22,94.83 74.38,94.98 74.38,96.44 74.54,96.6 74.76,96.6 74.92,96.44 74.92,95.28 75.07,95.12 75.3,95.12 75.46,95.28 75.46,96.26 75.61,96.41 75.84,96.41 75.99,96.26 75.99,92.64 75.87,92.51 75.68,92.51 75.56,92.64 75.56,93.36 75.43,93.49 75.25,93.49 75.12,93.36 75.12,92.14 76.62,90.64 76.62,78.91 79.37,76.16 79.61,76.16 80.07,75.7 80.42,75.7 80.88,75.24 81.31,75.24 81.72,74.83 82.02,74.83 82.53,74.32 82.94,74.32 83.37,73.89 83.62,73.89 84.13,73.38 84.46,73.38 84.87,72.98 85.27,72.98 85.71,73.41 86.01,73.41 86.44,72.98 86.88,72.98 87.32,73.42 87.57,73.42 88.04,73.89 88.37,73.89 88.86,74.37 89.16,74.37 89.44,74.65 89.44,77.15 v1(89.02,77.57)
DDR4_DIMM2_DQ29: length 67.4
  L16_SIG6 w0.081: v1(80.69,107.6) 80.19,108.1 74.56,108.1 74.34,107.87 74.34,107.24 74.14,107.05 72.33,107.05 72.21,106.92 72.21,106.71 72.33,106.59 73.58,106.59 73.71,106.46 73.71,106.25 73.58,106.12 71.88,106.12 71.72,105.96 71.72,93.55 75.47,89.81 75.47,79.03 78.54,75.95 78.54,74.96 79.16,74.35 79.69,74.35 80.14,73.89 80.42,73.89 80.88,73.43 81.26,73.43 81.69,73 82.02,73 82.51,72.52 82.81,72.52 83.32,72.01 83.7,72.01 84.11,71.61 84.39,71.61 84.87,71.12 85.22,71.12 85.68,71.58 86.04,71.58 86.49,71.12 86.82,71.12 87.28,71.58 87.61,71.58 88.07,72.04 88.4,72.04 88.91,72.55 89.19,72.55 89.62,72.98 90,72.98 90.46,73.43 90.74,73.43 90.99,73.69 90.99,76.83 90.71,77.11 v1(89.82,77.11)
DDR4_DIMM2_DQ30: length 64.1
  L16_SIG6 w0.081: v1(89.02,75.73) 88.65,75.36 88.65,75.06 88.37,74.78 88.07,74.78 87.69,74.4 87.31,74.4 86.8,73.89 86.49,73.89 86.04,74.35 85.63,74.35 85.17,73.89 84.89,73.89 84.44,74.35 84,74.35 83.52,74.83 83.29,74.83 82.84,75.29 82.46,75.29 82.02,75.72 81.64,75.72 81.2,76.16 80.91,76.16 80.46,76.62 80.06,76.62 79.56,77.11 79.01,77.11 77.16,78.96 77.16,90.91 77.58,91.32 77.58,92.48 76.85,93.21 76.85,94.61 76.55,94.91 76.55,98.75 76.85,99.05 76.85,100.69 77.32,101.17 81.76,101.17 81.98,101.39 81.98,101.94 81.39,102.53 79.75,102.53 79.21,103.06 74.78,103.06 74.56,103.28 74.56,103.52 74.75,103.71 79.84,103.71 80.55,103.01 81.79,103.01 82.59,102.21 85.19,102.21 v1(85.79,101.6)
DDR4_DIMM2_DQ31: length 64
  L16_SIG6 w0.081: v1(86.64,107.6) 86.27,107.23 82.95,107.23 82.81,107.37 82.81,107.82 82.47,108.16 81.45,108.16 81.11,107.82 81.11,107.26 80.85,107 75.9,107 72.67,103.77 72.67,93.72 76.03,90.36 76.03,79.02 78.98,76.08 78.98,75.4 79.1,75.27 79.63,75.27 80.09,74.81 80.45,74.81 80.88,74.37 81.19,74.37 81.64,73.92 82.05,73.92 82.53,73.43 82.79,73.43 83.27,72.95 83.65,72.95 84.11,72.49 84.41,72.49 84.84,72.06 85.22,72.06 85.68,72.52 86.04,72.52 86.49,72.06 86.82,72.06 87.36,72.6 87.64,72.6 88.02,72.98 88.42,72.98 88.87,73.42 89.25,73.42 89.72,73.89 89.97,73.89 90.23,74.15 90.23,75.78 v1(89.82,76.19)
DDR4_DIMM2_DQ32: length 93.7
  L03_SIG1 w0.081: v4(136.79,101.6) 136.08,100.89 133.96,100.89 133.62,101.23 132.96,101.23 132.84,101.12 132.84,100.85 132.73,100.74 132.57,100.74 132.46,100.85 132.46,101.12 132.34,101.23 132.18,101.23 132.07,101.12 132.07,100.85 131.96,100.74 131.8,100.74 131.69,100.85 131.69,101.12 131.57,101.23 130.95,101.23 129.11,99.39 128.18,99.39 127.87,99.07 127.87,97.82 127.57,97.52 125.37,97.52 124.8,96.94 123.16,96.94 123.04,96.83 123.04,96.67 123.16,96.56 123.92,96.56 124.04,96.45 124.04,96.29 123.92,96.17 122.98,96.17 122.56,96.59 122.26,96.59 121.16,95.48 120.32,95.48 119.44,94.6 116.77,94.6 116.51,94.86 114.31,94.86 113.98,95.19 112.28,95.19 112.2,95.11 112.2,94.89 112.28,94.81 113.31,94.81 113.4,94.73 113.4,94.5 113.31,94.42 111.81,94.42 111.72,94.5 111.72,95.11 111.64,95.19 109.27,95.19 109.19,95.11 109.19,94.89 109.27,94.81 110.78,94.81 110.86,94.73 110.86,94.5 110.78,94.42 107.14,94.42 107.06,94.5 107.06,94.73 107.14,94.81 108.2,94.81 108.28,94.89 108.28,95.11 108.2,95.19 106.72,95.19 106.64,95.11 106.64,94.5 106.56,94.42 104.37,94.42 103.46,93.52 101.85,93.52 101.23,93.26 100.57,92.6 89.53,88.92 88.13,87.52 87.96,87.52 87.82,87.65 87.82,87.79 88.51,88.48 88.51,88.66 88.36,88.81 88.18,88.81 87.63,88.26 87.29,88.26 86.55,87.52 86.55,87.36 86.94,86.97 86.94,86.81 86.82,86.69 86.66,86.69 86.27,87.08 86.11,87.08 86,86.97 86,86.81 86.21,86.6 86.21,86.44 86.1,86.32 85.94,86.32 85.73,86.54 85.57,86.54 85.06,86.03 84.35,86.03 80.65,82.33 80.65,81.54 80.4,81.28 80.18,81.28 79.85,80.96 79.85,79.56 80.01,79.39 80.44,79.39 80.89,78.95 81.16,78.95 81.67,78.44 82.05,78.44 82.43,78.06 82.9,78.06 83.04,77.98 83.18,77.73 83.34,77.64 83.61,77.64 84.14,77.11 v4(85.04,77.11)
DDR4_DIMM2_DQ33: length 96.5
  L03_SIG1 w0.081: v4(137.64,107.6) 137.22,107.17 133.19,107.17 132.93,107.44 132.21,107.44 131.89,107.12 117.71,107.12 115.59,104.99 99.46,104.99 97.56,103.09 95.88,103.09 93.34,100.55 92.9,100.55 91.62,99.27 91.62,97.01 90.58,95.96 88.5,95.96 87.01,97.45 85.85,97.45 82.63,94.24 82.63,92.99 75.42,85.78 75.42,77.4 78.57,74.24 79.56,74.24 79.73,74.31 80.06,74.64 80.19,74.69 80.34,74.69 80.44,74.65 80.77,74.32 80.96,74.24 81.32,74.24 81.75,73.82 82.56,73.48 82.81,73.48 83.19,73.87 83.57,73.87 84.08,74.37 84.46,74.37 84.64,74.55 84.64,75.45 85.04,75.84 v4(85.04,76.19)
DDR4_DIMM2_DQ34: length 93.7
  L03_SIG1 w0.081: v4(142.74,101.6) 142.74,102.15 143.09,102.49 144.03,102.49 144.85,103.32 144.85,103.46 144.73,103.58 144.55,103.58 143.87,102.9 143.69,102.9 143.56,103.03 143.56,103.21 144.72,104.37 144.72,105.67 145.13,106.08 145.13,107.03 145.02,107.14 144.56,107.14 144.35,106.93 144.35,106.35 144,106 144,104.46 142.91,103.37 142.91,102.96 142.33,102.39 142.33,101.52 142.05,101.23 141.7,101.23 140.64,100.17 140.64,99.9 140.4,99.66 140.28,99.61 138.34,99.61 138.11,99.84 138.11,100.04 137.85,100.3 137.46,100.46 133.2,100.46 133.1,100.36 131.4,100.36 131.3,100.46 130.74,100.46 130.33,100.05 130.33,99.82 129.09,98.58 129.09,98.15 128,97.06 125.66,97.06 125.14,96.53 124.8,96.53 123.8,95.53 122.05,95.53 121.65,95.13 120.48,95.13 119.56,94.21 116.3,94.21 116.02,94.49 114.46,94.49 114.13,94.15 113.71,94.15 113.06,93.51 104.3,93.51 103.6,92.81 89.69,88.59 88.34,87.24 88.34,87.01 87.76,86.43 84.43,85.42 81.47,82.46 81.47,81.08 81.2,80.81 80.9,80.81 80.55,80.46 80.55,80.13 80.85,79.83 81.3,79.83 81.67,79.45 82.05,79.45 82.56,78.95 82.81,78.95 83.32,78.44 83.7,78.44 84.24,77.9 v4(84.24,77.57)
DDR4_DIMM2_DQ35: length 96.9
  L03_SIG1 w0.081: v4(84.24,75.73) 84.24,75.42 83.64,74.83 83.26,74.83 82.81,74.37 82.43,74.37 82.05,74.75 81.51,74.75 81.2,74.45 80.97,74.45 80.86,74.5 80.44,74.91 80.16,74.91 79.98,74.84 79.66,74.52 79.52,74.46 79.3,74.46 79.06,74.7 78.6,74.7 76.43,76.86 76.02,77.85 76.02,84.92 86,94.89 87.24,95.41 90.79,95.41 92.26,96.88 92.82,98.22 93.66,99.07 94.09,99.24 94.73,99.89 94.73,100.11 94.98,100.35 95.47,100.55 96.37,100.55 98.65,101.14 100.73,103.22 101.21,103.22 103.44,104.15 115.51,104.15 117.99,106.63 119.9,106.63 121.35,106.04 130.49,106.04 132,106.66 132.36,107.02 132.8,107.02 132.99,106.83 137.55,106.83 138.12,107.4 138.12,108.02 138.86,108.76 140.32,108.76 141.11,107.98 142.91,107.98 143.29,107.6 v4(143.59,107.6)
DDR4_DIMM2_DQ36: length 91.9
  L03_SIG1 w0.081: v4(135.09,101.6) 134.41,102.28 134.08,102.28 133.95,102.42 130.97,102.42 130.58,102.03 129.77,102.03 128.16,100.42 127.33,100.42 125.31,98.41 121.11,98.41 120.94,98.23 120.94,97.46 120.81,97.34 120.6,97.34 120.47,97.46 120.47,98.41 119.76,99.12 117.68,99.12 117.4,98.84 117.4,96.17 117.32,96.09 117,96.09 116.91,96.17 116.91,98.05 116.83,98.13 116.53,98.13 116.45,98.05 116.45,96.57 116.37,96.48 116.07,96.48 115.99,96.57 115.99,97.61 115.91,97.69 115.61,97.69 115.53,97.61 115.53,96.57 115.45,96.48 115.15,96.48 115.06,96.57 115.06,97.56 114.98,97.65 114.68,97.65 114.6,97.56 114.6,96.57 114.52,96.48 105.23,96.48 104.11,95.36 101.95,95.36 101.26,94.67 98.9,94.67 98.8,94.57 98.8,94.33 98.89,94.24 99.75,94.24 99.84,94.15 99.84,93.86 99.75,93.78 98.96,93.78 98.73,93.54 97.04,93.54 96.41,92.92 94.56,92.92 93.91,92.27 93.04,92.27 91.98,91.2 87.75,89.81 87.65,89.86 87.55,90.15 87.6,90.25 89.85,90.99 89.9,91.09 89.81,91.38 89.71,91.43 87.42,90.68 84.6,87.86 84.6,87.34 83.24,85.98 82.29,85.98 78.69,82.38 78.69,78.49 79.15,78.04 79.63,78.04 80.1,77.57 v4(81.05,77.57)
DDR4_DIMM2_DQ37: length 92.5
  L03_SIG1 w0.081: v4(135.94,107.6) 138.56,109.2 140.43,109.2 143.75,108.05 143.93,107.87 144.01,107.68 144.01,107.33 142.83,105.1 141.41,101.42 141.03,101.03 139.75,100.5 138.4,100.5 137.91,100.71 137.17,101.45 137.17,101.75 136.9,102.02 135.7,102.02 135.53,101.84 135.53,101.43 135.4,101.3 135.27,101.22 134.1,101.22 133.87,101.45 133.87,101.75 133.64,101.98 131.01,101.98 129.51,100.49 128.79,100.49 126.84,98.54 126.74,98.47 124.94,97.72 122.68,97.27 121.74,96.88 120.24,95.88 119.65,95.29 119.13,95.07 118.72,95.07 117.5,95.28 116.67,95.57 115.02,95.85 112.43,95.85 109.39,95.55 106.49,95.55 105.42,95.3 103.71,94.48 102.81,94.48 101.87,94.36 101.71,94.3 100.39,93.55 99.98,93.43 98.7,92.65 88.65,89.4 87.89,89.09 85.87,87.74 84.15,86.33 83.41,85.59 83.19,85.5 79.08,81.38 79.08,79.25 79.44,78.88 80.42,78.48 80.7,78.2 81.24,77.97 81.67,77.55 v4(81.85,77.11)
DDR4_DIMM2_DQ38: length 89.8
  L03_SIG1 w0.081: v4(79.46,77.57) 79.11,77.57 78.34,78.34 78.34,82.55 82.11,86.32 82.33,86.32 83.27,87.27 83.68,87.27 83.96,87.55 83.96,87.94 87.91,91.88 91.85,91.88 92.99,93.02 93.83,93.02 94.36,93.55 95.72,93.55 97.78,95.62 98.11,95.62 98.25,95.48 98.25,95.3 98.39,95.16 98.59,95.16 98.74,95.3 98.74,95.48 98.88,95.62 101.44,95.62 101.81,95.99 102.92,95.99 103.77,96.83 111.04,96.83 111.31,97.11 111.31,97.82 111.43,97.94 111.75,97.94 111.83,97.86 111.83,96.94 111.91,96.86 112.21,96.86 112.29,96.94 112.29,97.88 112.38,97.96 112.68,97.96 112.76,97.88 112.76,96.97 112.84,96.89 113.14,96.89 113.22,96.97 113.22,97.86 113.3,97.94 113.6,97.94 113.68,97.86 113.68,96.98 113.76,96.89 114.06,96.89 114.14,96.98 114.14,97.95 114.22,98.03 115.76,98.03 117.27,99.54 119.98,99.54 120.55,98.97 120.92,98.97 121.3,99.34 121.68,99.34 122.08,98.94 123.37,98.94 123.76,99.33 124.32,99.33 124.65,99 125.38,99 126.14,99.75 126.14,101.6 126.22,101.69 126.43,101.69 126.52,101.6 126.52,100.61 126.61,100.52 126.84,100.52 126.93,100.61 126.93,101.66 127.34,102.08 129.27,102.08 130.52,103.33 133.26,103.33 133.48,103.1 134.7,103.1 134.91,102.89 136.51,102.89 137.65,101.76 137.65,101.44 138.1,100.99 138.4,100.87 139.7,100.87 140.74,101.29 v4(141.04,101.6)
DDR4_DIMM2_DQ39: length 89.8
  L03_SIG1 w0.081: v4(141.89,107.6) 141.89,105.44 141.56,105.11 140.27,105.11 139.76,104.6 139.76,101.48 139.5,101.22 138.42,101.22 138.29,101.28 138.11,101.46 138.11,102.54 137.75,102.9 137.28,102.9 136.74,103.44 133.85,103.44 133.63,103.66 129.81,103.66 129.42,103.27 126.11,103.27 125.22,102.38 125.22,100.59 124.71,100.07 123.94,100.07 123.33,99.46 122.24,99.46 121.94,99.75 121.13,99.75 120.87,99.5 120.56,99.5 120.16,99.89 116.66,99.89 115.99,99.23 114.73,99.23 113.92,98.42 111.07,98.42 110,97.35 103.32,97.35 102.53,96.56 99.42,96.56 99.28,96.42 99.28,96.28 99.14,96.14 98.93,96.14 98.79,96.28 98.79,96.42 98.65,96.56 98.09,96.56 97.03,95.5 95.91,95.5 94.39,93.98 94.15,93.98 93.64,93.46 92.69,93.46 91.58,92.35 87.76,92.35 83.77,88.36 83.43,88.36 82.32,87.25 81.86,87.25 77.93,83.32 77.93,78.22 79.05,77.11 v4(80.26,77.11)
DDR4_DIMM2_DQ40: length 102
  L05_SIG2 w0.081: v1(83.44,78.03) 84.43,78.03 84.89,78.49 85.21,78.49 85.46,78.73 85.46,82.42 86.96,83.92 86.96,88.02 88.77,89.84 88.77,90.93 88.92,91.07 89.18,91.07 89.32,91.21 89.32,91.41 89.18,91.56 88.92,91.56 88.77,91.7 88.77,91.9 88.92,92.04 89.18,92.04 89.32,92.19 89.32,92.39 89.18,92.53 88.92,92.53 88.77,92.67 88.77,92.88 88.92,93.02 89.18,93.02 89.32,93.16 89.32,93.36 89.18,93.51 88.92,93.51 88.77,93.65 88.77,94.5 93.45,99.18 94.35,99.18 94.74,99.56 94.74,100.27 95.06,100.59 95.32,100.59 95.74,101.01 96.09,101.01 96.43,101.35 96.43,101.94 96.81,102.32 97.73,102.32 99.01,103.6 100.17,103.6 100.69,104.12 102.87,104.12 103.2,104.44 105,104.44 105.14,104.58 105.14,104.82 105.29,104.97 105.49,104.97 105.63,104.82 105.63,104.58 105.77,104.44 105.98,104.44 106.12,104.58 106.12,104.82 106.26,104.97 106.46,104.97 106.61,104.82 106.61,104.58 106.75,104.44 107.52,104.44 107.66,104.58 107.66,104.87 107.81,105.02 108.01,105.02 108.15,104.87 108.15,104.58 108.29,104.44 108.49,104.44 108.64,104.58 108.64,104.87 108.78,105.02 108.98,105.02 109.13,104.87 109.13,104.58 109.27,104.44 110.34,104.44 110.49,104.58 110.49,104.92 110.63,105.06 110.83,105.06 110.98,104.92 110.98,104.58 111.12,104.44 111.32,104.44 111.46,104.58 111.46,104.92 111.61,105.06 111.81,105.06 111.95,104.92 111.95,104.58 112.09,104.44 112.3,104.44 112.44,104.58 112.44,104.92 112.58,105.06 112.78,105.06 112.93,104.92 112.93,104.58 113.07,104.44 116.38,104.44 118.05,102.77 119.73,102.77 120.72,103.76 121.78,103.76 122.13,104.11 131.25,104.11 131.36,104.01 131.36,103.73 131.46,103.62 131.61,103.62 131.72,103.73 131.72,104.01 131.82,104.11 131.97,104.11 132.08,104.01 132.08,103.73 132.18,103.62 132.33,103.62 132.44,103.73 132.44,104.01 132.54,104.11 132.69,104.11 132.8,104.01 132.8,103.73 132.91,103.62 133.05,103.62 133.16,103.73 133.16,104.01 133.27,104.11 133.75,104.11 133.92,103.94 136.15,103.94 136.26,103.83 136.26,103.68 136.15,103.58 134.93,103.58 134.83,103.47 134.83,103.32 134.93,103.22 137.91,103.22 138.02,103.32 138.02,103.47 137.91,103.58 136.8,103.58 136.69,103.68 136.69,103.83 136.8,103.94 138.4,103.94 139.48,102.86 142.17,102.86 142.29,102.74 142.29,102.52 142.4,102.4 142.57,102.4 142.69,102.52 142.69,102.74 142.81,102.86 142.98,102.86 143.1,102.74 143.1,102.52 143.22,102.4 143.39,102.4 143.5,102.52 143.5,102.74 143.62,102.86 143.78,102.86 144.63,102.01 145.74,102.01 v1(146.14,101.6)
DDR4_DIMM2_DQ41: length 100.5
  L05_SIG2 w0.081: v1(146.99,107.6) 147.42,108.03 149.78,108.03 150,107.8 150,107.34 150.5,105.31 150.5,103.98 149.78,103.25 148.61,103.25 146.69,105.17 140.77,105.17 140.1,105.84 135.47,105.84 134.82,106.49 133.68,106.49 133.3,106.11 132.02,106.11 131.08,107.05 130.78,107.05 129.8,108.03 120.38,108.03 120.26,108.16 115.89,108.16 115.72,107.99 104.58,107.99 103.65,107.06 101.55,107.06 100.87,106.39 98.15,106.39 97.48,105.72 96.38,105.72 93.35,102.69 91.37,102.69 90.49,101.81 90.49,101.15 90.19,100.85 89.18,100.85 88.78,100.45 88.78,99.67 88.15,99.03 88.15,98.83 88.41,98.57 88.41,98.37 88.26,98.23 88.06,98.23 87.7,98.59 87.5,98.59 87.36,98.44 87.36,98.24 87.72,97.88 87.72,97.68 86.96,96.92 86.96,96.62 85.89,95.55 85.89,94.72 85.25,94.07 85.25,93.51 84.13,92.39 84.13,84.21 82.25,82.33 82.25,79.81 v1(82.65,79.41)
DDR4_DIMM2_DQ42: length 101.9
  L05_SIG2 w0.081: v1(82.65,78.49) 83.56,78.49 83.96,78.89 84.29,78.89 84.65,79.25 84.65,82.3 86.57,84.22 86.57,84.54 86.43,84.68 86.21,84.68 86.07,84.82 86.07,85.02 86.21,85.17 86.43,85.17 86.57,85.31 86.57,85.51 86.43,85.65 86.15,85.65 86.01,85.8 86.01,86 86.15,86.14 86.43,86.14 86.57,86.29 86.57,88.21 87.59,89.23 87.59,91.09 87.71,91.2 87.88,91.2 88,91.09 88,89.99 88.12,89.87 88.29,89.87 88.4,89.99 88.4,92.87 88.29,92.99 88.12,92.99 88,92.87 88,91.72 87.88,91.6 87.71,91.6 87.59,91.72 87.59,93.43 87.92,93.76 87.92,94.26 89.83,96.16 89.83,97.21 90.27,97.66 90.48,97.66 90.59,97.54 90.8,97.54 90.94,97.68 90.94,97.88 90.82,98 90.82,98.2 91.07,98.45 92.19,98.45 93.02,99.28 93.02,100.09 93.42,100.49 94.19,100.49 94.87,101.17 95.41,101.17 95.58,101.34 95.58,101.8 96.46,102.68 97.61,102.68 98.88,103.95 99.96,103.95 100.47,104.46 102.71,104.46 103.03,104.78 103.9,104.78 104.2,105.07 104.69,105.07 105.02,105.4 106.53,105.4 106.86,105.07 107.2,105.07 107.58,105.45 109.09,105.45 109.48,105.07 109.88,105.07 110.22,105.41 113.11,105.41 113.42,105.1 116.36,105.1 117.9,106.64 119.44,106.64 120.43,105.65 120.43,105.03 121.16,104.29 121.81,104.29 121.97,104.45 133.9,104.45 134.07,104.28 138.7,104.28 139.79,103.19 143.96,103.19 144.79,102.36 146.05,102.36 146.73,101.67 147.12,101.67 147.66,101.12 149.77,101.12 150.02,100.87 150.72,100.87 151.44,101.6 v1(152.09,101.6)
DDR4_DIMM2_DQ43: length 100.5
  L05_SIG2 w0.081: v1(83.44,79.87) 83.04,80.27 83.04,82.44 84.64,84.04 84.64,92.14 86.39,93.88 86.39,94.33 86.25,94.47 86.25,95.16 87.63,96.55 87.63,96.95 90.45,99.77 90.45,100.07 92.55,102.17 93.48,102.17 96.46,105.15 99.24,105.15 100.01,105.91 101.27,105.91 101.46,106.1 103.27,106.1 104.23,107.06 114.18,107.06 114.34,106.9 116.13,106.9 117.01,107.77 119.87,107.77 120.62,107.02 130.2,107.02 131.15,106.08 131.43,106.08 131.75,105.76 133.55,105.76 133.93,106.14 134.61,106.14 135.25,105.49 139.61,105.49 140.75,104.36 144.76,104.36 145,104.11 147.26,104.11 148.83,102.54 149.39,102.54 149.95,101.98 149.95,101.43 150.17,101.21 150.56,101.21 150.82,101.47 150.82,102.83 151.77,103.78 151.77,105.94 151.91,106.08 152.23,106.08 152.37,105.94 152.37,105.01 152.52,104.87 152.8,104.87 152.94,105.01 v1(152.94,107.6)
DDR4_DIMM2_DQ44: length 98.3
  L05_SIG2 w0.081: v1(144.44,101.6) 144,102.04 138.6,102.04 137.81,102.82 134.71,102.82 134.08,103.46 133.81,103.46 133.61,103.25 133.61,103.1 133.37,102.87 133.14,102.87 132.76,103.24 130.87,103.24 130.75,103.36 130.75,103.6 130.63,103.72 130.46,103.72 130.35,103.6 130.35,102.88 130.23,102.76 130.06,102.76 129.94,102.88 129.94,103.6 129.82,103.72 129.65,103.72 129.53,103.6 129.53,103.36 129.41,103.24 128.84,103.24 128.72,103.12 128.72,102.73 128.6,102.61 128.43,102.61 128.31,102.73 128.31,103.65 128.19,103.77 128.02,103.77 127.91,103.65 127.91,102.74 127.79,102.62 127.62,102.62 127.5,102.74 127.5,103.65 127.38,103.77 127.21,103.77 127.09,103.65 127.09,103.36 126.97,103.24 126.21,103.24 126.09,103.12 126.09,102.71 125.98,102.59 125.81,102.59 125.69,102.71 125.69,103.6 125.57,103.72 125.4,103.72 125.28,103.6 125.28,103.36 125.16,103.24 124.55,103.24 124.43,103.12 124.43,102.67 124.31,102.55 124.14,102.55 124.02,102.67 124.02,103.62 123.9,103.74 123.73,103.74 123.61,103.62 123.61,102.67 123.5,102.55 123.33,102.55 123.21,102.67 123.21,103.57 123.09,103.69 122.92,103.69 122.8,103.57 122.8,103.36 122.68,103.24 120.77,103.24 119.87,102.35 117.84,102.35 116.09,104.09 103.34,104.09 102.99,103.74 101.8,103.74 101.25,103.19 99.11,103.19 97.9,101.98 97.52,101.98 97.3,101.76 97.3,101.46 96.33,100.49 95.8,100.49 95.59,100.28 95.59,99.22 94.87,98.49 93.35,98.49 89.65,94.8 89.65,89.83 87.86,88.04 87.86,86.45 87.59,86.18 87.59,83.76 86.24,82.41 86.24,78.21 86.02,78 85.67,78 85.23,77.56 81.13,77.56 80.66,78.03 v1(80.26,78.03)
DDR4_DIMM2_DQ45: length 98.2
  L05_SIG2 w0.081: v1(145.29,107.6) 144.46,108.44 138.38,108.44 137.29,109.52 132.31,109.52 131.93,109.9 101.9,109.9 101.4,109.4 99,109.4 98.08,108.47 96.06,108.47 94.5,106.91 92.8,106.91 92.46,106.57 90.95,106.57 90.62,106.91 89.34,106.91 88.61,106.18 88.61,104.83 87.39,103.61 85.69,103.61 84.52,102.44 84.52,101.5 83.72,100.7 83.72,100.53 83.58,100.39 83.38,100.39 83.23,100.53 83.23,100.97 83.09,101.12 82.92,101.12 82.78,100.97 82.78,99.37 82.92,99.22 83.58,99.22 83.72,99.08 83.72,97.2 83.58,97.06 83.38,97.06 83.23,97.2 83.23,98.54 83.09,98.68 82.89,98.68 82.74,98.54 82.74,97.06 81.92,96.24 81.92,93.23 81.3,92.61 81.3,85.98 80.38,85.06 80.38,83.16 79.84,82.62 79.84,78.87 v1(79.46,78.49)
DDR4_DIMM2_DQ46: length 99
  L05_SIG2 w0.081: v1(150.39,101.6) 150.39,102.79 150.86,103.91 150.86,107.67 150.12,108.41 147.18,108.41 146.6,107.83 146.6,107.47 146.28,107.16 139.4,107.16 138.8,107.41 138.4,107.8 137.84,108.03 133.27,108.03 131.75,109.55 102.12,109.55 101.43,108.87 99.1,108.87 98.33,108.09 97.61,108.09 97.31,107.79 97.31,107.5 96.85,107.04 96.04,107.04 93.62,105.13 90.15,104.28 86.67,102.84 86.19,102.36 86.19,101.34 85.82,100.97 83.19,94.61 82.84,94.26 81.69,88.02 81.69,85.88 80.65,82.42 80.65,80.26 v1(80.26,79.87)
DDR4_DIMM2_DQ47: length 98.5
  L05_SIG2 w0.081: v1(79.46,79.41) 79.08,79.79 79.08,82.72 79.79,83.42 79.79,85.12 80.9,86.23 80.9,92.94 81.13,93.18 81.13,94.36 81.4,94.62 81.4,97.04 82.01,97.65 82.01,101.76 82.46,102.21 83.31,102.21 86.04,104.94 87.11,104.94 87.98,105.81 87.98,106.49 88.78,107.29 88.78,107.87 89.31,108.39 93.25,108.39 93.73,108.86 97.91,108.86 98.9,109.85 101.33,109.85 101.73,110.24 138.38,110.24 139,109.63 144.89,109.63 145.6,108.92 150.27,108.92 151.24,107.94 v1(151.24,107.6)
DDR4_DIMM2_DQ48: length 99.5
  L05_SIG2 w0.081: v1(155.49,101.6) 154.93,101.04 154.25,101.04 153.56,100.35 152.64,100.35 152.51,100.22 152.51,99.73 152.16,99.38 151.71,99.38 151.42,99.09 146.83,99.09 146.62,99.3 146.62,99.68 146.44,99.86 145.87,99.86 145.76,99.74 145.76,99.55 145.62,99.41 143.44,99.41 143.27,99.59 135.74,99.59 135.51,99.82 135.51,100.18 135.3,100.38 132.84,100.38 132.76,100.46 132.76,100.79 132.68,100.87 132.45,100.87 132.37,100.79 132.37,100.43 132.29,100.35 132.07,100.35 131.99,100.43 131.99,100.79 131.91,100.87 131.68,100.87 131.6,100.79 131.6,100.43 131.52,100.35 130.79,100.35 130.71,100.43 130.71,100.79 130.63,100.88 130.4,100.88 130.32,100.79 130.32,100.43 130.24,100.35 130.02,100.35 129.94,100.43 129.94,100.79 129.86,100.88 129.63,100.88 129.55,100.79 129.55,100.43 129.47,100.35 128.4,100.35 128.32,100.43 128.32,100.74 128.24,100.82 128.02,100.82 127.93,100.74 127.93,100.43 127.85,100.35 126.69,100.35 126.61,100.43 126.61,100.79 126.53,100.87 126.31,100.87 126.23,100.79 126.23,100.43 126.14,100.35 125.01,100.35 124.93,100.43 124.93,100.77 124.85,100.85 124.63,100.85 124.54,100.77 124.54,100.43 124.46,100.35 119.45,100.35 116.16,101.01 115.77,101.17 114.32,101.17 113.16,102.33 112.04,102.33 111.48,101.77 111.12,101.77 110.8,102.1 109.5,102.1 109.02,101.62 108.54,101.62 108.17,101.99 106.73,101.99 106.54,101.8 105.83,101.8 105.64,101.99 104.28,101.99 103.97,101.69 103.36,101.69 103.05,101.99 102.62,101.99 102.39,101.76 102.39,101.2 102.2,101.01 101.44,101.01 100.64,100.22 100.05,100.22 99.87,100.4 99.22,100.4 98.98,100.16 98.98,99.8 98.65,99.47 97.79,99.12 97.24,98.57 96.99,98.57 95.17,96.76 94.78,96.76 93.48,95.45 92.68,95.45 92.21,94.98 92.21,94.16 91.7,93.65 91.24,92.55 91.24,86.64 89.83,83.22 89.42,82.81 89.42,75.09 89.73,74.77 90.03,74.77 90.26,74.54 90.26,74.24 v1(90.61,73.89)
DDR4_DIMM2_DQ49: length 97.4
  L05_SIG2 w0.081: v1(90.61,74.81) 90.21,75.21 90.21,83.04 91.6,86.4 91.6,92.4 92.64,93.44 93.52,93.44 93.7,93.62 93.84,93.96 93.84,94.15 93.5,94.49 93.5,95 94.8,96.29 95.19,96.29 96.3,97.4 97.08,97.4 97.27,97.59 97.45,98.03 97.45,98.22 97.98,98.76 98.79,99.09 99.2,99.51 99.84,99.51 100.13,99.79 101.11,99.79 101.79,100.47 103,100.47 103.24,100.71 103.24,101.03 103.52,101.31 104.05,101.31 104.14,101.22 113.19,101.22 113.63,100.78 115.76,100.78 116.26,100.58 119.62,99.91 120.16,99.91 120.47,99.6 120.9,99.6 121.07,99.76 121.85,99.76 122.05,99.56 123.39,99.56 123.58,99.75 124.82,99.75 124.99,99.58 126.06,99.58 126.27,99.78 127,99.78 127.19,99.59 127.71,99.59 127.91,99.78 128.74,99.78 128.94,99.59 129.42,99.59 129.6,99.77 130.29,99.77 130.47,99.59 131.88,99.59 132.16,99.87 132.93,99.87 133.23,99.57 135.26,99.57 135.64,99.2 143.07,99.2 143.55,98.71 151.56,98.71 152.16,98.83 152.41,98.93 153,99.53 153.95,99.53 154.24,99.82 154.24,100.14 154.46,100.37 154.87,100.37 155.81,101.3 155.93,101.6 155.93,105.72 156.47,106.26 156.47,106.47 155.93,107.01 155.93,107.19 v1(156.34,107.6)
DDR4_DIMM2_DQ50: length 99.8
  L05_SIG2 w0.081: v1(91.41,73.43) 91.62,73.64 91.62,73.89 92.08,74.35 92.44,74.35 92.69,74.6 92.91,74.72 93.13,74.72 93.38,74.97 93.38,81.45 93.51,81.58 93.51,81.86 93.42,81.95 93.42,82.87 94.14,83.59 94.14,85.6 95.14,86.6 95.23,86.83 95.23,88.14 94.93,88.45 94.93,91.34 97.14,93.55 97.88,93.55 98.13,93.8 98.13,94.36 100.38,96.61 100.92,96.83 102.76,96.83 103.37,97.44 104.63,97.44 104.98,97.79 106.26,97.79 106.96,97.5 107.24,97.5 107.5,97.77 108.86,97.77 109.52,97.5 111.17,97.5 111.81,97.24 114.34,96.73 116.12,95.99 117.78,94.34 119.75,94.34 121.69,96.28 122.15,96.46 123.45,96.46 123.86,96.88 133.53,96.88 134.15,96.25 155.83,96.25 157.77,98.2 159,98.2 160.17,99.37 160.17,101.11 160.3,101.23 160.46,101.23 160.59,101.11 160.59,98.88 160.71,98.76 160.84,98.76 160.97,98.88 160.97,101.12 v1(161.44,101.6)
DDR4_DIMM2_DQ51: length 97.6
  L05_SIG2 w0.081: v1(162.29,107.6) 161.96,107.83 161.59,107.98 161.43,108.01 157.97,108.01 157.79,107.93 157.71,107.86 157.62,107.63 157.62,107.05 157.41,105.25 156.94,103.21 156.76,101.64 156.76,101.4 156.14,100.46 155.86,99.78 155.62,99.55 154.84,99.39 153.66,99.04 152.44,98.53 151.62,98.37 142.23,98.37 135.68,98.8 134.06,99.17 133.38,99.17 132.66,99.32 132.38,99.32 132.21,99.25 130.33,99.25 130.26,99.32 129.62,99.32 129.56,99.25 128.69,99.25 128.61,99.33 128.05,99.33 127.96,99.25 127.06,99.25 126.99,99.32 126.27,99.32 126.2,99.24 124.85,99.24 124.78,99.32 123.62,99.32 123.53,99.23 121.91,99.23 121.82,99.32 121.1,99.32 121.04,99.26 120.4,99.26 120.1,99.38 115.8,100.29 114.98,100.38 103.62,100.38 103.42,100.29 103.29,100.17 103.13,99.76 103.02,99.65 102.82,99.57 102.54,99.57 101.97,99.46 101.07,99.19 100.02,98.75 98.5,98.52 98.16,98.38 97.91,98.14 97.63,97.46 97.26,97.08 96.15,96.34 95.09,95.29 94.85,94.93 94.43,93.91 93.92,93.15 93.33,92.42 93.02,91.97 92.87,91.59 92.15,88 92.06,87.02 91.63,84.56 91.25,83.19 91.01,82 91.01,76.16 v1(91.41,75.27)
DDR4_DIMM2_DQ52: length 99.9
  L05_SIG2 w0.081: v1(94.6,73.43) 94.6,73.08 94.04,72.52 93.61,72.52 93.08,71.99 92.78,71.99 92.46,71.68 92.03,71.68 91.57,71.21 91.18,71.21 90.83,71.56 90.46,71.56 89.41,72.61 89.41,73.15 89.08,73.48 88.78,73.48 88.36,73.91 88.1,73.91 87.81,74.2 87.81,83 88.41,83.6 88.89,86.82 89.12,88 89.37,88.58 90.16,89.38 90.46,90.34 90.46,94.03 90.82,94.91 91.92,96.01 94,97.4 94.61,97.65 95.16,98.02 96.31,99.16 96.85,99.39 97.29,99.83 97.29,100.13 98.03,100.87 98.61,101.11 99.66,102.16 101.16,102.16 103.5,103.12 113.76,103.12 113.98,103.34 115.86,103.34 117.42,101.78 118.94,101.78 119.43,101.29 120.02,101.29 120.17,101.43 120.17,101.69 120.48,102 131.04,102 131.32,102.27 132.06,102.27 132.33,102 137.06,102 137.97,101.08 146.93,101.08 147.59,100.42 149.67,100.42 149.88,100.21 150.91,100.21 151.74,101.05 152.95,101.05 153.5,101.6 v1(153.79,101.6)
DDR4_DIMM2_DQ53: length 102.9
  L05_SIG2 w0.081: v1(154.64,107.6) 154.16,104.17 154.16,101.45 153.96,101.25 153.35,100.84 153,100.69 152.54,100.69 152.07,100.5 151.7,100.12 151.7,99.87 151.43,99.6 151.08,99.6 150.81,99.87 150.26,99.87 149.57,99.58 147.71,99.58 147.44,99.86 147.44,100.06 147.14,100.36 136.16,100.67 133.52,101.23 120.81,101.23 120.14,100.95 119.23,100.95 118.3,101.09 116.57,101.61 115.8,102.13 115.48,102.13 114.11,102.69 111.35,102.69 109.73,102.54 109.17,102.43 108.79,102.26 108.37,102.26 108.31,102.33 106.59,102.33 106.53,102.26 105.84,102.26 105.78,102.33 104.14,102.33 103.92,102.11 103.41,102.11 103.19,102.33 102.52,102.33 101.45,101.88 101.1,101.53 100.31,101.21 99.4,101.21 99.16,101.11 98.68,100.63 98.51,100.56 98.16,100.21 98.09,100.06 98.09,99.82 97.8,99.53 96.22,98.47 95.56,97.82 94.9,97.37 94.37,97.16 92.22,95.72 91.42,94.93 91.33,94.7 91.33,93.95 90.86,92.82 90.86,90.66 90.57,88.73 88.6,82.28 88.6,74.71 89,74.31 89.19,74.31 89.68,73.82 89.95,73.82 90.24,73.53 90.24,72.82 90.49,72.57 90.79,72.57 91.24,72.13 91.67,72.13 92.02,72.48 92.33,72.48 92.81,72.97 93.07,72.97 93.4,73.3 93.4,74.4 v1(93.8,74.81)
DDR4_DIMM2_DQ54: length 100.7
  L05_SIG2 w0.081: v1(159.74,101.6) 160.26,102.11 161.45,102.11 161.89,101.68 161.89,99.04 160.94,98.1 160.78,98.1 160.2,98.67 160.04,98.67 159.93,98.56 159.93,98.4 160.51,97.82 160.51,97.66 159.95,97.11 159.62,97.11 159.51,97.22 159.51,97.71 159.4,97.82 159.24,97.82 159.12,97.71 159.12,97.22 159.01,97.11 158.85,97.11 158.74,97.22 158.74,97.71 158.63,97.82 158.47,97.82 158.35,97.71 158.35,97.22 158.24,97.11 157.35,97.11 156.04,95.8 133.92,95.8 133.69,95.57 133.37,95.57 132.45,96.49 123.98,96.49 123.03,95.54 121.52,95.54 119.97,93.98 117.66,93.98 115.97,95.67 114.3,96.36 111.75,96.87 111.04,97.17 109.45,97.17 108.8,97.44 107.64,97.44 107.37,97.17 106.9,97.17 106.3,97.42 105.14,97.42 104.8,97.08 103.59,97.08 103.01,96.5 101.04,96.5 100.84,96.41 100.67,96.25 100.67,96.12 99.83,95.28 99.83,95.14 99.54,94.44 98.65,93.56 98.41,93.56 98.05,93.2 97.26,93.2 95.59,91.52 95.59,86.75 95.46,86.44 94.5,85.47 94.5,83.47 94.2,83.18 94.2,74.29 v1(93.8,73.89)
DDR4_DIMM2_DQ55: length 103.2
  L05_SIG2 w0.081: v1(94.6,75.27) 94.97,75.64 94.97,85.44 95.73,86.2 95.97,86.78 95.97,91.42 97.24,92.69 98.71,92.69 98.94,92.92 98.94,93.3 99.79,94.16 100.18,95.1 100.7,95.61 101.21,95.61 101.68,96.09 103.08,96.09 103.71,96.73 104.94,96.73 105.27,97.06 106.29,97.06 106.83,96.83 107.51,96.83 107.78,97.1 108.73,97.1 109.39,96.83 110.68,96.83 111.16,96.63 113.83,96.1 114.94,95.64 115.19,95.39 115.19,95.26 115.73,94.72 116.44,94.72 117.56,93.6 120.83,93.6 121.02,93.79 121.02,94.33 121.27,94.58 122.79,94.58 123.77,95.56 130.24,95.56 130.45,95.76 132.59,95.76 133.14,95.21 133.82,95.21 134.07,95.47 156.45,95.47 157.65,96.68 160.09,96.68 162.71,99.29 162.71,101.89 160.59,104 160.59,105.68 160.48,105.79 159.73,105.79 159.62,105.91 159.62,106.07 159.73,106.18 160.48,106.18 160.59,106.29 160.59,106.45 160.48,106.57 159.73,106.57 159.62,106.68 159.62,106.84 159.73,106.95 160.48,106.95 160.59,107.06 v1(160.59,107.6)
DDR4_DIMM2_DQ56: length 93.5
  L03_SIG1 w0.081: v4(164.84,101.6) 164.57,101.6 164.05,102.12 163.68,102.12 163.37,102.42 161.31,102.42 160.65,103.08 160.24,103.08 160.1,102.94 160.1,102.8 159.97,102.67 159.78,102.67 159.64,102.8 159.64,102.94 159.5,103.08 154.18,103.08 153.16,102.05 152.82,102.05 152.53,101.76 152.53,101.51 152,100.97 151.68,100.97 150.81,100.1 150.81,98.98 150.52,98.69 149.76,98.69 148.99,97.92 147.82,97.44 147.17,97.44 143.52,95.92 141.45,95.92 141.25,95.84 135.82,95.84 134.47,94.49 133.99,94.49 133.84,94.34 133.84,93.1 130.74,90.01 117.75,90.01 117.63,89.89 117.63,89.73 117.75,89.62 119.82,89.62 119.95,89.49 119.95,89.26 119.82,89.13 111.45,89.13 110.07,88.72 108.88,88.36 107.8,87.28 107.33,87.28 105.91,85.87 100.29,83.54 93.68,83.54 89.77,82.35 89.14,81.72 88.91,81.72 87.98,80.79 v4(86.63,80.79)
DDR4_DIMM2_DQ57: length 94.1
  L03_SIG1 w0.081: v4(85.83,80.33) 85.83,80.62 85.2,81.26 84.8,81.26 84.41,81.65 84.06,81.65 83.79,81.92 83.79,82.41 85.31,83.94 86.5,84.65 92.29,86.4 93.25,87.37 95.02,87.37 96.75,89.1 106.09,91.94 113.8,91.94 115.9,92.65 124.45,92.65 125.36,93.56 126.37,93.56 127.31,94.5 127.81,94.5 128.94,95.63 129.44,95.63 131.58,97.77 132.45,97.77 133.35,98.67 137.57,98.67 137.84,98.4 140.55,98.4 142.49,99.2 143.11,99.83 143.11,100.26 143.32,100.47 143.54,100.56 144.81,100.56 145.71,101.46 145.71,101.83 146.76,102.89 153.1,106.76 164.22,106.76 v4(165.69,107.6)
DDR4_DIMM2_DQ58: length 95.4
  L03_SIG1 w0.081: v4(170.79,101.6) 167.8,104.6 157.33,104.6 157.03,104.9 153.68,104.9 152.07,103.29 150.53,102.77 149.93,102.17 149.93,101.25 149.36,100.68 148.83,100.68 148.23,100.08 148.23,99.63 147.43,98.83 143.24,97.1 141.36,97.1 141.02,96.96 134.93,96.96 134.51,96.54 133.42,96.54 132.72,95.84 132.52,95.84 131.91,95.23 131.91,94.74 131.22,94.06 131.22,92.76 129.6,91.14 117.18,91.14 116.37,90.33 110.66,90.33 103.79,88.25 102.14,86.59 97.64,84.73 92.5,84.73 88.04,83.38 87.12,82.73 86.85,82.36 86.85,81.93 v4(86.63,81.71)
DDR4_DIMM2_DQ59: length 96.1
  L03_SIG1 w0.081: v4(85.83,82.17) 87.13,83.47 87.46,83.66 92.3,85.13 97.05,85.13 100.18,86.43 101.01,87.26 101.47,87.44 103.34,88.72 110.04,90.75 116.02,90.75 116.76,91.49 128.93,91.49 130.84,93.4 130.84,94.19 131.55,94.9 131.55,95.43 132.45,96.32 132.67,96.32 133.92,97.56 137.11,97.56 137.38,97.29 140.91,97.29 141.32,97.46 142.79,97.46 146.65,99.06 147.42,99.83 147.42,100.11 147.87,100.56 148.2,100.56 148.7,101.05 148.92,101.05 149.14,101.27 149.14,102.34 149.62,102.82 151.88,103.75 153.36,105.24 157.33,105.24 157.48,105.09 164.5,105.09 164.78,105.36 165.62,105.36 165.89,105.09 166.96,105.09 v4(171.64,107.6)
DDR4_DIMM2_DQ60: length 99.6
  L03_SIG1 w0.081: v4(163.14,101.6) 163.14,101.06 163.45,100.75 164.54,100.75 164.64,100.65 164.64,100.41 164.5,100.27 164.27,100.27 164.16,100.38 162.76,100.38 162.58,100.56 162.58,101.07 162.44,101.21 161.87,101.21 161.76,101.09 161.36,101.09 161,101.45 161,101.73 160.74,101.99 159.58,101.99 159.3,101.71 158.57,101.71 157.95,102.34 157.28,102.34 156.93,101.99 156.47,101.99 156.12,102.34 155.45,102.34 155.11,101.99 154.46,101.99 154.24,101.77 154.24,101.42 153.98,101.16 153.15,100.81 152.51,100.17 152.51,99.63 150.75,97.87 149.9,97.87 149.3,97.27 147.93,96.7 147.4,96.7 143.9,95.25 141.65,95.25 141.45,95.17 137.23,95.17 136.13,94.06 135.78,94.06 130.76,89.05 120.83,89.05 120.16,88.38 119.68,88.38 119.56,88.27 119.56,87.95 119.45,87.84 119.19,87.84 119.08,87.95 119.08,88.21 118.96,88.32 118.8,88.32 118.69,88.21 118.69,87.95 118.58,87.84 117.47,87.84 117.35,87.95 117.35,88.27 117.24,88.38 111.72,88.38 110.98,88.16 109.27,86.44 100.05,82.63 93.87,82.63 93.12,82.4 92.41,81.69 92.02,81.69 90.82,80.5 89.44,80.5 88.4,79.45 88.03,79.45 87.54,78.96 87.24,78.96 86.78,78.49 86.55,78.49 86.11,78.06 85.73,78.06 85.35,78.44 84.84,78.44 84.39,78.89 84.08,78.89 83.61,79.36 83.23,79.36 82.74,79.86 82.44,79.86 81.97,80.33 v4(81.05,80.33)
DDR4_DIMM2_DQ61: length 99.3
  L03_SIG1 w0.081: v4(163.99,107.6) 163.55,108.05 151.03,108.05 150.79,107.8 150.79,107.35 150.44,107 148.21,107 146.68,105.48 146.68,105.3 146.83,105.15 147.01,105.15 148.1,106.24 148.28,106.24 148.43,106.09 148.43,105.91 146.54,104.03 145.74,104.03 145.61,103.9 145.61,103.16 144.44,101.98 144.2,101.98 143.96,101.74 143.96,101.45 143.75,101.23 142.81,101.23 142.27,100.69 141.92,100.69 141.41,100.18 141.41,99.75 140.98,99.32 140.38,99.07 138.12,99.07 137.84,99.34 131.05,99.34 128.18,96.47 125.89,96.47 125.01,95.59 124.72,95.59 124.03,94.9 122.82,94.9 122.5,94.58 120.71,94.58 119.67,93.54 114.11,93.54 113.26,92.69 105.21,92.69 92.02,88.69 91.68,88.34 91.68,87.66 91.34,87.32 89.42,87.32 88.03,85.93 84.81,84.95 82.23,82.38 82.23,81.17 v1(81.85,80.79)
DDR4_DIMM2_DQ62: length 98.8
  L03_SIG1 w0.081: v4(82.65,81.25) 82.94,80.96 82.94,80.72 83.38,80.29 83.57,80.29 84.04,79.81 84.42,79.81 84.82,79.41 85.18,79.41 85.64,78.95 86.01,78.95 86.44,79.38 86.78,79.38 87.8,80.39 88.77,80.39 90.11,81.74 90.81,81.74 91.16,82.09 91.9,82.54 93.53,83.03 99.97,83.03 107.85,86.29 108.88,87.33 109.36,87.33 110.36,88.32 111.78,88.76 117.8,88.76 117.92,88.64 117.92,88.41 118.03,88.29 118.19,88.29 118.3,88.41 118.3,88.64 118.42,88.76 119.95,88.76 120.83,89.64 130.87,89.64 134.68,93.45 134.68,94.16 136.02,95.5 141.34,95.5 141.54,95.59 143.77,95.59 147.37,97.08 147.86,97.08 149.18,97.63 149.86,98.31 150.62,98.31 151.23,98.92 151.23,99.4 151.67,99.84 151.67,100.34 151.91,100.57 152.17,100.57 152.79,101.19 153.06,101.19 153.4,101.53 153.4,101.77 153.65,102.03 155.21,102.67 159.1,102.67 159.44,102.33 160.9,102.33 161.15,102.08 163.23,102.08 163.58,101.73 163.58,101.39 163.83,101.13 164.52,101.13 165.89,100.56 167.06,100.56 168.76,101.27 v4(169.09,101.6)
DDR4_DIMM2_DQ63: length 98.7
  L03_SIG1 w0.081: v4(83.44,81.71) 83.44,82.81 85.34,84.71 91.84,86.68 92.21,87.05 92.21,88.06 92.64,88.5 93.33,88.5 105.99,92.34 113.33,92.34 115.08,93.06 119.83,93.06 120.28,93.51 122.06,93.51 123.02,94.47 125.13,94.47 126.27,95.61 128.07,95.61 130.94,98.48 132.68,98.48 133.21,99.01 137.71,99.01 137.98,98.74 140.45,98.74 141.79,99.29 142.35,99.85 142.35,100.23 143.01,100.89 144.27,100.89 144.88,101.5 144.88,101.93 146.05,103.1 146.34,103.1 148.22,104.98 149.37,104.98 149.67,105.28 149.67,105.47 149.47,105.67 149.47,105.86 149.61,106 149.8,106 150,105.8 150.19,105.8 151.55,107.16 164.16,107.16 164.4,107.39 164.4,107.77 164.63,108 169.54,108 v4(169.94,107.6)
DDR4_DIMM2_DQ64: length 69.1
  L12_SIG4 w0.089: v1(90.89,101.6) 90.89,100.89 90.47,100.46 90.47,99.67 90.29,99.5 89.75,99.5 89.62,99.63 89.62,100.53 89.49,100.66 88.89,100.66 88.76,100.53 88.76,99.63 88.63,99.5 88.04,99.5 87.91,99.63 87.91,100.44 87.78,100.57 87.16,100.57 87.03,100.44 87.03,99.63 86.9,99.5 86.37,99.5 86.25,99.62 86.25,100.5 86.07,100.67 85.47,100.67 85.33,100.54 85.33,99.63 85.22,99.51 84.6,99.51 84.48,99.4 84.48,99.12 84.61,98.99 85.66,98.99 85.79,98.86 85.79,98.67 85.66,98.54 84.61,98.54 84.48,98.41 84.48,98.23 84.61,98.1 86.1,98.1 86.23,97.97 86.23,97.78 86.1,97.65 84.61,97.65 84.48,97.52 84.48,96.93 84.35,96.8 84.16,96.8 84.03,96.93 84.03,99.04 83.9,99.17 83.72,99.17 83.59,99.04 83.59,96.47 83.72,96.34 84.52,96.34 84.66,96.21 84.66,95.82 84.52,95.69 83.36,95.69 83.23,95.56 83.23,95.38 83.36,95.25 84.35,95.25 84.48,95.12 84.48,94.93 84.35,94.8 83.36,94.8 83.23,94.67 83.23,94.49 83.36,94.36 84.35,94.36 84.48,94.23 84.48,93.51 83.9,92.94 83.9,92.8 84.1,92.6 84.31,92.6 85.25,93.54 85.45,93.54 85.61,93.38 85.61,93.17 84.63,92.19 84.63,91.98 84.78,91.83 84.98,91.83 85.97,92.81 86.18,92.81 86.34,92.66 86.34,92.45 85.33,91.44 85.33,91.3 87.8,88.83 88,88.83 88.15,88.98 88.15,89.18 86.15,91.18 86.15,91.39 86.29,91.53 86.5,91.53 88.64,89.39 88.64,85.86 91.26,83.24 91.26,82.47 91.02,82.22 91.02,77.97 v1(90.61,77.57)
DDR4_DIMM2_DQ65: length 69.3
  L12_SIG4 w0.089: v1(91.74,107.6) 91.37,107.98 83,107.98 82.78,107.75 82.78,107.32 82.6,107.14 81.77,107.14 80.61,105.98 80.61,104.68 81.67,103.62 89.65,103.62 90.17,103.11 90.17,102.37 90.31,102.22 91.2,102.22 91.34,102.08 91.34,99.81 90.6,99.07 86.36,99.07 86.26,98.97 86.26,98.76 86.39,98.63 87.12,98.63 87.25,98.5 87.25,98.32 87.12,98.19 86.79,98.19 86.66,98.05 86.66,97.86 86.76,97.76 87.02,97.76 87.16,97.61 87.16,97.41 87.02,97.26 85.3,97.26 85.15,97.12 85.15,96.64 85.3,96.49 87.02,96.49 87.16,96.35 87.16,96.14 87.02,96 85.3,96 85.15,95.85 85.15,95.65 85.3,95.5 87.02,95.5 87.14,95.38 87.14,95.24 87.02,95.12 85.47,95.12 85.37,95.01 85.37,94.61 85.47,94.51 86.01,94.51 86.27,94.25 86.27,93.35 86.77,92.86 86.77,92 89.1,89.66 89.1,86.25 91.83,83.53 91.83,77.52 v1(91.41,77.11)
DDR4_DIMM2_DQ66: length 68.1
  L12_SIG4 w0.089: v1(96.89,101.6) 96.89,102.47 97.79,103.36 97.79,104.22 97.38,104.63 97.38,106.58 98.09,107.29 98.09,107.82 97.9,108.01 96.55,108.01 96.4,107.85 96.4,107.24 96.25,107.09 95.97,107.09 95.56,107.5 95.56,108.31 95.19,108.68 80.96,108.68 80.25,107.97 80.25,107.23 79.41,106.39 79.41,105.84 79.28,105.71 78.81,105.71 78.68,105.59 78.68,105.29 78.81,105.17 79.62,105.17 79.75,105.04 79.75,104.75 79.62,104.62 78.81,104.62 78.68,104.49 78.68,104.2 78.81,104.07 79.28,104.07 79.41,103.95 79.41,97.36 81.13,95.64 81.13,92.95 85.56,88.52 85.56,86.49 88.64,83.42 88.64,76.41 88.87,76.18 89.2,76.18 89.58,75.8 90.15,75.8 90.23,75.73 v1(90.61,75.73)
DDR4_DIMM2_DQ67: length 68.1
  L12_SIG4 w0.089: v1(91.41,76.19) 91.07,76.53 91.07,76.8 90.7,77.17 90.43,77.17 90.2,77.4 90.2,83.55 87.86,85.89 87.86,88.08 82.83,93.11 82.83,98.97 83.71,99.85 83.71,100.24 84.63,101.16 89.36,101.16 89.66,101.46 89.66,102.89 89.36,103.18 81.46,103.18 80.2,104.45 80.2,106.46 81.13,107.39 81.13,107.75 81.71,108.33 95,108.33 95.11,108.23 95.11,107.47 95.88,106.7 96.79,106.7 v1(97.69,107.6)
DDR4_DIMM2_DQ68: length 71
  L12_SIG4 w0.089: v1(89.25,101.6) 89.25,102.63 89.09,102.78 88.91,102.78 88.76,102.64 88.76,101.84 88.62,101.69 88.13,101.69 87.98,101.84 87.98,102.64 87.84,102.78 87.66,102.78 87.51,102.64 87.51,102.15 87.37,102 87.16,102 87.02,102.15 87.02,102.64 86.87,102.78 86.4,102.78 86.26,102.64 86.26,102.17 86.13,102.05 85.95,102.05 85.82,102.17 85.82,102.64 85.69,102.77 85.47,102.77 85.34,102.64 85.34,102.16 85.19,102.01 84.69,102.01 84.54,102.16 84.54,102.64 84.4,102.78 84.18,102.78 84.04,102.64 84.04,102.17 83.89,102.03 83.5,102.03 83.36,102.17 83.36,102.64 83.21,102.78 82.97,102.78 82.82,102.64 82.82,102.14 82.68,102 81.99,102 81.85,102.14 81.85,102.64 81.7,102.78 81.05,102.78 80.5,103.33 80.19,103.33 79.97,103.12 79.97,102.8 80.23,102.55 80.23,101.26 80.38,101.11 83.23,101.11 83.37,100.97 83.37,100.76 83.23,100.62 80.41,100.62 80.27,100.48 80.27,99.75 80.42,99.6 82.03,99.6 82.17,99.46 82.17,99.25 82.03,99.11 80.09,99.11 79.94,98.96 79.94,98.76 80.09,98.61 81.88,98.61 82.03,98.47 82.03,98.26 81.88,98.12 80.15,98.12 80,97.97 80,97.77 80.15,97.62 81.88,97.62 82.03,97.48 82.03,97.27 81.88,97.13 81.31,97.13 81.17,96.98 81.17,96.45 81.95,95.66 81.95,93.03 86.63,88.35 86.63,86.24 89.42,83.45 89.42,76.96 89.75,76.63 90.02,76.63 90.48,76.18 90.82,76.18 91.04,75.96 91.04,74.99 91.22,74.81 91.59,74.81 92.05,74.35 92.37,74.35 92.83,74.81 93.24,74.81 93.5,75.07 93.5,75.43 v1(93.8,75.73)
DDR4_DIMM2_DQ69: length 72.3
  L12_SIG4 w0.089: v1(90.04,107.6) 89.76,107.31 89.76,107.1 90.12,106.74 90.55,106.74 90.88,107.08 92.06,107.08 92.22,107.24 92.22,107.88 92.32,107.98 94.6,107.98 94.76,107.82 94.76,106.65 95.09,106.32 96.63,106.32 96.97,105.98 96.97,104.27 97.12,104.12 97.29,104.12 97.43,103.99 97.43,103.5 97.1,103.17 96.94,103.17 96.47,102.71 95.69,102.71 95.54,102.56 95.54,101.19 95.64,101.09 96.54,101.09 96.64,100.98 96.64,100.84 96.54,100.74 95.6,100.74 95.5,100.64 95.5,100.5 95.6,100.4 96.28,100.4 96.38,100.3 96.38,98.72 95.31,97.65 95.31,94.82 94.69,94.2 94.69,93.83 95.19,93.33 95.19,90.98 95.09,90.88 94.95,90.88 94.85,90.98 94.85,93.16 94.75,93.26 94.6,93.26 94.5,93.16 94.5,91 94.4,90.9 94.26,90.9 94.16,91 94.16,93.61 94.06,93.71 93.92,93.71 93.82,93.61 93.82,88.44 93.92,88.34 94.06,88.34 94.16,88.44 94.16,90.29 94.26,90.39 94.4,90.39 94.5,90.29 94.5,88.44 94.6,88.34 94.75,88.34 94.85,88.44 94.85,90.29 94.95,90.39 95.09,90.39 95.19,90.29 95.19,84.94 95.09,84.84 94.95,84.84 94.85,84.94 94.85,86.03 94.31,86.57 94.31,87.75 94.2,87.86 94.03,87.86 93.92,87.75 93.92,86.39 94.46,85.85 94.46,82.88 95,82.34 95,77.51 v1(94.6,77.11)
DDR4_DIMM2_DQ70: length 72.2
  L12_SIG4 w0.089: v1(95.14,101.6) 95.14,100.89 94.73,100.48 94.73,99.72 94.87,99.58 95.93,99.58 96.03,99.48 96.03,98.92 95.93,98.82 95.71,98.82 95.61,98.92 95.61,99.1 95.51,99.2 95.37,99.2 95.27,99.1 95.27,98.25 95.17,98.15 95.02,98.15 94.92,98.25 94.92,99.12 94.82,99.22 94.68,99.22 94.58,99.12 94.58,98.09 94.48,97.99 94.34,97.99 94.24,98.09 94.24,99.5 94.14,99.6 94,99.6 93.9,99.5 93.9,97.67 94,97.56 94.83,97.56 94.93,97.46 94.93,97.32 94.83,97.22 93.67,97.22 93.57,97.12 93.57,96.98 93.67,96.88 94.83,96.88 94.93,96.78 94.93,96.64 94.83,96.54 94,96.54 93.9,96.44 93.9,96.29 94,96.19 94.83,96.19 94.93,96.09 94.93,95.95 94.83,95.85 93.95,95.85 93.84,95.75 93.84,95.61 93.95,95.51 94.83,95.51 94.93,95.41 94.93,95.27 94.83,95.16 94,95.16 93.73,94.9 93.73,94.74 93.91,94.56 93.91,94.41 93.81,94.31 93.66,94.31 93.52,94.45 92.31,94.45 92.04,94.18 92.04,91.31 92.14,91.21 92.28,91.21 92.38,91.31 92.38,93.51 92.48,93.61 92.62,93.61 92.72,93.51 92.72,91.27 92.82,91.17 92.96,91.17 93.06,91.27 93.06,93.51 93.17,93.61 93.31,93.61 93.41,93.51 93.41,88.49 93.31,88.39 93.17,88.39 93.06,88.49 93.06,90.51 92.96,90.61 92.82,90.61 92.72,90.51 92.72,87.88 92.62,87.78 92.48,87.78 92.38,87.88 92.38,90.51 92.28,90.61 92.14,90.61 92.04,90.51 92.04,87.44 92.45,87.02 92.59,87.02 93.07,87.5 93.21,87.5 93.31,87.4 93.31,87.26 92.84,86.78 92.84,86.64 94.06,85.42 94.06,85.28 93.96,85.18 93.81,85.18 92.26,86.73 92.12,86.73 92.02,86.63 92.02,86.49 93.95,84.56 93.95,82.77 94.19,82.53 94.19,77.96 v1(93.8,77.57)
DDR4_DIMM2_DQ71: length 70.7
  L12_SIG4 w0.089: v1(95.99,107.6) 95.99,108.17 96.19,108.36 98.86,108.36 99.22,108 99.95,108 100.2,107.75 100.2,107.45 99.83,107.08 99.83,106.12 99.73,106.02 99.57,106.02 99.47,106.12 99.47,107.06 99.37,107.16 99.23,107.16 99.13,107.06 99.13,106.12 99.03,106.02 98.89,106.02 98.79,106.12 98.79,107.07 98.68,107.17 98.54,107.17 98.44,107.07 98.44,106.12 98.34,106.02 98.2,106.02 98.1,106.12 98.1,106.41 98,106.52 97.86,106.52 97.76,106.41 97.76,104.88 97.86,104.78 98.09,104.78 98.15,104.84 98.15,105.06 98.23,105.14 98.5,105.14 98.62,105.03 98.62,104.53 98.52,104.43 98.25,104.43 98.14,104.33 98.14,104.19 98.25,104.09 98.52,104.09 98.62,103.98 98.62,103.84 98.52,103.74 98.25,103.74 98.14,103.64 98.14,103.5 98.25,103.4 98.52,103.4 98.62,103.3 98.62,103.13 98.52,103.03 97.99,103.03 97.89,102.93 97.89,102.79 97.99,102.69 98.89,102.69 98.99,102.59 98.99,102.44 98.89,102.34 97.53,102.34 97.43,102.24 97.43,102.1 97.53,102 99.19,102 99.29,101.9 99.29,101.31 99.19,101.21 97.14,101.21 97.04,101.11 97.04,100.92 97.14,100.82 98.85,100.82 98.95,100.72 98.95,100.52 98.85,100.42 97.49,100.42 97.3,100.23 97.3,99.49 97.2,99.39 96.84,99.39 96.74,99.28 96.74,99.02 96.84,98.92 97.2,98.92 97.3,98.82 97.3,98.4 97.2,98.3 96.59,98.3 96.38,98.09 96.38,95.61 96.28,95.51 96.14,95.51 96.04,95.61 96.04,97.47 95.94,97.57 95.8,97.57 95.7,97.47 95.7,95.21 95.83,95.07 96.5,95.07 96.7,94.88 96.7,94.41 96.39,94.1 95.87,94.1 95.53,93.76 95.53,85.04 95.79,84.78 95.79,84.57 95.69,84.47 94.94,84.47 94.84,84.36 94.84,84.22 94.94,84.12 95.9,84.12 96,84.02 96,83.88 95.9,83.78 94.94,83.78 94.84,83.68 94.84,83.54 94.94,83.44 95.93,83.44 96.03,83.34 96.03,83.19 95.93,83.09 95.21,83.09 95.11,82.99 95.11,82.85 95.21,82.75 95.69,82.75 95.79,82.65 95.79,77.4 95.51,77.12 95.21,77.12 94.6,76.51 v1(94.6,76.19)
DDR4_DIMM2_DQS_N0: length 67.5
  L12_SIG4 w0.076: v1(87.43,74.81) 87.77,75.01 87.79,75.07 87.75,75.14 arc(87.71,75.17) 87.67,75.18 87.38,75.18 arc(87.25,75.15) 87.15,75.06 87.04,74.89 arc(86.87,74.74) 86.65,74.69 86.55,74.69 arc(86.34,74.75) 86.19,74.91 86.12,75.08 arc(86.07,75.27) 86.12,75.46 86.18,75.6 arc(86.21,75.74) 86.18,75.88 86.12,75.97 arc(86.07,76.2) 86.13,76.43 86.15,76.46 arc(86.2,76.63) 86.16,76.79 86.1,76.89 arc(86.05,77.1) 86.11,77.3 86.18,77.43 arc(86.22,77.56) 86.19,77.69 86.11,77.85 arc(86.06,78.06) 86.13,78.26 86.18,78.34 arc(86.23,78.48) 86.2,78.63 86.13,78.76 arc(86.09,79) 86.18,79.22 86.21,79.25 arc(86.26,79.36) 86.23,79.46 86.14,79.63 arc(86.07,79.87) 86.14,80.11 86.18,80.19 arc(86.22,80.32) 86.19,80.46 86.14,80.55 arc(86.07,80.81) 86.14,81.06 86.17,81.12 arc(86.2,81.23) 86.17,81.35 86.12,81.44 arc(86.05,81.66) 86.1,81.88 86.2,82.07 arc(86.22,82.11) 86.22,82.15 86.22,82.63 86.22,82.64 86.22,82.66
  L12_SIG4 w0.089: v1(56.04,107.6) 56.37,107.27 56.37,107.01 55.22,105.86 55.22,104.62 55.6,104.24 56.96,104.24 57.32,104.61 57.32,106.23 57.59,106.49 58.04,106.49 58.29,106.24 58.29,104.52 58.65,104.16 59.33,104.16 59.69,104.52 59.69,105.85 59.96,106.12 60.65,106.12 60.9,105.86 60.9,104.05 61.27,103.68 64.74,103.68 65.09,104.04 66.66,104.04 67.35,104.72 72.16,104.72 76.11,100.77 76.11,99.96 75.77,99.61 75.77,96.9 78.59,94.08 78.59,92.33 82.74,88.18 82.74,86.59 86.22,83.12 86.22,82.66
DDR4_DIMM2_DQS_N1: length 64.6
  L14_SIG5 w0.076: 85.25,82.01 85.27,82 85.27,82 85.32,81.95 85.39,81.85 arc(85.54,81.69) 85.74,81.61 85.98,81.57 arc(86.08,81.52) 86.14,81.43 86.18,81.34 arc(86.2,81.22) 86.15,81.11 86.12,81.07 arc(86.05,80.87) 86.08,80.66 86.19,80.45 arc(86.21,80.34) 86.19,80.23 86.08,79.97 arc(86.06,79.83) 86.1,79.69 86.06,79.54 v1(85.83,79.41)
  L14_SIG5 w0.081: 85.25,82.01 84.69,82.58 79.19,82.58 76.4,85.38 76.4,87.57 72.48,91.49 67.91,91.49 66.02,93.37 63.98,93.37 62.94,94.42 60.48,94.42 60.22,94.69 60.22,95.74 60.06,95.9 59.78,95.9 59.62,95.74 59.62,94.6 59.39,94.37 58.95,94.37 58.69,94.63 58.69,95.66 58.54,95.81 58.12,95.81 57.86,96.07 57.86,96.72 58.12,96.98 59.55,96.98 59.71,97.14 59.71,97.43 59.55,97.59 58.72,97.59 58.45,97.85 58.45,98.52 58.86,98.93 62.28,98.93 62.95,99.59 63.83,99.59 64.24,100 64.24,100.49 63.99,100.73 63.61,100.73 63.34,101 63.34,101.67 63.09,101.92 63.09,102.81 63.37,103.08 64.43,103.08 64.62,103.27 64.62,105.02 64.86,105.26 65.45,105.26 65.59,105.39 65.59,105.71 65.43,105.87 64.83,105.87 64.57,106.13 64.57,106.64 64.83,106.91 65.57,106.91 65.73,107.07 65.73,107.26 v1(65.39,107.6)
