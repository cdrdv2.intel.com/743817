# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 192.29,101.93 190.51,101.93 190.51,103.08 190.25,103.08 190.25,101.93 189.24,101.93 188.98,102.19 185.81,102.19 185.55,101.93 185.55,98.38 185.81,98.12 187.21,98.12 187.33,98.25 187.33,99.14 187.59,99.39 188.73,99.39 188.98,99.65 188.98,100.15 189.24,100.41 190.76,100.41 190.76,99.27 191.02,99.27 191.02,100.41 194.95,100.41 195.33,100.79 195.33,102.19 194.95,102.19 194.95,101.68 194.83,101.55 194.32,101.55 194.19,101.68 194.19,102.19 192.54,102.19 ; 5 cut-outs
GND on TOP: 210.07,33.35 210.07,38.56 210.57,39.07 210.57,42.12 210.32,42.37 208.29,42.37 208.03,42.12 208.03,38.81 208.54,38.31 208.54,35.61 206.92,35.61 206.64,35.89 205.87,35.89 205.87,33.73 206.26,33.35 ; 4 cut-outs
GND on TOP: 201.18,93.3 204.99,93.3 205.24,93.55 205.24,96.73 204.99,96.98 201.18,96.98 200.92,96.73 200.92,93.55
GND on TOP: 185.55,107.14 185.55,106 185.81,105.74 194.95,105.74 195.21,106 195.21,107.14 194.95,107.39 185.81,107.39
GND on TOP: 41.79,55.96 41.79,40.72 41.92,40.59 49.16,40.59 49.28,40.72 49.28,55.96 49.16,56.09 41.92,56.09
GND on TOP: 73.16,45.29 73.16,44.15 75.04,44.15 75.16,44.27 75.16,45.29 75.04,45.42 73.29,45.42
GND on TOP: 76.84,35.77 78.37,35.77 78.49,35.89 78.49,38.18 78.37,38.31 76.84,38.31 76.72,38.18 76.72,35.89
GND on TOP: 193.56,35.64 193.56,33.35 195.97,30.94 195.97,26.49 193.17,26.49 192.92,26.24 192.92,25.48 192.16,24.72 192.16,19 191.78,18.62 188.28,18.62 188.16,18.75 188.16,29.29 188.03,29.42 184.16,29.42 184.03,29.29 184.03,26.95 183.9,26.83 179.34,26.83 179.22,26.95 179.22,30.25 179.34,30.38 179.84,30.38 179.97,30.51 179.97,30.69 180.06,30.9 180.09,30.94 180.22,30.94 180.44,30.85 180.77,30.52 180.98,30.43 185.47,30.43 185.6,30.56 185.6,33.4 185.47,33.53 184.47,33.53 184.35,33.66 184.35,35.64 184.47,35.77 193.43,35.77 ; 1 cut-out
GND on TOP: 164.85,34.75 165.11,35 167.14,35 167.39,34.75 167.39,16.97 167.01,16.59 164.98,16.59 164.85,16.72
GND on BOTTOM: 148.22,93.04 156.09,93.04 156.47,92.66 156.47,34.37 156.22,34.11 148.34,34.11 148.09,34.37 148.09,92.92
GND on BOTTOM: 123.32,47.07 129.29,47.07 129.55,47.32 129.55,70.82 129.29,71.07 123.32,71.07 123.07,70.82 123.07,47.32
GND on BOTTOM: 85.61,17.86 85.61,15.06 85.73,14.94 86.49,14.94 86.62,15.06 86.62,17.86 86.52,17.96 85.71,17.96
GND on BOTTOM: 241.31,106 242.2,106 242.32,105.87 242.32,104.52 242.07,104.27 241.43,104.27 241.18,104.52 241.18,105.87
GND on BOTTOM: 23.68,80.65 23.48,80.85 22.99,80.85 22.44,80.29 22.44,80.14 22.56,80.01 22.64,80.01 23.07,80.44 23.3,80.44 23.43,80.32 23.68,80.57
GND on BOTTOM: 67.32,17.22 69.73,17.22 69.73,14.81 69.6,14.68 68.84,14.68 68.71,14.81 68.71,16.21 68.46,16.46 67.32,16.46
GND on BOTTOM: 47.51,28.68 46.48,28.68 46.36,28.56 46.36,27.76 45.73,27.13 44.71,27.13 44.71,25.1 45.22,25.1 45.22,25.35 45.73,25.86 47.25,25.86 47.51,26.11
GND on BOTTOM: 227.97,55.83 234.96,55.83 235.21,55.58 235.21,31.57 234.96,31.32 229.65,31.32 229.45,31.52 229.45,39.68 229.6,39.83 232.16,39.83 232.8,40.46 232.8,48.72 232.54,48.97 228.1,48.97 227.72,49.35 227.72,55.58
GND on BOTTOM: 73.79,55.45 73.79,56.72 72.27,56.72 72.14,56.59 72.14,55.32 73.67,55.32
GND on BOTTOM: 178.32,29.42 174.89,29.42 174.76,29.29 174.76,18.75 174.63,18.62 169.55,18.62 169.43,18.75 169.43,35.64 169.55,35.77 178.32,35.77 178.44,35.64 178.44,29.54
GND on BOTTOM: 200.79,34.37 200.79,41.35 200.54,41.61 198.64,41.61 198.25,41.23 198.25,34.37 198.51,34.11 200.54,34.11
GND on BOTTOM: 81.92,30.94 84.84,30.94 85.1,31.19 85.1,32.59 84.84,32.84 82.05,32.84 81.8,32.59 81.8,31.07
GND on BOTTOM: 173.36,55.7 175.01,55.7 175.22,55.91 175.22,56.77 175.01,56.97 173.36,56.97 173.11,56.72 173.11,55.96
GND on BOTTOM: 9.41,35.38 6.36,35.38 6.1,35.64 6.1,37.42 6.36,37.67 9.15,37.67 9.41,37.42 ; 1 cut-out
GND on BOTTOM: 126.65,86.57 127.9,86.57 128.15,86.82 128.15,88.6 127.9,88.85 126.65,88.85 126.4,88.6 126.4,86.82
GND on BOTTOM: 148.47,33.73 156.22,33.73 156.47,33.48 156.47,16.72 156.09,16.33 149.74,16.33 148.85,17.22 148.85,21.29 148.09,22.05 148.09,33.35
GND on BOTTOM: 99.35,97.36 99.35,99.14 99.1,99.14 98.72,99.52 98.72,100.15 98.59,100.28 96.81,100.28 96.43,99.9 96.43,99.01 96.68,98.76 97.32,98.76 97.57,98.5 97.57,97.61 97.83,97.36
GND on BOTTOM: 201.94,24.21 203.84,24.21 204.1,24.46 204.1,25.35 203.84,25.61 201.94,25.61 201.68,25.35 201.68,24.46
GND on BOTTOM: 133.1,61.8 134.63,61.8 134.88,62.05 134.88,65.74 134.63,65.99 133.1,65.99 132.98,65.86 132.98,61.93
GND on BOTTOM: 182.76,39.7 182.76,38.18 182.63,38.05 180.47,38.05 180.35,38.18 180.35,39.7 180.47,39.83 182.63,39.83
GND on BOTTOM: 133.1,52.02 134.63,52.02 134.88,52.28 134.88,58.37 134.63,58.63 133.1,58.63 132.98,58.5 132.98,52.15
GND on BOTTOM: 219.21,42.24 219.21,31.61 218.92,31.32 214,31.32 213.75,31.57 213.75,41.35 214.13,41.73 215.78,41.73 216.8,42.75 218.7,42.75
GND on BOTTOM: 122.13,86.57 123.45,86.57 123.71,86.82 123.71,88.6 123.45,88.85 122.13,88.85 121.88,88.6 121.88,86.82
GND on BOTTOM: 64.27,21.29 65.67,21.29 65.92,21.03 65.92,14.07 65.77,13.92 63.76,13.92 63.51,14.18 63.51,15.19 63,15.7 63,19.26 63.76,20.02 63.76,20.78
GND on BOTTOM: 97.56,32.45 101.57,32.45 102.3,33.19 102.3,35.6 102.05,35.85 96.86,35.85 96.6,35.6 96.6,33.41
GND on BOTTOM: 102.2,65.81 104.91,65.81 104.99,65.74 104.99,59.03 104.63,58.68 104.63,57.58 103.61,57.58 103.61,59.29 103.44,59.46 102.1,59.46 101.94,59.63 100.11,59.63 99.95,59.46 98.58,59.46 98.43,59.31 98.43,58.54 98.36,58.47 97.29,58.47 97.29,59.64 96.96,59.97 96.96,65.48 97.22,65.74 99.75,65.74 99.88,65.61 99.88,64.39 100.01,64.26 101.95,64.26 102.08,64.39 102.08,65.69 ; 2 cut-outs
GND on BOTTOM: 133.48,73.74 134.37,73.74 134.63,73.99 134.63,75.64 134.37,75.9 133.48,75.9 133.23,75.64 133.23,73.99
GND on BOTTOM: 164.85,35.51 164.85,92.79 165.11,93.04 167.14,93.04 167.39,92.79 167.39,35.51 167.14,35.26 165.11,35.26
GND on BOTTOM: outline of 110 points within 58.05,45.29 68.71,53.29 ; 6 cut-outs
GND on BOTTOM: 67.45,23.57 67.45,22.56 69.95,22.56 69.95,23.57
GND on BOTTOM: 164.85,34.5 165.11,34.75 167.14,34.75 167.39,34.5 167.39,18.62 166.76,17.99 164.98,17.99 164.85,18.11
GND on BOTTOM: 133.1,42.24 134.5,42.24 134.75,42.5 134.75,48.59 134.5,48.85 133.1,48.85 132.98,48.72 132.98,42.37
GND on BOTTOM: 36.08,33.73 42.3,33.73 42.64,33.39 42.64,31.91 42.56,31.83 40.39,31.83 40.22,31.65 40.22,28.45 40.29,28.37 42.7,28.37 42.81,28.27 42.81,27.87 42.7,27.76 39.45,27.76 39.25,27.56 39.25,26.39 39.1,26.24 35.7,26.24 35.55,26.4 35.55,28.35 35.62,28.43 37.22,28.43 37.81,29.02 38.7,29.02 38.79,29.11 38.79,31.64 38.61,31.82 38.38,31.82 38.22,31.98 38.22,33 38.09,33.12 36.57,33.12 36.44,33 36.44,31.82 35.78,31.82 35.78,33.44 ; 6 cut-outs
GND on BOTTOM: 99.35,105.11 99.35,106.76 99.32,106.76 98.72,107.36 98.72,108.03 98.59,108.16 96.81,108.16 96.43,107.77 96.43,107.14 96.68,106.89 97.8,106.89 98.08,106.6 98.08,105.33 98.31,105.11
GND on BOTTOM: 115.83,33.99 124.34,33.99 124.59,34.24 124.59,35.64 124.34,35.89 115.83,35.89 115.58,35.64 115.58,34.24
GND on BOTTOM: 135.67,106.89 135.67,101.55 135.42,101.3 133.99,101.3 133.84,101.45 133.84,101.78 133.64,101.98 133.41,101.98 133.39,102.01 133.39,106.89 133.56,107.06 135.5,107.06
GND on BOTTOM: 210.57,34.37 210.57,41.35 210.32,41.61 208.41,41.61 208.03,41.23 208.03,34.37 208.29,34.11 210.32,34.11
GND on BOTTOM: 195.21,51.89 195.21,57.48 195.33,57.61 195.84,57.61 195.97,57.48 195.97,56.85 196.2,56.62 197.19,56.62 197.24,56.57 197.24,53.29 196.98,53.04 196.98,51.77 197.37,51.39 197.37,46.05 197.11,45.8 194.19,45.8 194.06,45.93 194.06,50.75 ; 5 cut-outs
GND on BOTTOM: 134.55,94.44 133.39,94.44 133.39,99.27 133.64,99.52 134.98,99.52 135.16,99.34 135.16,95.05
GND on BOTTOM: 195.08,103.33 195.08,100.66 194.83,100.41 193.81,100.41 192.67,99.27 186.32,99.27 185.55,100.03 185.55,101.93 185.81,102.19 188.73,102.19 189.11,102.57 189.11,103.71 189.24,103.84 192.16,103.84 192.41,103.58 194.83,103.58
GND on BOTTOM: 7.37,57.61 4.58,57.61 4.33,57.86 4.33,60.02 4.58,60.28 7.12,60.28 7.37,60.02 ; 1 cut-out
GND on BOTTOM: 7.88,97.87 8.72,97.87 8.97,98.12 8.97,98.86 8.72,99.11 7.88,99.11 7.63,98.86 7.63,98.12
GND on BOTTOM: 193.56,35.64 193.56,18.75 193.43,18.62 188.45,18.62 188.23,18.71 188.22,18.72 188.22,29.29 188.09,29.42 184.16,29.42 184.03,29.29 184.03,26.95 183.9,26.83 179.99,26.83 179.86,26.95 179.86,28.02 179.99,28.15 181.24,28.15 182.13,29.03 182.13,30.43 182.38,30.69 185.55,30.69 185.77,30.91 185.77,33.72 185.63,33.86 184.67,33.86 184.54,33.99 184.54,35.64 184.67,35.77 193.43,35.77
GND on L02_GND1, L04_GND2, L06_GND3, L08_GND4, L11_GND5, L13_GND6, L15_GND7, L17_GND8: 14.37,5.13 0.63,5.13 0.63,110.52 253.37,110.52 253.37,13.38 140.78,13.38 139.09,12.69 138.39,11 138.39,9.7 139.09,8.01 140.78,7.31 144.11,7.31 144.11,5.5 142.98,3.58 132.82,3.58 132.68,3.72 132.68,7.62 130.67,9.63 128.67,7.62 128.67,1.69 58.74,1.69 58.74,7.45 57.15,9.03 55.57,7.45 55.57,5.64 45.64,5.64 45.64,10.92 43.18,13.38 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.38 14.37,13.38
GND on L03_SIG1: 116.59,64.85 118.5,64.85 118.75,65.1 118.75,68.15 118.24,68.66 116.09,68.66 115.83,68.4 115.83,65.61
GND_CHS on BOTTOM (solid shape): 4.22,99.11 7.12,99.11 7.12,98.61 6.41,98.61 6.41,98.22 7.12,98.22 7.12,97.74 5.09,97.74 4.76,97.41 4.15,97.41 3.18,98.38 2.42,98.38 2.42,93.17 3.18,93.17 4.07,94.06 4.76,94.06 5.09,93.73 5.09,93.3 3.06,91.26 0.64,91.26 0.64,100.41 2.93,100.41
GND_QSFP_CAGE on TOP: 50.49,37.42 0.64,37.42 0.64,59.43 38.71,59.43 50.49,59.43 50.49,56.45 48.19,56.45 48.19,57.95 40.76,57.95 40.7,57.89 40.7,57.64 40.39,57.33 39.78,57.33 39.5,57.61 39.5,57.87 39.43,57.95 35.31,57.95 35.31,55.86 33.5,55.86 33.5,40.84 35.31,40.84 35.31,38.75 43.95,38.75 43.95,39.09 44.28,39.42 44.91,39.42 45.22,39.12 45.22,38.75 48.19,38.75 48.19,40.25 50.49,40.25
GND_QSFP_CAGE on BOTTOM: 4.33,55.07 7.12,55.07 7.37,55.32 7.37,57.1 4.58,57.1 4.33,56.85 ; 1 cut-out
GND_QSFPDD_CAGE on TOP: 36.39,15.48 0.64,15.48 0.64,37.09 36.39,37.09 36.39,33.66 34.39,33.66 34.39,19.46 36.39,19.46
GND_QSFPDD_CAGE on BOTTOM: 6.1,32.91 9.15,32.91 9.41,33.17 9.41,34.94 6.36,34.94 6.1,34.69 ; 1 cut-out
VBUS_5V on L16_SIG6: 2.67,97.23 3.39,96.52 7.91,96.52 11.59,92.84 23.58,92.84 24.52,93.78 24.52,95.58 24.01,96.09 13.09,96.09 9.02,100.15 3.56,100.15 2.67,99.27
VCCBAT on L03_SIG1: 91.07,69.42 91.57,69.42 93.23,71.07 105.19,71.07 107.64,69.67 110.5,69.67 120.02,79.33 121.76,79.33 122.39,79.71 124.21,79.71 130.06,73.87 161.04,73.87 162.06,74.88 169.81,74.88 170.06,75.14 170.06,76.79 169.55,77.29 160.28,77.29 159.01,76.02 134.37,76.02 133.74,75.39 129.8,75.39 124.24,80.95 122.13,80.95 122.03,80.85 118.6,80.85 109.82,71.84 109.49,71.84 108.97,71.33 107.32,71.33 105.29,72.6 91.57,72.6 90.81,71.83 90.81,69.67
VCCBAT on L07_SIG3: 218.19,67.39 218.19,68.4 217.69,68.91 204.1,68.91 202.19,70.82 185.05,70.82 179.84,76.02 169.43,76.02 169.04,75.64 169.04,74.5 169.43,74.12 179.46,74.12 184.79,68.79 189.87,68.79 190.89,67.77 202.32,67.77 203.21,66.88 217.69,66.88
VDD18_ZL30733 on BOTTOM: 71.25,58.24 71.25,56.24 70.44,55.43 70.44,54.89 70.24,54.69 70.24,52.2 69.81,51.77 69.81,49.99 69.58,49.76 69.58,47.83 70.01,47.4 70.01,45.6 69.7,45.29 68.84,45.29 68.84,45.8 69.35,45.8 69.35,46.31 68.84,46.31 68.84,46.69 69.1,46.69 69.1,46.92 68.76,47.25 68.76,50.35 69.07,50.65 69.07,52.68 68.89,52.86 68.89,56.26 70.24,57.61 70.24,58.24 ; 1 cut-out
VDD18_ZL30733 on L03_SIG1: 66.43,51.13 57.92,51.13 57.79,51.26 57.79,51.64 58.68,52.53 66.43,52.53 67.7,53.8 69.35,53.8 69.48,53.67 69.48,53.04 69.35,52.91 68.21,52.91
VDD33_ZL30733 on BOTTOM: 54.62,50.24 56.65,50.24 57.16,50.75 58.17,50.75 58.3,50.62 58.3,50.24 58.17,50.12 57.67,50.12 57.54,49.99 57.54,48.97 57.67,48.85 58.3,48.85 58.3,48.21 57.28,48.21 56.83,48.67 54.67,48.67 54.49,48.85 54.49,50.12
VDD33_ZL30733 on L03_SIG1: 57.64,47.22 57.82,47.04 67.95,47.04 69.1,48.19 69.1,52.17 68.84,52.43 68.28,52.43 66.61,50.75 57.82,50.75 57.64,50.57
VDD_ZL_OSC on BOTTOM: 57.68,56.66 57.79,56.77 57.79,57.08 57.64,57.23 54.11,57.23 54.11,55.32 54.62,55.32 55.4,56.11 55.4,56.37 55.7,56.66
(no net) on TOP: 193.81,80.34 190.38,80.34 190.25,80.47 190.25,88.47 190.51,88.72 192.92,88.72 193.17,88.47 193.17,83.9 193.94,83.14 193.94,80.47
(no net) on TOP: 53.73,71.58 53.73,66.25 53.98,65.99 58.81,65.99 59.06,66.25 59.06,74.12 58.68,74.5 57.28,74.5 56.7,75.09 51.39,75.09 51.19,74.88 51.19,72.85 51.82,72.21 53.09,72.21
(no net) on TOP: 244.23,94.69 244.23,80.34 243.59,79.71 238.77,79.71 237.85,80.63 227.65,80.63 227.46,80.82 227.46,82.9 227.59,83.03 227.59,84.28 226.96,84.28 226.96,84.79 226.96,84.79 227.46,84.79 227.46,96.47 228.35,97.36 241.56,97.36
(no net) on TOP: 13.22,98.5 12.2,98.5 12.07,98.63 12.07,100.03 14.87,100.03 14.87,99.01 13.72,99.01
(no net) on TOP: 146.95,20.31 142.72,20.31 142.12,20.91 137.68,20.91 137.17,20.4 137.17,18.37 141.1,18.37 141.45,18.71 145.19,18.71 145.19,17.12 144.91,16.84 144.91,16.08 146.44,16.08 146.95,16.59 ; 4 cut-outs
(no net) on TOP: 95.64,30.18 96.12,30.66 96.12,39.6 95.64,40.08 86.62,40.08 85.86,39.32 85.86,30.94 86.62,30.18
(no net) on TOP: 193.05,92.66 192.16,92.66 192.16,92.92 192.89,92.92 192.89,93.17 192.16,93.17 192.16,93.55 192.92,94.31 192.92,95.58 193.05,95.71 194.32,95.71 194.44,95.58 194.44,92.79 194.19,92.53 193.17,92.53
(no net) on TOP: 143.92,21.56 143.92,20.66 143.64,20.66 143.64,21.39 143.39,21.39 143.39,20.66 143,20.66 142.25,21.41 137.42,21.41 137.17,21.67 137.17,22.94 137.42,23.19 143.52,23.19 144.03,22.68 144.03,21.67
(no net) on TOP: 50.12,82.04 50.12,79.91 49.54,79.33 49.54,77.19 49.41,77.07 44.51,77.07 44.51,81.87 44.76,82.12 50.05,82.12
(no net) on TOP: 50.05,87.07 50.17,86.95 50.17,82.63 50.05,82.5 48.14,82.5 48.01,82.63 48.01,86.18 47.76,86.44 44.58,86.44 43.95,85.8 39.38,85.8 39.38,87.07
(no net) on TOP: 61.98,73.1 63.38,73.1 63.38,72.21 63.23,72.06 63.23,70.48 66.33,70.48 66.68,70.82 67.7,70.82 67.7,68.28 66.3,68.28 65.7,68.87 61.48,68.87 61.48,72.6 ; 4 cut-outs
(no net) on TOP: 170.31,86.82 170.57,87.07 180.35,87.07 180.73,86.69 180.73,85.29 181.41,84.61 181.41,78.99 180.98,78.56 178.57,78.56 177.43,79.71 170.7,79.71 170.31,80.09
(no net) on TOP: 52.08,86.06 52.08,82.63 52.2,82.5 55.13,82.5 55.89,81.74 61.48,81.74 61.73,81.99 61.73,84.91 61.48,85.17 56.14,85.17 55.13,86.18 52.2,86.18
(no net) on TOP: 64.52,67.64 64.52,68.52 64.78,68.52 64.78,67.8 65.03,67.8 65.03,68.52 65.42,68.52 66.17,67.77 67.7,67.77 67.83,67.64 67.83,66.88 67.7,66.75 64.65,66.75 64.4,67.01 64.4,67.52
(no net) on TOP: 177.55,74.25 170.7,74.25 170.31,73.87 170.31,68.15 170.7,67.77 180.98,67.77 181.74,68.53 181.74,71.45 182.51,72.21 182.51,76.66 182.25,76.91 178.7,76.91 178.32,76.53 178.32,75.01
(no net) on TOP: 170.31,79.07 170.31,75.01 170.57,74.75 177.3,74.75 177.93,75.39 177.93,76.66 178.57,77.29 186.57,77.29 186.82,77.55 186.82,77.93 186.57,78.18 178.44,78.18 177.3,79.33 170.57,79.33
(no net) on TOP: 48.27,66.25 48.01,65.99 42.43,65.99 42.17,66.25 42.17,74.25 42.43,74.5 43.95,74.5 44.51,75.06 44.51,75.09 49.21,75.09 49.41,74.88 49.41,72.47 49.16,72.21 48.65,72.21 48.27,71.83
(no net) on TOP: 64.52,70.94 64.52,72.21 64.65,72.34 66.05,72.34 66.43,72.72 66.43,73.1 66.56,73.23 69.74,73.23 69.83,73.14 69.83,69.39 69.73,69.29 68.46,69.29 68.21,69.55 68.21,70.94 67.83,71.33 66.68,71.33 66.18,70.82 65,70.82 65,71.55 64.78,71.55 64.78,70.94
(no net) on TOP: 50.55,87.07 54.24,87.07 55.76,88.6 61.48,88.6 61.73,88.34 61.73,86.06 61.48,85.8 56.52,85.8 55.89,86.44 52.08,86.44 51.82,86.18 51.82,82.63 51.7,82.5 50.55,82.5 50.43,82.63 50.43,86.95
(no net) on TOP: 194.83,77.55 194.83,73.87 195.46,73.23 196.1,73.23 196.35,72.98 196.35,72.21 197.37,71.2 197.37,66.75 196.86,66.25 194.32,66.25 193.94,66.63 193.94,73.23 194.16,73.46 194.16,76.05 193.94,76.28 190.38,76.28 190.25,76.41 190.25,77.55 190.38,77.68 194.7,77.68
(no net) on TOP: 50.48,82.04 50.48,79.91 51.19,79.2 51.19,77.19 51.32,77.07 56.09,77.07 56.09,80.77 54.74,82.12 50.55,82.12
(no net) on TOP: 189.75,77.93 187.46,77.93 186.82,78.56 183.78,78.56 183.61,78.73 183.61,84.49 184.03,84.91 189.36,84.91 189.87,84.41 189.87,78.06
(no net) on TOP: 30.49,98.88 29.85,98.25 29.85,95.84 30.11,95.58 32.14,95.58 32.39,95.84 32.39,98.25 32.01,98.63 32.01,101.58 33.94,101.58 34.04,101.68 34.58,101.68 34.58,103.13 34.27,103.43 31.22,103.43 30.49,102.69 ; 5 cut-outs
(no net) on TOP: 64.52,63.07 64.52,64.34 64.65,64.47 66.05,64.47 66.3,64.72 68.97,64.72 69.22,64.47 69.22,63.45 66.68,63.45 66.18,62.95 65,62.95 65,63.68 64.78,63.68 64.78,63.07
(no net) on TOP: 193.76,76.02 190.38,76.02 190.25,75.9 190.25,66.63 190.63,66.25 192.92,66.25 193.3,66.63 193.3,73.1 193.89,73.69 193.89,75.9
(no net) on TOP: 225.81,96.6 225.81,84.79 226.45,84.79 226.45,84.28 225.81,84.28 225.81,83.48 225.59,83.26 225.18,83.26 223.44,85.01 221.91,85.01 221.11,85.8 221.11,96.47 221.62,96.98 225.43,96.98
(no net) on TOP: 49.03,65.99 52.97,65.99 53.22,66.25 53.22,71.45 52.84,71.83 51.57,71.83 50.81,72.6 50.81,79.2 50.55,79.45 50.17,79.45 49.92,79.2 49.92,72.34 49.41,71.83 49.03,71.83 48.78,71.58 48.78,66.25
(no net) on TOP: 52.08,92.28 52.2,92.41 52.2,92.92 52.08,93.04 49.41,93.04 48.39,94.06 39.76,94.06 39.38,93.68 39.38,87.84 39.63,87.58 44.2,87.58 44.58,87.96 44.58,91.9 44.97,92.28
(no net) on TOP: 32.52,100.28 33.54,100.28 33.92,99.9 33.92,98.88 34.3,98.5 34.3,94.57 34.04,94.31 33.15,94.31 32.9,94.57 32.9,98.38 32.39,98.88 32.39,99.75 33.13,99.75 33.13,100.03 32.39,100.03 32.39,100.15
(no net) on TOP: 200.13,75.75 200.36,75.52 201.56,75.52 201.81,75.77 201.81,88.32 201.4,88.72 195.49,88.72 195.23,88.47 195.23,83.85 195.56,83.52 199.65,83.52 200.13,83.04
(no net) on TOP: 61.48,61 65.7,61 66.3,60.4 69.1,60.4 69.22,60.53 69.22,62.94 66.68,62.94 66.33,62.6 63.23,62.6 63.23,64.19 63.38,64.34 63.38,65.23 61.98,65.23 61.48,64.72 ; 4 cut-outs
(no net) on TOP: 30.11,100.28 30.11,100.03 29.37,100.03 29.37,99.77 30.11,99.77 30.11,99.01 29.34,98.25 29.34,96.85 29.22,96.73 28.18,96.73 28.07,96.83 28.07,99.65 28.71,100.28
(no net) on TOP: 69.86,79.07 69.86,82.37 69.48,82.76 68.59,82.76 66.17,85.17 62.77,85.17 62.24,84.64 62.24,74.87 62.73,74.37 67.19,74.37 67.7,74.88 67.7,78.31 68.08,78.69 69.48,78.69
(no net) on TOP: 189.75,92.66 188.35,92.66 186.95,94.06 186.95,96.85 187.21,97.11 189.36,97.11 189.36,94.31 189.87,93.8 189.87,93.2 189.14,93.2 189.14,92.92 189.87,92.92 189.87,92.79
(no net) on TOP: 64.52,59.77 64.52,60.64 64.78,60.64 64.78,59.92 65.03,59.92 65.03,60.65 65.42,60.65 66.17,59.9 67.93,59.9 68.05,59.77 68.05,59.01 67.93,58.88 64.65,58.88 64.4,59.13 64.4,59.64
(no net) on TOP: 194.83,78.06 194.7,77.93 190.38,77.93 190.25,78.06 190.25,79.96 190.38,80.09 193.94,80.09 194.19,80.34 194.19,83.39 193.56,84.03 193.56,88.72 194.83,88.72
(no net) on TOP: 191.78,89.74 191.78,93.8 192.41,94.44 192.41,96.85 192.16,97.11 189.87,97.11 189.87,94.31 190.25,93.93 190.25,91.37 188.63,91.37 188.35,91.65 187.59,91.65 187.59,90.38 188.22,89.74 ; 4 cut-outs
(no net) on TOP: 143.9,18.24 143.9,16.97 143.77,16.84 142.37,16.84 141.99,16.46 141.99,16.08 141.87,15.95 135.14,15.95 134.88,16.21 134.88,17.6 135.14,17.86 141.23,17.86 141.73,18.36 143.42,18.36 143.42,17.63 143.64,17.63 143.64,18.24
(no net) on TOP: 47.76,86.06 47.76,82.63 47.63,82.5 39.63,82.5 39.38,82.76 39.38,84.91 39.63,85.17 43.95,85.17 44.97,86.18 47.63,86.18
(no net) on TOP: 46.49,18.9 46.49,34.27 46.72,34.5 59.44,34.5 59.7,34.24 59.7,28.98 56.98,28.98 56.98,24.54 59.7,24.54 59.7,18.87 59.44,18.62 46.77,18.62 ; 3 cut-outs
(no net) on TOP: 189.8,77.63 187.43,77.63 186.72,76.91 184.03,76.91 183.78,76.66 183.78,72.34 184.03,72.09 189.36,72.09 189.87,72.6 189.87,77.55
(no net) on BOTTOM: 192.67,90.25 192.67,96.85 192.41,97.11 190.13,97.11 189.87,96.85 189.87,94.06 189.49,93.68 189.49,90.25 189.75,89.99 192.41,89.99
(no net) on BOTTOM: 13.98,61.29 13.98,65.36 13.34,65.99 13.34,70.94 13.6,71.2 15.88,71.2 15.88,65.86 15.5,65.48 15.5,62.92 17.13,62.92 17.41,63.2 18.17,63.2 18.17,61.67 17.79,61.29 ; 4 cut-outs
(no net) on BOTTOM: 36.33,104.73 36.33,100.66 37.6,99.39 38.49,99.39 38.49,95.46 38.36,95.33 36.2,95.33 35.95,95.58 35.95,99.39 35.57,99.77 35.06,99.77 34.81,100.03 34.81,103.08 33.28,103.08 33.15,102.95 32.39,102.95 32.39,104.09 32.57,104.27 33.97,104.27 34.42,104.73 ; 4 cut-outs
(no net) on BOTTOM: 54.49,74.25 54.49,66.5 54.74,66.25 59.82,66.25 60.21,66.63 60.21,70.69 59.32,70.69 58.68,71.33 58.68,74.25 58.43,74.5 54.74,74.5
(no net) on BOTTOM: 42.71,43.77 44,45.06 44,46.38 44.58,46.97 44.97,46.97 45.83,47.83 45.83,48.62 46.03,48.82 48.29,48.82 48.34,48.77 48.34,47.96 48.7,47.6 48.7,41.46 47.78,40.54 45.52,40.54 45.3,40.31 42.68,40.31 42.43,40.57 42.43,41.61 42.17,41.86 37.36,41.86 36.98,42.24 36.98,44.33 38.31,44.33 38.87,43.77 ; 3 cut-outs
(no net) on BOTTOM: 26.95,46.76 33.17,46.76 33.51,46.41 33.51,45.16 33.43,45.08 31.26,45.08 31.09,44.9 31.09,41.73 31.34,41.48 33.54,41.48 33.73,41.28 33.73,40.16 33.03,39.45 26.62,39.45 26.37,39.7 26.37,41.55 26.49,41.68 28.09,41.68 28.68,42.27 29.57,42.27 29.66,42.36 29.66,44.89 29.48,45.07 29.26,45.07 29.09,45.23 29.09,46.25 28.96,46.37 27.44,46.37 27.31,46.25 27.31,45.07 26.65,45.07 26.65,46.46 ; 7 cut-outs
(no net) on BOTTOM: 29.6,102.19 29.6,94.64 29.93,94.31 32.01,94.31 32.01,96.98 31.25,96.98 31,97.23 31,99.52 31.12,99.65 31.76,99.65 32.01,99.9 32.01,102.31 31.88,102.44 29.85,102.44
(no net) on BOTTOM: 146.18,20.4 137.55,20.4 137.17,20.02 137.17,19.13 137.55,18.75 142.88,18.75 143.64,17.99 146.18,17.99 146.44,18.24 146.44,20.14
(no net) on BOTTOM: 37.51,101.83 36.84,101.83 36.84,101.55 37.47,101.55 37.47,101.33 36.72,101.33 36.72,100.66 37.6,99.77 38.65,99.77 39,99.43 39,96.98 39.25,96.73 40.9,96.73 41.03,96.85 41.03,100.41 40.77,100.66 39.18,100.66 38.87,100.98 38.87,101.42 38.36,101.93 37.61,101.93
(no net) on BOTTOM: 37.12,49.17 43.03,49.17 43.31,49.46 45.17,49.46 45.5,49.13 45.5,48.11 45.16,47.77 43.06,47.77 42.74,47.45 38.79,47.45 38.62,47.27 37.12,47.27 36.99,47.4 36.99,49.04 ; 3 cut-outs
(no net) on BOTTOM: 12.69,64.19 13.58,64.19 13.58,64.47 12.86,64.47 12.86,64.72 13.59,64.72 13.59,65.11 12.83,65.86 12.83,67.13 12.71,67.26 11.44,67.26 11.31,67.13 11.31,64.34 11.56,64.09 12.58,64.09
(no net) on BOTTOM: 42.71,49.61 36.96,49.61 36.96,51.01 37.12,51.16 38.44,51.16 38.51,51.23 38.52,51.25 42.71,51.25 42.96,51 42.96,49.86 ; 2 cut-outs
(no net) on BOTTOM: 13.29,91.47 14.36,91.47 14.49,91.6 14.49,95.58 19.08,95.58 19.21,95.71 19.21,96.22 19.57,96.22 19.57,95.71 19.69,95.58 20.07,95.58 20.2,95.71 20.2,96.85 20.56,96.85 20.56,92.15 20.43,92.03 19.84,92.03 19.72,91.9 19.72,91.6 19.84,91.47 20.45,91.47 20.45,91.14 19.87,91.14 19.79,91.06 19.79,90.76 20,90.55 20,89.11 19.69,89.11 19.69,89.74 19.57,89.87 15.15,89.87 15.02,89.74 15.02,89.11 14.7,89.11 14.7,89.74 14.57,89.87 14.18,89.87 13.93,90.12 13.93,90.99 13.8,91.11 13.29,91.11 ; 3 cut-outs
(no net) on BOTTOM: 52.59,26.14 52.84,26.39 52.84,27.16 52.52,27.47 49.66,27.47 49.43,27.7 49.43,31.58 48.01,31.58 48.01,26.14
(no net) on BOTTOM: 29.28,42.58 28.28,42.58 28.01,42.31 26.52,42.31 26.5,42.34 26.5,44.18 26.62,44.3 27.51,44.3 28.22,43.6 29.28,43.6
(no net) on BOTTOM: 59.82,31.7 59.82,29.19 59.57,28.93 57.92,28.93 57.41,29.44 56.65,29.44 56.65,31.07 56.4,31.32 55.66,31.32 55.63,31.35 55.63,31.7 55.89,31.96 59.57,31.96 ; 2 cut-outs
(no net) on BOTTOM: 178.95,73.97 170.31,73.97 170.06,73.71 170.06,68.23 170.31,67.97 178.95,67.97 179.2,68.23 179.2,73.71
(no net) on BOTTOM: 50.3,87.96 50.55,87.96 50.55,87.58 50.05,87.07 50.05,85.17 50.3,84.91 52.33,84.91 52.46,85.04 52.46,85.55 52.71,85.8 54.36,85.8 54.49,85.68 54.49,85.17 55,84.66 60.97,84.66 61.22,84.41 61.22,71.45 60.97,71.2 59.44,71.2 59.19,71.45 59.19,74.5 58.68,75.01 53.98,75.01 53.73,74.75 53.73,66.5 53.47,66.25 48.52,66.25 48.27,66.5 48.27,74.5 47.89,74.88 42.55,74.88 42.17,74.5 42.17,72.47 41.03,71.33 41.03,67.64 40.77,67.39 39.12,67.39 38.87,67.64 38.87,74.88 39.12,75.14 39.76,75.14 40.52,74.37 40.9,74.37 41.03,74.5 41.03,74.88 41.41,75.26 41.41,79.96 41.66,80.22 47.12,80.22 47.76,80.85 47.76,85.65 49.31,87.2 49.54,87.2 ; 3 cut-outs
(no net) on BOTTOM: 33.54,101.81 34.3,101.81 34.41,101.69 34.41,101.55 33.69,101.55 33.69,101.27 34.42,101.27 34.42,99.78 35.44,98.76 35.44,94.57 35.31,94.44 34.04,94.44 33.79,94.69 33.79,98 32.9,98.88 32.9,101.17
(no net) on BOTTOM: 41.66,66.75 42.17,66.25 47.38,66.25 47.63,66.5 47.63,67.9 47.51,68.02 47.51,71.71 47.63,71.83 47.63,74.12 47.38,74.37 42.81,74.37 42.68,74.25 42.68,72.21 41.66,71.2
(no net) on BOTTOM: 194.32,94.19 193.05,94.19 192.92,94.31 192.92,95.58 193.05,95.71 194.32,95.71 194.44,95.58 194.44,94.31
(no net) on BOTTOM: 48.98,89.18 49.09,89.3 51.44,89.3 51.44,89.74 51.19,89.99 48.48,89.99 48.32,89.83 48.32,87.54 48.04,87.26 44.77,87.26 44.46,87.58 43.7,87.58 43.57,87.71 43.57,93.8 43.7,93.93 48.65,93.93 48.78,94.06 48.78,94.31 48.52,94.57 39.63,94.57 38.74,93.68 38.74,77.04 39,76.79 39,75.54 39.12,75.42 40.27,75.42 40.39,75.54 40.39,86.31 40.65,86.57 43.7,86.57 44.08,86.18 47.92,86.18 48.98,87.24 ; 1 cut-out
(no net) on BOTTOM: 217.18,54.43 217.06,54.32 217.06,48.73 216.92,48.59 210.19,48.59 209.68,49.1 209.68,54.05 209.18,54.56 203.21,54.56 202.32,55.45 202.32,75.9 204.22,77.8 217.69,77.8 218.07,77.42 218.07,72.85 218.19,72.72 218.19,70.18 217.81,69.8 217.05,69.8 215.27,68.02 215.27,58.37 215.91,57.74 216.8,57.74 217.18,57.36 ; 2 cut-outs
(no net) on BOTTOM: 179.05,87.28 170.42,87.28 170.16,87.02 170.16,80.35 170.42,80.1 179.05,80.1 179.31,80.35 179.31,87.02
(no net) on BOTTOM: 43.29,47.43 43.95,47.43 44,47.42 44,46.81 43.7,46.51 43.7,45.42 42.56,44.28 38.99,44.28 38.34,44.93 37.05,44.93 36.84,45.14 36.84,46.66 37,46.83 42.69,46.83 ; 5 cut-outs
(no net) on BOTTOM: 0.64,100.41 2.93,100.41 4.22,99.11 7.12,99.11 7.12,98.61 6.41,98.61 6.41,98.22 7.12,98.22 7.12,97.74 5.09,97.74 4.76,97.41 4.15,97.41 3.18,98.38 2.42,98.38 2.42,93.17 3.18,93.17 4.07,94.06 4.76,94.06 5.09,93.73 5.09,93.3 3.06,91.26 0.64,91.26
(no net) on BOTTOM: 61.98,63.32 65.54,63.32 65.92,62.94 67.44,62.94 67.7,62.69 67.7,61.04 67.95,61.04 67.95,60.66 67.32,60.66 66.81,60.15 62.24,60.15 61.73,60.66 61.73,63.07
(no net) on BOTTOM: 15.9,64.21 17.41,64.21 18.8,65.61 18.8,70.79 18.6,70.99 17.68,70.99 17.48,71.2 16.39,71.2 16.39,65.86 15.89,65.36 15.89,64.75 16.62,64.75 16.62,64.47 15.9,64.47 ; 1 cut-out
(no net) on BOTTOM: 195.66,77.93 195.66,77.54 195.08,77.54 194.9,77.71 194.9,77.93 194.77,78.06 193,78.06 192.62,77.68 192.62,75.95 192.92,75.64 193.25,75.64 193.38,75.52 193.38,75.14 193.5,75.01 193.89,75.01 194.01,74.88 194.01,73.87 193.76,73.61 192.87,73.61 192.49,73.23 192.49,66.25 192.36,66.12 190.71,66.12 188.55,68.28 185.88,68.28 183.22,65.61 170.52,65.61 170.26,65.86 170.26,67.21 170.52,67.47 179.46,67.47 179.84,67.85 179.84,74.09 179.46,74.48 170.31,74.48 170.06,74.73 170.06,79.2 170.31,79.45 179.59,79.45 179.97,79.83 179.97,87.3 179.59,87.68 170.42,87.68 170.16,87.94 170.16,89.74 170.54,90.12 183.22,90.12 183.34,89.99 183.34,87.33 183.6,87.07 188.42,87.07 188.93,86.57 188.93,80.85 189.44,80.34 193.38,80.34 194.27,79.45 194.27,78.95 194.52,78.69 194.9,78.69 ; 3 cut-outs
(no net) on BOTTOM: 55.38,25.25 55,24.87 55,23.89 54.71,23.6 53.6,23.6 53.6,23.19 53.25,22.84 51.3,22.84 50.67,22.2 50.67,20.51 51.01,20.17 59.19,20.17 59.44,20.42 59.44,24.62 58.81,25.25 ; 6 cut-outs
(no net) on BOTTOM: 137.65,21.67 141.87,21.67 142.12,21.92 142.12,22.68 141.87,22.94 137.65,22.94 137.4,22.68 137.4,21.92
(no net) on BOTTOM: 37.45,55.1 38.79,56.44 40.27,56.44 42.09,58.27 48.42,58.27 48.75,57.94 48.75,50.22 48.34,49.81 48.34,49.3 48.35,49.3 48.16,49.1 46,49.1 45.25,49.85 44.17,49.85 43.82,50.19 43.82,51.62 43.54,51.9 38.75,51.9 38.31,51.46 36.99,51.46 36.99,53.55 37.45,54 ; 5 cut-outs
(no net) on BOTTOM: 219.81,98.21 225.21,98.21 225.81,97.61 225.81,81.74 224.92,80.85 224.92,75.26 224.42,74.75 219.46,74.75 219.21,75.01 219.21,77.04 219.72,77.55 220.48,77.55 221.11,78.18 221.11,82.88 220.73,83.26 219.21,83.26 218.83,83.64 218.83,97.23
(no net) on BOTTOM: 67.83,63.45 68.08,63.2 68.08,61.67 68.46,61.29 68.46,60.02 69.73,58.75 71.51,58.75 72.02,59.26 72.02,61.55 71.51,62.05 70.62,62.05 70.11,62.56 70.11,64.85 69.48,65.48 60.21,65.48 59.19,64.47 59.19,60.05 59.34,59.9 60.84,59.9 60.97,60.02 60.97,64.09 61.22,64.34 65.41,64.34 66.3,63.45 ; 1 cut-out
(no net) on BOTTOM: 65.41,71.33 68.33,71.33 68.59,71.58 68.59,72.72 68.33,72.98 65.67,72.98 65.41,72.72
(no net) on BOTTOM: 34.17,53.93 36.2,53.93 36.46,53.67 36.46,42.34 36.13,42.01 32.87,42.01 32.39,42.5 31.48,42.5 31.48,42.93 32.21,42.93 32.21,43.23 31.48,43.23 31.48,43.61 32.31,43.61 32.49,43.79 33.72,43.79 33.92,43.99 33.92,53.67 ; 4 cut-outs
(no net) on BOTTOM: 67.57,67.77 66.56,67.77 66.3,67.52 66.3,67.01 66.56,66.75 67.57,66.75 67.83,67.01 67.83,67.52
(no net) on BOTTOM: 227.59,97.61 228.16,98.19 243.27,98.19 244.23,97.23 244.23,80.34 243.59,79.71 238.89,79.71 237.88,80.72 227.34,80.72 227.08,80.98 227.08,82.63 227.59,83.14 ; 6 cut-outs
(no net) on BOTTOM: 189.36,94.57 189.36,96.85 189.11,97.11 187.21,97.11 186.95,96.85 186.95,94.57 187.21,94.31 189.11,94.31
(no net) on BOTTOM: 175.48,49.65 175.78,49.35 182.76,49.35 183.4,49.99 183.4,55.58 182.77,56.2 175.69,56.2 175.48,55.99
(no net) on BOTTOM: 225.43,73.99 227.34,75.9 227.34,79.99 227.59,80.25 237.37,80.25 237.37,80.22 238.77,78.82 238.77,75.39 241.43,72.72 241.43,58.24 240.29,57.1 228.99,57.1 225.81,60.28 225.81,66.12 223.91,68.02 219.21,68.02 218.96,68.28 218.96,73.23 218.57,73.61 218.57,73.99 ; 1 cut-out
(no net) on BOTTOM: 48.32,25.76 48.06,25.49 48.06,22.64 48.39,22.3 50.26,22.3 51.3,23.35 52.36,23.35 53.12,24.11 54.62,24.11 54.62,25.12 55.25,25.76 59.06,25.76 59.32,26.01 59.32,26.77 59.06,27.03 53.98,27.03 52.71,25.76
(no net) on BOTTOM: 53.98,27.41 58.55,27.41 58.81,27.66 58.81,28.17 58.55,28.43 57.92,28.43 57.41,28.93 55.63,28.93 55.38,29.19 55.38,34.65 54.74,35.28 48.93,35.28 48.14,34.5 48.14,32.62 52.97,32.62 53.35,32.24 53.35,29.44 53.86,28.93 53.86,27.54
(no net) on BOTTOM: 50.43,31.98 52.46,31.98 53.09,31.35 53.09,28.17 52.84,27.92 52.15,27.92 51.98,28.1 50.17,28.1 49.79,28.48 49.79,31.35 ; 1 cut-out
(no net) on BOTTOM: 62.36,68.53 67.52,68.53 67.95,68.96 67.95,70.82 63.76,70.82 63.38,71.2 62.36,71.2 62.11,70.94 62.11,68.79
AUX_VDD_1V85 on TOP (solid shape): 225.53,78.97 225.53,78.54 224.29,77.29 224.29,76.66 224.16,76.53 223.53,76.53 223.53,78.06 224.04,78.06 224.71,78.73 224.71,78.99 224.8,79.07 225.43,79.07
FPGA_VCC on TOP: 79.69,92.71 133.66,92.71 134.25,93.3 146.82,93.3 147.12,92.99 147.12,35.69 146.69,35.26 141.74,35.26 140.7,36.3 109.96,36.3 109.74,36.53 109.74,37.49 109.48,37.75 108.31,37.75 108.06,37.49 108.06,36.53 107.93,36.4 104.66,36.4 103.1,37.95 101.4,37.95 101.1,38.25 101.1,39.96 100.51,40.54 83.01,40.54 82.68,40.21 82.68,37.92 82.56,37.8 81.8,37.8 81.67,37.92 81.67,40.21 81.16,40.72 79.38,40.72 77.63,42.47 77.63,90.66 ; 42 cut-outs
FPGA_VCC on BOTTOM: 107.32,56.19 107.55,56.42 107.55,66.17 107.42,66.3 105.67,66.3 105.54,66.17 105.54,59.06 105.14,58.65 105.14,57.58 105.06,57.51 104.93,57.51 104.76,57.33 104.76,56.39 104.96,56.19
FPGA_VCC on BOTTOM: 136.15,93.3 146.57,93.3 147.07,92.79 147.07,35.38 146.82,35.13 125.86,35.13 124.72,36.27 110.37,36.27 109.99,36.65 109.99,40.72 110.37,41.1 122.05,41.1 123.07,42.12 123.07,46 123.37,46.31 129.8,46.31 130.06,46.56 130.06,70.87 130.44,71.25 132.8,71.25 133.08,71.53 133.08,72.93 132.77,73.23 131.73,73.23 131.58,73.38 131.58,76.15 130.31,77.42 130.31,79.07 129.93,79.45 124.85,79.45 124.34,79.96 124.34,89.74 124.85,90.25 132.47,90.25 135.14,92.92 135.77,92.92 ; 12 cut-outs
FPGA_VCC on BOTTOM: 101.68,66.32 103.49,66.32 103.61,66.45 103.61,67.49 103.46,67.64 101.73,67.64 101.56,67.47 101.56,66.45
FPGA_VCC on BOTTOM: 95.05,57.08 95.66,57.08 96.4,57.81 96.4,58.09 96.78,58.47 96.78,59.57 96.4,59.95 96.4,64.19 96.2,64.39 94.57,64.39 94.37,64.19 94.37,57.76
FPGA_VCC on BOTTOM: 100.26,66.98 100.03,66.98 99.75,67.26 99.27,67.26 98.84,67.69 98.38,67.69 97.95,68.13 97.59,68.13 97.37,67.9 96.78,67.9 96.55,67.67 96.55,66.32 100.29,66.32 100.41,66.45 100.41,66.83
FPGA_VCC on L03_SIG1: 90.81,54.31 90.81,68.53 91.32,69.04 91.83,69.04 93.35,70.56 105.3,70.56 107.46,69.29 110.24,69.29 110.37,69.17 110.37,52.15 109.48,51.26 93.86,51.26
FPGA_VCC on L09_PWR1: 148.22,91.26 148.22,34.75 147.84,34.37 135.64,34.37 133.1,36.91 110.12,36.91 109.99,37.04 109.99,37.54 109.74,37.8 102.5,37.8 100.46,39.83 100.46,53.29 99.96,53.8 99.07,53.8 98.56,53.29 97.04,53.29 96.53,53.8 95.89,53.8 95.51,53.42 90.3,53.42 90.05,53.67 90.05,92.03 90.69,92.66 146.82,92.66
FPGA_VCC_GND on BOTTOM (solid shape): 183.4,55.58 183.4,49.99 182.76,49.35 175.78,49.35 175.48,49.65 175.48,55.75 175.48,55.99 175.63,56.14 175.65,56.13 175.71,56.12 175.78,56.11 175.9,56.14 176.01,56.2 182.77,56.2
FPGA_VCC_GND on L02_GND1: 171.84,61.42 171.84,57.23 175.78,57.23 176.41,56.59 176.41,50.88 178.7,48.59 178.7,45.54 187.84,45.54 187.84,59.26 180.6,59.26 180.35,59.52 180.35,60.15 179.08,61.42
FPGA_VCC_GND on L03_SIG1: 177.68,54.94 182.51,54.94 182.76,54.69 182.76,51.64 182.13,51.01 166,51.01 165.11,50.12 165.11,45.16 164.6,44.66 162.82,44.66 162.57,44.91 162.57,73.99 162.95,74.37 170.06,74.37 170.44,74.75 170.44,77.04 169.81,77.68 162.95,77.68 162.57,78.06 162.57,88.22 163.08,88.72 173.24,88.72 173.62,88.34 173.62,59.01
FPGA_VCC_HSSI_GXF on TOP: 147.12,24.08 146.87,23.83 137.93,23.83 136.91,24.84 136.91,34.37 137.29,34.75 146.87,34.75 147.12,34.5
FPGA_VCC_HSSI_GXF on BOTTOM: 147.07,22.68 146.82,22.43 143.29,22.43 142.4,23.32 137.93,23.32 137.43,23.82 137.43,24.58 136.74,25.28 136.74,29.52 136.96,29.75 139.76,29.75 141.76,31.75 141.76,34.6 141.92,34.75 146.82,34.75 147.07,34.5
FPGA_VCC_HSSI_GXF on BOTTOM: 74.68,71.81 74.89,72.01 74.89,73.03 74.43,73.48 74.43,74.63 74.94,75.14 75.57,75.14 75.83,75.39 75.83,76.53 74.3,76.53 73.41,75.64 73.41,72.6 74.2,71.81
FPGA_VCC_HSSI_GXF on BOTTOM: 102.3,61.17 103.05,61.17 103.22,61.34 103.22,62.6 102.19,62.6 102.19,61.28
FPGA_VCC_HSSI_GXF on BOTTOM: 101.51,57.74 102.88,57.74 103.13,57.99 103.13,58.7 102.88,58.96 101.99,58.96 101.89,59.06 100.08,59.06 99.98,58.96 99.07,58.96 98.81,58.7 98.81,57.99 99.22,57.58 101.35,57.58
FPGA_VCC_HSSI_GXF on BOTTOM: 98.99,61.27 99.75,61.27 99.88,61.39 99.88,62.46 99.75,62.59 98.99,62.59 98.86,62.46 98.86,61.39
FPGA_VCC_HSSI_GXF on L10_PWR2: 119.39,26.75 119.01,27.13 119.01,28.4 107.58,39.83 107.58,52.66 106.81,53.42 89.54,53.42 85.73,57.23 74.56,57.23 74.05,57.74 74.05,72.85 74.3,73.1 79.26,73.1 82.94,69.42 92.46,69.42 92.84,69.8 92.84,71.83 92.97,71.96 95,71.96 96.53,70.44 108.34,70.44 109.07,71.17 125.99,71.17 128.38,68.79 155.2,68.79 156.09,67.9 156.09,33.1 153.55,30.56 153.55,29.16 151.14,26.75 145.04,26.75 143.77,25.48 133.23,25.48 131.96,26.75
FPGA_VCC_HSSI_GXF on L14_SIG5: 92.74,65.54 87.38,62.45 86.21,62.31 84.18,60.28 74.18,60.28 73.72,59.82 73.72,56.24 74.4,55.55 78.14,55.55 78.75,54.94 84.84,54.94 86.62,53.16 102.75,53.16 103.89,54.31 103.89,67.26 103.23,67.92 95.52,67.92
FPGA_VCCA_PLL on TOP: 85.35,34.03 84.95,33.63 82.09,33.63 81.93,33.79 79.37,33.79 79,34.16 79,38.18 79.13,38.31 81.08,38.31 81.29,38.1 81.29,36.83 81.59,36.53 85.22,36.53 85.35,36.4
FPGA_VCCA_PLL on BOTTOM: 81.03,33.73 85.48,33.73 85.86,34.11 85.86,38.56 86.24,38.94 91.32,38.94 91.83,38.43 93.35,38.43 93.61,38.69 93.61,40.59 93.35,40.85 90.69,40.85 90.3,40.46 82.3,40.46 80.53,38.69 80.53,34.24
FPGA_VCCA_PLL on L07_SIG3: 106.86,73.18 107.2,72.85 107.2,69.9 105.67,68.79 105.67,49.86 107.32,48.21 107.32,33.23 104.53,30.43 96.65,30.43 93.73,27.51 82.1,27.51 80.27,29.34 80.27,34.85 81.95,36.53 83.57,36.53 83.93,36.88 83.93,39.33 84.34,39.74 85.19,39.74 85.78,40.34 87.26,40.34 88.55,41.63 88.55,44.76 88.15,45.16 88.15,50.88 87.64,51.39 87.64,54.82 85.89,56.56 85.89,70.85 86.49,71.45 94.5,71.45 96.27,73.23 97.29,73.23 98.18,72.34 99.32,72.34 100.16,73.18
FPGA_VCCCLK_GXF on BOTTOM: 63.38,95.96 64.4,94.95 64.4,85.8 64.02,85.42 62.11,85.42 62.11,90.71 59.19,93.63 59.19,97.11 59.32,97.23 60.71,97.23 60.84,97.36 60.84,98.38 59.7,99.52 59.7,101.93 59.19,102.44 59.19,103.96 59.7,103.96 59.7,103.33 59.82,103.2 62.24,103.2 63.38,102.06
FPGA_VCCCLK_GXF on BOTTOM: 80.01,62.92 81.8,64.47 84.84,64.47 85.61,63.71 87.26,63.71 89.54,65.23 89.54,67.77 87.89,69.42 77.35,69.42 76.46,68.53 76.46,65.86 76.21,65.61 74.73,65.61 74.35,65.99 74.18,65.99 73.97,65.79 73.97,65.51 74.43,65.05 74.48,65.05 74.68,64.85 74.68,63.45 76.46,63.45 76.97,62.94 76.97,55.32 76.72,55.07 72.14,55.07 71.76,54.69 71.76,52.02 72.78,52.02 73.41,52.66 73.41,53.55 79.13,53.55 80.02,54.44 ; 1 cut-out
FPGA_VCCCLK_GXF on L03_SIG1: 85.61,66.12 87.26,66.12 87.64,65.74 87.64,65.23 87.26,64.85 87.26,53.04 92.84,47.45 112.15,47.45 114.31,49.61 114.31,60.28 116.34,60.28 117.36,59.26 117.36,47.58 113.93,44.15 89.29,44.15 83.57,49.86 83.57,64.09
FPGA_VCCCLK_GXF on L07_SIG3: 114.43,58.63 134.5,58.63 134.63,58.75 134.63,60.28 134.25,60.66 115.7,60.66 114.31,59.26 114.31,58.75
FPGA_VCCERT_FGT_GXF on TOP (solid shape): 57.28,74.5 58.68,74.5 59.06,74.12 59.06,66.25 58.81,65.99 53.98,65.99 53.73,66.25 53.73,71.58 53.09,72.21 51.82,72.21 51.19,72.85 51.19,74.88 51.39,75.09 56.7,75.09
FPGA_VCCERT_FGT_GXF on BOTTOM (solid shape): 58.68,74.25 58.68,71.33 59.32,70.69 60.21,70.69 60.21,66.63 59.82,66.25 54.74,66.25 54.49,66.5 54.49,74.25 54.74,74.5 58.43,74.5
FPGA_VCCERT_FGT_GXF on L05_SIG2: 67.52,75.52 67.52,71.5 68.59,70.44 74.99,70.44 76.59,68.84 76.59,68.28 78.11,66.75 79,66.75 79.38,66.37 79.66,66.37 81.64,67.52 83.27,67.52 83.7,67.95 85.81,67.9 109.48,67.9 109.86,68.28 113.8,68.28 114.31,67.77 114.31,56.58 109.86,53.93 55.25,53.93 47.12,62.05 47.12,75.01 48.24,76.13 66.91,76.13
FPGA_VCCERT_FGT_GXF on L09_PWR1: 89.67,92.03 89.67,53.04 88.27,51.64 59.7,51.64 56.01,55.32 56.01,64.98 54.49,66.5 54.49,81.61 54.87,81.99 58.07,81.99 68.74,92.66 89.03,92.66
FPGA_VCCFUSEWR_GXF on TOP: 208.15,36.91 206.64,36.91 205.24,38.31 205.24,42.12 205.49,42.37 207.27,42.37 207.53,42.12 207.53,38.81 208.15,38.19 208.15,37.44 207.42,37.44 207.42,37.16 208.15,37.16
FPGA_VCCFUSEWR_GXF on BOTTOM: 207.4,39.45 207.4,41.35 207.14,41.61 205.49,41.61 205.24,41.35 205.24,39.45 205.49,39.19 207.14,39.19
FPGA_VCCFUSEWR_GXF on L03_SIG1: 88.15,66.25 89.8,66.25 90.43,65.61 90.43,54.18 93.99,50.62 109.61,50.62 110.75,51.77 110.75,60.4 111.51,61.17 113.42,61.17 113.93,60.66 113.93,49.99 111.89,47.96 92.97,47.96 87.64,53.29 87.64,64.72 88.02,65.1 88.02,66.12
FPGA_VCCFUSEWR_GXF on L07_SIG3: 111.51,60.28 111.51,64.26 113.16,65.92 113.16,69.04 113.8,69.67 151.77,69.67 162.19,59.26 195.59,59.26 207.53,47.32 207.53,39.45 207.02,38.94 204.73,38.94 204.1,39.58 204.1,41.23 193.81,51.51 146.31,51.51 136.79,61.04 115.58,61.04 113.39,58.85 112.94,58.85
FPGA_VCCH_FGT_GXF on TOP: 100.59,36.27 96.53,36.27 96.53,40.03 96.73,40.24 100.31,40.24 100.59,39.96
FPGA_VCCH_FGT_GXF on BOTTOM: 96.53,36.4 100.97,36.4 101.48,36.91 101.48,39.32 99.93,40.87 97.09,40.87 96.53,40.31
FPGA_VCCH_FGT_GXF on L16_SIG6: 115.2,69.67 115.83,69.04 115.83,55.59 118.54,54.88 122.31,52.52 122.31,44.02 121.88,43.37 115.2,39.19 101.11,39.22 99.84,38.56 96.3,38.56 95.69,37.95 91.19,37.95 90.58,38.56 80.53,38.56 79.76,39.32 79.76,43.13 80.31,43.68 85.99,47.06 85.99,51.37 85.35,51.73 85.35,63.27 85.99,63.66 85.99,65.74 87.76,67.52 96.53,67.52 98.36,65.68 98.36,52.98 98.94,52.4 102.88,52.4 103.51,53.04 103.51,64.59 108.59,69.67
FPGA_VCCH_SDM on TOP (solid shape): 69.83,73.14 69.83,69.39 69.73,69.29 68.46,69.29 68.21,69.55 68.21,70.94 67.83,71.33 66.68,71.33 66.18,70.82 65,70.82 65,71.55 64.78,71.55 64.78,70.94 64.54,70.94 64.54,71.56 64.53,71.6 64.52,71.64 64.52,72.21 64.65,72.34 66.05,72.34 66.43,72.72 66.43,73.1 66.56,73.23 69.74,73.23
FPGA_VCCH_SDM on BOTTOM (solid shape): 68.59,72.72 68.59,71.58 68.33,71.33 65.41,71.33 65.41,72.72 65.67,72.98 68.33,72.98
FPGA_VCCH_SDM on L05_SIG2: 77.73,69.63 77.73,69.29 78.49,68.53 80.37,68.53 81.56,69.41 83.05,69.41 84.34,70.69 91.32,70.69 91.96,71.33 92.59,71.33 92.84,71.07 92.84,69.55 91.62,68.33 83.47,68.33 83.04,67.9 81.1,67.9 79.92,66.96 78.54,66.96 76.97,68.53 76.97,69.04 75.19,70.82 68.84,70.82 67.93,71.73 67.93,73.1 68.33,73.51 73.85,73.51
FPGA_VCCIO_1V2 on TOP (solid shape): 180.73,86.69 180.73,85.29 181.41,84.61 181.41,78.99 180.98,78.56 178.57,78.56 177.43,79.71 170.7,79.71 170.31,80.09 170.31,86.82 170.57,87.07 180.35,87.07
FPGA_VCCIO_1V2 on BOTTOM (solid shape): 179.31,87.02 179.31,80.35 179.05,80.1 170.42,80.1 170.16,80.35 170.16,87.02 170.42,87.28 179.05,87.28
FPGA_VCCIO_1V2 on TOP: 194.16,105.23 194.16,103.81 193.89,103.53 191.85,103.53 191.65,103.33 191.27,103.33 191.27,105.11 191.4,105.23
FPGA_VCCIO_1V2 on TOP: 68.08,14.68 67.19,14.68 66.94,14.94 66.94,17.1 66.56,17.48 66.56,17.73 68.33,17.73 68.46,17.6 68.46,14.81 68.59,14.68 68.59,13.92 68.46,13.79 68.21,13.79 68.21,14.56
FPGA_VCCIO_1V2 on BOTTOM: 67.19,14.94 68.21,14.94 68.33,15.06 68.33,16.08 68.21,16.21 67.19,16.21 67.06,16.08 67.06,15.06
FPGA_VCCIO_1V2 on BOTTOM: 113.67,108.66 117.3,108.66 117.81,108.16 132.34,108.16 132.34,108.28 132.85,107.77 132.85,92.53 131.83,91.52 121.42,91.52 118.37,88.47 116.06,88.47 115.7,88.12 115.7,86.82 115.45,86.57 112.15,86.57 111.89,86.82 111.89,88.01 111.51,88.39 107.32,88.39 107.07,88.14 107.07,86.82 106.81,86.57 104.78,86.57 104.66,86.69 104.66,88.22 104.4,88.47 103.64,88.47 103.39,88.22 103.39,86.82 103.13,86.57 100.72,86.57 100.46,86.82 100.46,88.14 100.08,88.52 96.7,88.52 96.15,87.96 96.15,86.69 95.89,86.44 94.37,86.44 94.11,86.69 94.11,88.09 93.68,88.52 86.49,88.52 85.99,89.03 85.99,105.36 85.1,106.25 65.69,106.25 65.54,106.1 65.54,104.35 64.4,104.35 64.27,104.47 64.27,106.5 64.78,107.01 95.89,107.01 96.4,106.5 97.42,106.5 97.67,106.25 97.67,104.98 97.92,104.73 99.78,104.73 99.96,104.9 99.96,107.09 100.16,107.29 113.04,107.29 113.34,107.6 113.34,108.33 ; 36 cut-outs
FPGA_VCCIO_1V2 on L03_SIG1: 209.05,100.15 209.05,106.76 208.67,107.14 190,107.14 189.49,106.63 189.49,96.85 190,96.34 209.43,96.34 210.07,96.98 210.07,99.14
FPGA_VCCIO_1V2 on L09_PWR1: 63.05,27.89 92.59,27.89 92.84,27.64 123.83,27.64 131.71,19.76 131.71,18.37 129.29,15.95 122.92,15.95 121.77,14.81 66.17,14.81 65.16,15.83 49.16,15.83 47.12,13.79 44.33,13.79 41.44,13.49 40.08,10.92 40.08,5.77 34.62,5.77 34.62,14.02 13.73,14.02 13.73,5.77 1.28,5.77 1.28,60.53 2.04,61.29 15.76,61.29 16.14,60.91 16.14,56.09 19.31,52.91 29.85,52.91 32.65,55.7 35.24,55.7
FPGA_VCCIO_1V2 on L10_PWR2: 108.95,71.55 108.21,70.82 96.65,70.82 95.13,72.34 92.72,72.34 92.46,72.09 92.46,69.93 92.34,69.8 83.19,69.8 79.51,73.48 74.18,73.48 73.67,72.98 73.67,57.36 74.18,56.85 85.61,56.85 89.42,53.04 106.69,53.04 107.2,52.53 107.2,39.7 118.5,28.4 118.5,24.34 116.47,22.3 66.68,22.3 66.02,22.96 60.61,22.96 48.57,35 48.78,35 30.49,53.29 30.49,71.33 31,71.83 33.41,71.83 35.44,73.87 35.44,75.52 39.12,79.2 39.12,81.61 39.38,81.87 47.51,81.87 48.14,82.5 48.14,86.57 61.09,99.52 113.55,99.52 115.58,97.49 126.5,97.49 128.53,99.52 178.82,99.52 182.13,96.22 182.13,69.55 182,69.42 154.57,69.42 154.31,69.17 128.63,69.17 126.25,71.55
FPGA_VCCIO_1V2 on L12_SIG4: 170.06,78.56 180.09,78.56 180.73,79.2 180.73,88.34 181.24,88.85 184.16,88.85 188.22,92.92 188.22,99.27 190.25,101.3 196.86,101.3 197.75,102.19 197.75,108.54 196.6,109.68 180.22,109.68 176.16,105.62 176.16,95.07 174.51,93.42 172.35,93.42 169.3,90.38 169.3,79.33
FPGA_VCCIO_1V2 on L14_SIG5: 217.69,102.69 208.54,102.69 208.16,102.31 208.16,97.36 208.54,96.98 217.69,96.98 218.07,97.36 218.07,102.31
FPGA_VCCIO_1V2 on L16_SIG6: 127.9,27.64 122.82,27.64 122.18,27 111.13,27 110.62,26.49 110.62,23.35 111.03,22.94 129.55,22.94 129.95,23.35 129.95,25.58
FPGA_VCCIO_SDM_HPS on TOP: 198.37,36.91 196.86,36.91 195.46,38.31 195.46,42.12 195.71,42.37 197.49,42.37 197.75,42.12 197.75,38.81 198.37,38.19 198.37,37.44 197.64,37.44 197.64,37.16 198.37,37.16
FPGA_VCCIO_SDM_HPS on BOTTOM: 68.08,74.25 68.08,74.5 67.44,74.5 67.32,74.63 67.32,75.14 67.44,75.26 68.08,75.26 68.08,75.52 67.44,75.52 67.32,75.64 67.32,76.15 67.44,76.28 68.08,76.28 68.08,76.53 67.44,76.53 67.32,76.66 67.32,77.04 67.44,77.17 68.08,77.17 68.08,77.55 67.44,77.55 67.32,77.68 67.32,78.06 67.44,78.18 68.08,78.18 68.08,78.44 67.44,78.44 67.32,78.56 67.32,79.45 67.44,79.58 69.73,79.58 70.24,79.07 70.24,77.93 70.57,77.6 72.17,77.6 72.24,77.68 72.78,77.68 72.78,78.06 72.14,78.06 71.94,78.26 71.94,79.3 72.91,80.27 72.91,80.6 72.65,80.85 66.68,80.85 66.05,80.22 66.05,75.1 66.9,74.25
FPGA_VCCIO_SDM_HPS on BOTTOM: 12.96,52.38 12.96,52.89 13.09,53.01 14.23,53.01 14.36,52.89 14.36,52.38 14.23,52.25 13.09,52.25
FPGA_VCCIO_SDM_HPS on BOTTOM: 25.34,53.04 25.34,51.77 25.47,51.64 26.49,51.64 26.61,51.77 26.61,53.04 26.49,53.16 25.47,53.16
FPGA_VCCIO_SDM_HPS on BOTTOM: 12.96,54.41 12.96,54.92 13.09,55.04 14.23,55.04 14.36,54.92 14.36,54.41 14.23,54.28 13.09,54.28
FPGA_VCCIO_SDM_HPS on BOTTOM: 13.85,32.34 13.98,32.46 15.25,32.46 15.37,32.34 15.37,31.07 15.25,30.94 13.98,30.94 13.85,31.07
FPGA_VCCIO_SDM_HPS on L05_SIG2: 218.32,67.64 218.32,69.04 217.94,69.42 217.18,69.42 215.91,68.15 194.32,68.15 191.78,65.61 191.78,63.96 192.03,63.71 192.67,63.71 193.94,64.98 196.98,64.98 198.51,66.5 217.18,66.5
FPGA_VCCIO_SDM_HPS on L07_SIG3: 193.56,51.13 145.68,51.13 138.56,58.24 113.01,58.24 111.13,60.12 111.13,64.42 112.78,66.07 112.78,76.79 111.54,78.03 104.86,78.03 102.62,76.91 101.49,76.91 100.52,76.47 99.54,75.88 99.23,75.88 97.03,77.17 92.59,77.17 90.05,74.63 90.05,72.32 90.53,71.83 94.24,71.83 96.15,73.74 97.42,73.74 98.43,72.72 99.32,72.72 100.16,73.56 107.04,73.56 107.58,73.03 107.58,69.7 106.05,68.58 106.05,51.89 106.38,51.56 107.65,51.56 108.01,51.21 114.41,51.21 115.48,52.28 119.36,52.28 120.38,51.26 125.61,51.26 133.23,43.64 193.68,43.64 194.62,42.7 194.62,39.65 195.71,38.56 196.86,38.56 199.7,41.4 199.7,44.99
FPGA_VCCIO_SDM_HPS on L10_PWR2: 44.33,13.8 41.44,13.49 40.08,10.92 40.08,5.77 34.62,5.77 34.62,14.02 13.73,14.02 13.73,5.77 1.27,5.77 1.27,55.95 1.28,55.96 1.28,60.53 2.04,61.29 29.22,61.29 29.73,60.78 29.73,53.29 60.46,22.56 65.79,22.56 66.43,21.92 116.72,21.92 118.88,24.08 118.88,26.11 119.13,26.37 131.45,26.37 132.72,25.1 144.03,25.1 145.3,26.37 151.39,26.37 154.06,29.03 154.06,30.43 156.73,33.1 166.63,33.1 168.28,34.75 168.28,39.32 169.17,40.21 193.05,40.21 194.95,42.12 218.57,42.12 219.46,41.23 219.46,19.89 218.32,18.75 132.09,18.75 129.29,15.95 124.21,15.95 121.04,12.78 65.92,12.78 62.87,15.83 49.16,15.83 47.13,13.8
FPGA_VCCIO_SDM_HPS on L14_SIG5: 94.24,71.93 94.24,73.1 90.88,76.47 85.14,76.47 84.44,77.17 79.88,77.17 76.45,80.6 72.52,80.6 72.4,80.47 72.4,79.8 72.79,79.4 75.5,79.4 79.21,75.69 83.25,75.69 84.64,74.31 87.45,74.31 88.53,73.23 89.16,73.23 90.56,71.83 92.34,71.83 92.43,71.74 94.06,71.74
FPGA_VCCIO_SDM_HPS on L14_SIG5: 198,39.58 198,50.37 196.73,51.64 196.73,55.83 198.76,57.86 198.76,63.71 196.22,66.25 192.92,66.25 192.16,65.48 192.16,63.71 192.67,63.2 195.46,63.2 196.1,62.56 196.1,61.29 192.16,57.36 192.16,47.45 195.71,43.89 195.71,39.45 195.97,39.19 197.62,39.19
FPGA_VCCIO_SDM_HPS on L16_SIG6: 247.4,45.93 247.4,53.42 248.04,54.05 250.32,54.05 250.71,53.67 250.71,43.39 240.93,33.61 220.61,33.61 215.4,38.81 196.48,38.81 195.71,39.58 195.71,41.73 196.1,42.12 218.45,42.12 223.08,37.48 234.39,37.48 235.08,36.78 238.26,36.78
FPGA_VCCPLL on BOTTOM: 89.69,72.49 89.69,72.14 90.33,71.5 90.96,71.5 91.14,71.33 91.42,71.33 91.62,71.42 91.62,71.83 91.36,72.25 90.34,72.8 90,72.8
FPGA_VCCPLL on BOTTOM: 90.56,70.44 90.91,70.44 91.14,70.29 91.14,68.61 90.81,68.28 90.3,68.28 90.1,68.48 90.1,69.7
FPGA_VCCPLL on BOTTOM: 69.98,72.98 72.52,72.98 72.78,73.23 72.78,75.39 72.52,75.64 70.11,75.64 69.98,75.52
FPGA_VCCPLL on BOTTOM: 110.24,54.56 111.26,54.56 111.39,54.69 111.64,54.43 111.64,53.42 111.26,53.42 111.01,53.67 110.5,53.67 110.24,53.93
FPGA_VCCPLL on L12_SIG4: 71.05,75.49 75.15,75.49 75.89,75.04 75.89,73.83 76.31,73.83 76.31,73.67 78.12,73.67 85.29,69.28 86.91,69.44 90.77,72.09 109.86,72.09 111.13,70.82 111.13,65.99 107.32,63.58 107.32,57.48 109.66,55.15 110.19,55.15 111.01,54.33 111.01,53.65 110.4,53.04 108.72,53.04 108.21,53.55 108.21,54.31 107.45,55.07 107.07,55.07 105.93,56.21 105.93,64.19 109.74,66.35 109.74,70.06 109.23,70.56 106.38,70.56 104.76,69.22 103.72,69.22 102.75,70.18 102.06,70.18 101.94,70.31 91.7,70.31 87.47,67.77 85.62,67.77 81.08,70.56 79.47,70.56 77.63,71.66 75.37,71.66 74.81,72.21 74.05,72.21 73.03,73.23 71,73.23 70.62,73.61 70.62,75.06
FPGA_VCCPLLDIG_HPS on TOP: 81.92,37.42 81.92,36.91 82.05,36.78 83.45,36.78 83.57,36.91 83.57,37.29 83.45,37.42
FPGA_VCCPLLDIG_HPS on L07_SIG3: 83.57,37.04 83.57,37.54 83.32,37.8 81.29,37.8 78.37,34.88 78.37,28.02 82.07,24.31 94.47,24.31 98.23,28.07 106.71,28.07 110.88,32.24 110.88,49.61 111.82,50.55 111.82,52.91 111.31,53.42 110.37,53.42 110.32,53.37 110.32,50.96 109.48,50.12 109.48,32.41 105.85,28.78 97.42,28.78 94.11,25.48 83.42,25.48 79.89,29.01 79.89,35.03 81.77,36.91 83.45,36.91
FPGA_VCCPLLDIG_SDM on BOTTOM: 89.82,73.59 91.07,73.59 91.62,73.03 91.62,72.26 92.27,71.73 92.37,71.74 94.34,73.61 94.34,76.2 90.96,79.58 75.19,79.58 75.06,79.45 75.06,78.82 74.56,78.31 74.56,77.19 76.31,77.19 78.37,75.14 88.27,75.14 ; 3 cut-outs
FPGA_VCCPT on TOP (solid shape): 182.51,76.66 182.51,72.65 182.51,72.21 181.74,71.45 181.74,68.53 180.98,67.77 170.7,67.77 170.31,68.15 170.31,73.87 170.7,74.25 177.55,74.25 178.32,75.01 178.32,76.53 178.7,76.91 182.25,76.91
FPGA_VCCPT on BOTTOM (solid shape): 179.2,73.71 179.2,68.23 178.95,67.97 170.31,67.97 170.06,68.23 170.06,73.71 170.31,73.97 178.95,73.97
FPGA_VCCPT on TOP: 100.59,35.77 100.59,33.35 100.34,33.1 98.18,33.1 97.92,33.35 97.92,35.64 98.05,35.77
FPGA_VCCPT on TOP: 210.46,36.91 210.46,37.16 211.18,37.16 211.18,37.42 210.45,37.42 210.45,38.44 211.08,39.07 211.08,42.09 211.34,42.34 212.99,42.34 213.24,42.09 213.24,37.29 212.86,36.91
FPGA_VCCPT on TOP: 217.43,22.94 218.47,22.94 218.73,22.68 218.73,19.38 218.47,19.13 218.25,19.13 218.25,19.81 217.62,19.81 217.62,19.13 217.43,19.13 217.18,19.38 217.18,22.68 ; 1 cut-out
FPGA_VCCPT on TOP: 200.03,26.49 202.83,26.49 202.95,26.62 202.95,30.3 202.7,30.56 199.65,30.56 199.4,30.3 199.4,27.13 ; 7 cut-outs
FPGA_VCCPT on BOTTOM: 71,76.15 71,77.17 70.82,77.35 69.45,77.35 69.32,77.22 69.32,75.8 69.43,75.69 69.68,75.69 69.83,75.85 69.83,76 69.98,76.15
