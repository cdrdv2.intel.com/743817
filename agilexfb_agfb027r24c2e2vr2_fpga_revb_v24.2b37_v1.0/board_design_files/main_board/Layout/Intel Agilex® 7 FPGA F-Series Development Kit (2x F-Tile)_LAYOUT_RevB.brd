# Allegro board Intel Agilex® 7 FPGA F-Series Development Kit (2x F-Tile)_LAYOUT_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EN_G2: length 313.3
  TOP w0.149: v1(32.18,68.65) 32.18,67.94 30.74,66.5 29.22,66.5 26.17,63.45 19.82,63.45 16.52,60.15 14.23,60.15 v1(13.98,59.9)
  L03_SIG1 w0.081: v1(200.29,84.09) 200.73,84.53 202.57,84.53 v1(203.08,84.03)
  L05_SIG2 w0.081: v1(13.98,59.9) 13.98,58.32 14.27,58.03 14.27,55.8 14.59,55.49 14.59,54.41 14.23,54.05 14.23,53.32 14.59,52.97 14.59,51.16 15.2,50.55 15.2,43.96 14.75,43.51 14.75,40.09 14.28,39.63 14.28,38.33 15.7,36.91 15.7,30.74 15.83,30.61 16.36,30.61 16.64,30.32 16.64,29.86 17.01,29.5 17.01,29.2 19.16,27.06 24.42,27.06 24.71,27.35 32.25,27.35 33.42,26.17 33.42,25.72 34.15,24.99 41.84,24.99 42.28,24.54 46,24.54 47.89,22.65 47.89,18.89 48.73,18.06 57.41,18.06 58.43,17.04 60.71,17.04 61.97,15.78 63.03,15.78 64.06,14.75 64.78,14.75 65.18,14.35 65.18,13 66.25,11.93 79.95,11.93 80.15,12.13 82.45,12.13 82.7,12.38 126.04,12.38 127.34,13.68 132.48,13.68 135.64,16.84 135.82,16.84 136.01,17.03 136.01,17.84 136.33,18.16 146.9,18.16 147.54,17.52 165.96,17.52 166.91,18.47 166.91,22.2 168.79,24.08 168.79,25.3 171.28,27.79 171.28,29.49 171.97,30.18 172.47,30.18 173.49,31.19 179.2,31.19 180.86,32.84 180.86,37.16 179.84,38.18 179.84,44.91 180.59,45.66 180.59,48.33 181.24,48.97 182.51,48.97 184.42,50.88 184.42,53.81 186.76,56.15 187.9,56.15 v1(188.35,56.59)
  BOTTOM w0.149: R73.2 31.88,68.36 v1(32.18,68.65) ; v1(188.35,56.59) 189.03,57.27 189.03,57.65 191.4,60.02 196.35,60.02 201.18,64.85 201.18,75.77 202.67,77.27 202.67,83.62 v1(203.08,84.03)
EN_G3: length 351.4
  TOP w0.254: v1(201.81,36.03) U74.7
  L05_SIG2 w0.081: v1(201.81,36.03) 204.56,36.03 205.64,34.95 205.64,32.59 206.29,31.93 207.78,31.93 208.8,30.92 209.59,30.92 212.54,27.97 212.54,24.75 213.01,24.28 213.01,21.44 v1(211.84,20.27)
  L07_SIG3 w0.089: v1(36.9,75.39) 37.41,75.9 38.74,75.9 39.38,76.53 39.38,80.47 38.74,81.1 38.74,89.49 39.53,90.27 v1(40.77,90.27)
  L12_SIG4 w0.089: v1(27.18,73.65) 27.65,73.18 27.65,71.6 28.63,70.61 28.63,66.63 32.34,62.92 32.34,57.64 33.43,56.54 33.43,54.07 35.93,51.57 35.93,50.46 39.4,46.99 39.63,46.99 41.22,45.41 42.06,45.41 44.56,42.9 45.12,42.9 45.37,43.16 45.83,43.16 47.12,41.86 48.11,41.86 48.27,41.71 57.77,41.71 58.25,41.23 58.73,41.23 59,40.96 60.09,40.96 66.02,35.03 66.02,29.21 70.39,24.84 71.41,24.84 71.93,24.32 71.93,19.45 74.58,16.79 78.44,16.79 78.71,16.53 86.56,16.53 86.9,16.87 88.22,16.87 89.01,16.08 117.18,16.08 117.74,16.64 129.65,16.64 130.72,17.71 130.72,19.15 130.54,19.33 130.54,20.12 130.75,20.33 131.09,20.47 131.28,20.65 131.28,24.11 134.06,26.89 143.08,26.89 144.46,25.5 145.4,25.5 145.8,25.1 145.8,24.69 147.53,22.96 150.38,22.96 151.65,21.69 159.01,21.69 161.7,19 168.33,19 171.58,15.75 208.43,15.75 211.84,19.16 v1(211.84,20.27)
  L14_SIG5 w0.081: v1(201.16,77.8) 201.43,77.54 201.43,75.59 200.84,75.01 199.45,75.01 199.24,74.81 199.24,73.13 199.78,72.6 199.78,66.25 202.9,63.12 202.9,41.63 203.56,40.97 203.56,37.78 v1(201.81,36.03)
  L16_SIG6 w0.081: v1(40.77,90.27) 44.23,90.27 44.66,90.71 46.9,90.71 47.68,91.49 49.66,91.49 50.3,92.13 v1(50.3,93.41)
  BOTTOM w0.149: v1(50.3,93.41) 50.3,92.98 R852.1 ; v1(27.18,73.65) 27.65,74.12 29.42,74.12 30.44,75.14 33.54,75.14 34.3,75.9 36.39,75.9 v1(36.9,75.39)
EXT_JTAG_TCK: length 43.8
  L12_SIG4 w0.089: v1(25.15,97.61) 27.9,94.86 29.1,94.86 29.85,94.11 29.85,89.36 33.68,85.53 33.68,82.15 v1(34.18,81.65)
  L16_SIG6 w0.081: v1(16.9,106.7) 18.37,105.22 18.37,100.13 19.15,99.35 19.89,99.35 21.11,98.13 24.64,98.13 v1(25.15,97.61)
  BOTTOM w0.149: v1(25.15,97.61) 25.4,97.37 25.65,97.37 25.95,97.07 U6.1 ; v1(16.9,106.7) 15.88,105.68 15.88,101.93 J3.1
EXT_JTAG_TDI: length 42.3
  L12_SIG4 w0.089: v1(28.71,94.44) 28.71,91.35 28.57,91.21 28.38,91.21 28.24,91.35 28.24,92.27 28.1,92.41 27.91,92.41 27.77,92.27 27.77,90.58 32.68,85.66 32.68,82.14 v1(33.18,81.65)
  L16_SIG6 w0.081: J3.9 28.56,101.91 28.56,102.86 v1(30.49,104.79) 31,104.28 31,103.2 30.23,102.44 30.23,100.62 30.14,100.54 29.81,100.54 29.73,100.62 29.73,102.73 29.64,102.82 29.31,102.82 29.22,102.73 29.22,100.28 29.85,99.65 29.85,94.82 29.47,94.44 v1(28.71,94.44)
  BOTTOM w0.149: v1(28.71,94.44) 28.42,94.73 28.42,94.99 28.17,95.24 U6.8
EXT_JTAG_TDO: length 43.4
  L12_SIG4 w0.089: v1(26.04,94.06) 26.78,93.32 26.78,89.39 28.2,87.96 29.22,87.96 29.85,87.33 29.85,86.31 31.68,84.49 31.68,81.55 32.07,81.15 33.68,81.15 v1(34.18,80.65)
  L16_SIG6 w0.081: v1(18.93,106.7) 20.94,104.69 20.94,99.8 21.94,98.79 24.87,98.79 25.59,98.07 25.59,97.18 26.04,96.73 v1(26.04,94.06)
  BOTTOM w0.149: v1(18.93,106.7) 18.42,106.19 18.42,101.93 J3.3 ; v1(26.04,94.06) 26.35,94.37 U6.11
EXT_JTAG_TMS: length 43.5
  L12_SIG4 w0.089: v1(34.18,82.65) 34.18,83.02 34.55,83.39 34.55,83.9 34.17,84.28 34.17,86.52 30.53,90.15 30.53,94.8 28.76,96.58 28.07,96.58 27.15,97.5 v1(27.15,98.5)
  L16_SIG6 w0.081: v1(20.96,106.7) 23.43,104.23 23.43,99.9 23.93,99.39 28.7,99.39 28.84,99.25 28.84,98.88 28.71,98.76 28.07,98.76 27.82,98.5 v1(27.15,98.5)
  BOTTOM w0.149: J3.5 20.96,101.93 v1(20.96,106.7) ; v1(27.15,98.5) U6.4
EXT_PROC_RSTN: length 51.6
  TOP w0.149: R847.2 26.68,98.06 26.68,99.27 26.04,99.9 26.04,101.3 25.41,101.93 23.5,101.93 22.23,103.2
  L05_SIG2 w0.081: v1(34.18,79.65) 34.67,80.15 34.67,80.78 35.05,81.15 38.07,81.15 39.01,82.09 39.01,92.19 37.42,93.77 35.31,93.77 35.16,93.92 31.49,93.92 29.47,95.94 29.47,103.2 27.95,104.73 23.76,104.73 22.23,103.2
F_CLK_FPGA_100M_N: length 42.2
  L03_SIG1 w0.079: 83.53,72.43 83.51,72.43 83.49,72.44 83.17,72.44 83,72.62 82.54,72.62 82.42,72.69 82.3,72.9 82.11,73.07 80.89,73.57 80.77,73.68 80.66,73.86 80.42,74 80.13,74 79.82,73.83 79.71,73.64 79.57,73.55 78.82,73.55 77.32,74.17 76.47,74.17 v1(76.14,74.5)
  L03_SIG1 w0.081: v1(108.14,73.89) 108.37,73.76 108.4,73.61 108.32,73.53 107.52,73.53 106.86,74.19 106.86,74.31 106.93,74.38 106.93,74.48 106.8,74.61 106.69,74.61 106.62,74.54 106.5,74.54 106.23,74.82 arc(106.09,74.91) 105.92,74.95 arc(105.78,74.96) 105.65,74.98 arc(105.61,74.99) 105.58,75 arc(105.4,75.05) 105.22,75.1 arc(104.99,75.21) 104.78,75.36 arc(104.7,75.45) 104.63,75.55 arc(104.45,75.76) 104.18,75.83 arc(103.99,75.87) 103.85,76.01 arc(103.66,76.22) 103.38,76.3 arc(103.17,76.26) 102.99,76.14 arc(102.9,76.02) 102.82,75.89 arc(102.55,75.72) 102.29,75.92 arc(102.09,76.18) 101.78,76.29 101.76,76.29 arc(101.6,76.34) 101.48,76.47 arc(101.31,76.68) 101.05,76.75 100.91,76.75 arc(100.7,76.7) 100.53,76.56 100.4,76.38 arc(100.35,76.32) 100.27,76.3 100.17,76.3 arc(100.01,76.33) 99.88,76.45 arc(99.66,76.66) 99.37,76.75 arc(99.1,76.68) 98.89,76.49 arc(98.77,76.36) 98.59,76.3 arc(98.43,76.33) 98.31,76.44 arc(98.1,76.66) 97.82,76.75 arc(97.52,76.68) 97.29,76.48 arc(97.16,76.35) 96.98,76.3 arc(96.81,76.34) 96.69,76.46 arc(96.48,76.67) 96.2,76.75 arc(95.91,76.68) 95.7,76.47 arc(95.58,76.34) 95.41,76.29 arc(95.23,76.34) 95.1,76.46 arc(94.89,76.67) 94.6,76.75 arc(94.31,76.67) 94.1,76.46 arc(93.97,76.33) 93.81,76.28 arc(93.64,76.32) 93.52,76.45 arc(93.31,76.67) 93.02,76.75 arc(92.71,76.67) 92.49,76.45 arc(92.37,76.35) 92.22,76.31 arc(92.04,76.35) 91.91,76.47 arc(91.69,76.67) 91.41,76.75 arc(91.13,76.68) 90.92,76.47 arc(90.8,76.34) 90.63,76.29 arc(90.45,76.34) 90.32,76.46 arc(90.11,76.67) 89.82,76.75 arc(89.53,76.67) 89.31,76.46 arc(89.19,76.33) 89.03,76.28 arc(88.86,76.32) 88.74,76.45 arc(88.53,76.67) 88.24,76.75 arc(87.93,76.67) 87.71,76.45 arc(87.6,76.34) 87.46,76.31 arc(87.16,76.23) 86.94,76.01 arc(86.81,75.88) 86.63,75.83 arc(86.35,75.76) 86.15,75.55 arc(86.02,75.41) 85.84,75.37 arc(85.66,75.34) 85.5,75.26 arc(85.29,74.92) 85.33,74.53 arc(85.38,74.37) 85.36,74.2 arc(85.25,74.05) 85.07,74 arc(84.84,73.96) 84.65,73.83 arc(84.48,73.51) 84.53,73.16 arc(84.57,73.04) 84.58,72.92 arc(84.48,72.7) 84.25,72.61 83.97,72.61 83.79,72.43 83.53,72.43
  BOTTOM w0.102: v1(108.14,73.89) 108.46,74.44 R6841.1
F_CLK_FPGA_100M_P: length 42.1
  L03_SIG1 w0.079: v1(76.14,73.61) 76.47,73.94 77.28,73.94 78.77,73.32 79.63,73.32 79.88,73.47 79.99,73.66 80.19,73.77 80.36,73.77 80.5,73.7 80.59,73.53 80.77,73.37 81.99,72.87 82.12,72.75 82.25,72.53 82.48,72.39 82.9,72.39 83.08,72.22 83.49,72.22 83.51,72.23 83.53,72.23
  L03_SIG1 w0.081: v1(108.94,73.43) 108.72,73.56 108.59,73.52 108.4,73.33 107.44,73.33 106.09,74.68 arc(106.01,74.73) 105.92,74.75 105.91,74.75 arc(105.76,74.76) 105.61,74.79 arc(105.57,74.8) 105.53,74.81 arc(105.34,74.86) 105.16,74.92 arc(104.89,75.04) 104.65,75.21 arc(104.54,75.33) 104.46,75.47 arc(104.35,75.59) 104.19,75.63 arc(103.89,75.7) 103.68,75.92 arc(103.55,76.05) 103.38,76.1 103.38,76.1 arc(103.24,76.07) 103.13,76 103.13,76 arc(103.06,75.91) 103,75.82 arc(102.54,75.53) 102.11,75.85 arc(101.98,76.03) 101.78,76.09 101.76,76.09 arc(101.49,76.18) 101.3,76.4 arc(101.2,76.51) 101.05,76.56 100.91,76.56 arc(100.79,76.53) 100.69,76.44 100.56,76.26 arc(100.44,76.15) 100.28,76.11 100.18,76.1 arc(99.92,76.16) 99.72,76.35 arc(99.57,76.49) 99.36,76.55 arc(99.19,76.51) 99.06,76.39 arc(98.87,76.2) 98.62,76.1 arc(98.34,76.15) 98.14,76.35 arc(98,76.49) 97.81,76.55 arc(97.61,76.51) 97.46,76.37 arc(97.25,76.18) 96.99,76.11 arc(96.72,76.17) 96.52,76.36 arc(96.38,76.5) 96.19,76.55 arc(96.01,76.51) 95.87,76.37 arc(95.68,76.17) 95.41,76.1 arc(95.14,76.16) 94.93,76.37 arc(94.79,76.51) 94.6,76.56 94.6,76.56 arc(94.41,76.51) 94.26,76.36 arc(94.08,76.17) 93.82,76.09 arc(93.54,76.15) 93.35,76.36 arc(93.21,76.5) 93.02,76.56 93.02,76.56 arc(92.81,76.5) 92.66,76.35 arc(92.65,76.34) 92.65,76.33 arc(92.46,76.17) 92.22,76.11 arc(91.95,76.18) 91.75,76.37 arc(91.6,76.5) 91.41,76.55 arc(91.23,76.51) 91.09,76.38 arc(90.9,76.18) 90.63,76.1 arc(90.35,76.16) 90.15,76.37 arc(90.01,76.51) 89.82,76.56 arc(89.63,76.51) 89.48,76.36 arc(89.3,76.17) 89.04,76.09 arc(88.76,76.15) 88.57,76.36 arc(88.43,76.5) 88.24,76.56 88.24,76.56 arc(88.03,76.5) 87.88,76.35 arc(87.7,76.17) 87.45,76.11 arc(87.25,76.06) 87.11,75.92 arc(86.91,75.71) 86.62,75.64 arc(86.45,75.59) 86.33,75.46 arc(86.12,75.25) 85.83,75.17 arc(85.72,75.16) 85.62,75.1 arc(85.48,74.88) 85.51,74.61 arc(85.57,74.38) 85.54,74.14 arc(85.36,73.89) 85.06,73.8 arc(84.91,73.78) 84.79,73.7 arc(84.68,73.48) 84.71,73.24 arc(84.76,73.08) 84.78,72.91 arc(84.61,72.56) 84.25,72.41 84.05,72.41 83.87,72.23 83.53,72.23
  BOTTOM w0.102: v1(108.94,73.43) 109.26,73.98 R6840.1
FAN_CTRL: length 308.8
  TOP w0.149: v1(26.17,85.5) 25.68,85 25.68,80.15 U5.J5
  TOP w0.254: J2.4 236.93,22.24 v1(233.05,22.24)
  L03_SIG1 w0.081: v1(16.39,61.67) 17.03,61.04 17.79,61.04 19.65,59.18 21.88,59.18 24.54,56.52 25.23,56.52 27.13,54.61 27.13,50.04 28.84,48.34 v1(28.84,44.78)
  L14_SIG5 w0.081: v1(16.39,61.67) 16.67,61.95 16.67,63.93 15.78,64.83 15.78,67.05 15.41,67.41 15.07,67.41 14.55,67.94 14.55,69.9 14.76,70.12 14.76,81.05 16.39,82.68 16.39,82.86 17.63,84.1 20.33,84.1 20.66,83.77 20.66,83.57 20.95,83.28 22.31,83.28 22.64,82.95 22.64,82.53 22.89,82.28 24.55,82.28 24.7,82.43 24.7,82.83 24.98,83.11 25.2,83.11 25.61,83.52 25.61,84.94 v1(26.17,85.5)
  L16_SIG6 w0.081: v1(233.05,22.24) 226.61,15.8 194.8,15.8 193.68,14.68 138.69,14.68 134.37,10.37 129.75,10.37 126.58,7.19 60.21,7.19 57.73,9.66 57.73,12.46 50.93,19.26 50.93,19.89 49.47,21.35 49.47,22.22 46.57,25.12 46.57,29.47 44.08,31.96 44.08,37.42 42.55,38.94 42.55,41.61 41.49,42.67 37.42,42.67 34.3,45.8 29.85,45.8 v1(28.84,44.78)
FAN_TACH: length 291.7
  TOP w0.254: R89.2 v1(233.05,16.91)
  L03_SIG1 w0.081: v1(31.76,44.66) 31.76,46.05 27.57,50.24 27.57,55.2 25.66,57.1 24.87,57.1 22.37,59.61 19.85,59.61 17.79,61.67 v1(17.28,61.67)
  L14_SIG5 w0.081: v1(17.28,61.67) 17.28,65.69 16.29,66.68 16.29,67.34 15.73,67.9 15.73,68.35 15.09,68.99 15.09,73.74 15.68,74.32 15.68,81.33 16.75,82.4 16.75,82.78 17.63,83.67 18.57,83.67 19.22,83.03 21.5,83.03 21.65,82.87 21.65,82.37 22,82.02 25.18,82.02 25.71,82.55 25.71,83.19 v1(26.18,83.65)
  L16_SIG6 w0.081: v1(233.05,16.91) 229.18,16.91 227.34,15.06 195.84,15.06 194.95,14.18 138.82,14.18 134.63,9.98 129.86,9.98 126.51,6.64 60.38,6.64 57.28,9.73 57.28,12.27 50.5,19.05 50.5,19.51 49.03,20.98 49.03,22.05 46.26,24.82 46.26,29.01 43.57,31.7 43.57,36.91 42.04,38.43 42.04,41.48 41.41,42.12 36.96,42.12 34.42,44.66 v1(31.76,44.66)
FLASH0_1V8_CLK: length 17.6
  L05_SIG2 w0.081: v1(25.18,85.5) 25.03,85.65 25.03,85.83 24.78,86.07 24.78,89.75 24.59,89.94 24.59,92.56 25.03,92.99 25.3,92.99 25.69,93.37 25.89,93.37 26.52,94.01 26.52,94.29 26.84,94.6 27.83,94.6 28.4,94.03 30.06,94.03 31.83,92.26 v1(32.92,92.26)
FLASH0_1V8_CSN: length 25
  L05_SIG2 w0.081: v1(30.18,81.65) 30.18,80.88 30.92,80.14 32.34,80.14 32.7,80.5 32.7,80.7 33.03,81.03 33.45,81.03 33.78,81.36 33.78,81.81 34.02,82.05 34.41,82.05 34.78,82.42 34.78,82.78 35.05,83.05 36.09,83.05 36.89,83.85 37.48,83.85 38.26,84.63 38.26,89.73 37.3,90.69 36.68,90.69 35.39,91.97 35.39,92.36 35.08,92.66 33.74,92.66 33.36,92.28 33.36,92.08 32.92,91.64 v1(32.92,91.26)
  BOTTOM w0.149: R38.1 v1(32.92,91.26)
FLASH0_1V8_DATA0: length 24
  L05_SIG2 w0.081: v1(29.18,79.65) 29.67,79.65 29.8,79.78 29.8,80.14 29.67,80.27 28.74,80.27 28.58,80.43 28.58,81.91 28.79,82.12 29.47,82.12 29.75,82.4 29.75,82.96 30,83.21 30.46,83.21 30.72,82.96 30.97,82.96 31.27,83.26 31.58,83.26 31.71,83.14 31.71,82.3 31.86,82.15 32.32,82.15 32.67,82.51 32.67,82.91 32.94,83.18 33.34,83.18 33.6,83.44 33.6,84.01 33.96,84.37 34.3,84.37 34.4,84.47 34.4,84.89 34.75,85.25 34.75,87.2 34.65,87.3 34.48,87.3 34.37,87.19 34.37,85.35 34.25,85.22 34.09,85.22 33.99,85.32 33.99,89.41 33.75,89.65 33.75,89.8 33.92,89.96 v1(33.92,90.26)
FLASH0_1V8_DATA1: length 24.5
  L05_SIG2 w0.081: v1(32.18,80.65) 32.8,81.28 33.34,81.28 33.56,81.5 33.56,81.89 33.94,82.27 34.33,82.27 34.56,82.5 34.56,83.06 34.87,83.37 35.87,83.37 36.75,84.25 37.4,84.25 37.51,84.37 37.51,84.64 36.99,85.16 36.99,85.35 37.09,85.45 37.23,85.45 37.42,85.26 37.75,85.26 37.88,85.39 37.88,85.87 37.78,85.97 37.06,85.97 36.96,86.07 36.96,86.2 37.06,86.3 37.78,86.3 37.88,86.4 37.88,89.46 37.17,90.17 36.55,90.17 34.87,91.85 33.62,91.85 33.49,91.73 33.49,91.55 33.62,91.42 34.4,91.42 34.53,91.29 34.53,91.11 34.4,90.99 33.2,90.99 32.92,90.7 v1(32.92,90.26)
FLASH0_1V8_DATA2: length 25.2
  L05_SIG2 w0.081: v1(29.18,80.65) 29.57,81.05 29.57,81.74 30.06,82.22 31.27,82.22 31.66,81.84 31.66,81.28 31.78,81.16 32.29,81.16 32.65,81.51 32.65,81.69 33,82.05 33.41,82.05 33.8,82.43 33.8,82.9 34.07,83.17 34.24,83.17 35.05,83.97 35.24,83.97 35.47,83.74 35.61,83.74 35.71,83.84 35.71,83.98 35.48,84.21 35.48,84.35 35.58,84.44 35.72,84.44 36.02,84.14 36.16,84.14 36.26,84.24 36.26,84.38 35.9,84.73 35.9,84.87 36,84.97 36.14,84.97 36.48,84.63 36.61,84.63 36.71,84.73 36.71,84.87 36.43,85.15 36.43,85.29 36.63,85.5 36.63,87.18 36.73,87.28 37.39,87.28 37.48,87.38 37.48,87.52 37.39,87.62 36.73,87.62 36.63,87.71 36.63,88.48 36.73,88.58 37.4,88.58 37.5,88.68 37.5,88.82 37.4,88.92 36.73,88.92 36.63,89.01 36.63,89.26 36.85,89.48 36.85,89.68 36.7,89.83 36.35,89.83 v1(34.92,91.26)
  BOTTOM w0.149: R32.1 v1(34.92,91.26)
FLASH0_1V8_DATA3: length 27.5
  L05_SIG2 w0.081: v1(34.92,90.26) 34.47,90.26 34.32,90.12 34.32,87.76 34.45,87.63 34.6,87.63 34.73,87.76 34.73,89.77 34.86,89.89 34.98,89.89 35.11,89.77 35.11,85.98 35.24,85.85 35.36,85.85 35.49,85.98 35.49,89.36 35.61,89.48 35.76,89.48 35.87,89.37 35.87,85.88 34.68,84.69 34.68,84.18 34.51,84.01 34.03,84.01 33.83,83.82 33.83,83.34 33.56,83.07 33.56,82.5 33.32,82.26 32.78,82.26 v1(32.18,81.65)
  BOTTOM w0.149: v1(34.92,90.26) 37.35,90.26 37.72,90.63 R33.1
FLASH0_1V8_RESETN: length 25.6
  L05_SIG2 w0.081: v1(34.92,93.26) 35.23,93.26 36.68,91.81 36.95,91.81 38.63,90.14 38.63,83.4 37.29,82.07 34.85,82.07 34.62,81.84 34.62,81.39 34.4,81.17 34.02,81.17 33.69,80.85 33.69,80.43 33.4,80.14 32.83,80.14 31.84,79.15 28.68,79.15 v1(28.18,79.65)
  BOTTOM w0.149: R39.1 v1(34.92,93.26)
FLASH1_1V8_CLK: length 22
  L05_SIG2 w0.081: v1(25.3,92.26) 25.59,92.26 26.04,92.71 26.19,92.71 27.16,93.68 29.75,93.68 32.54,90.88 32.54,90.05 32.79,89.81 33.21,89.81 33.43,90.03 33.43,90.5 33.59,90.66 35.06,90.66 36.28,89.44 36.28,85.75 v1(35.06,84.53)
  BOTTOM w0.149: v1(35.06,84.53) 35.82,84.53 36.14,84.22 R54.2
FLASH1_1V8_CSN: length 25.2
  L05_SIG2 w0.081: v1(25.3,91.26) 25.3,91.77 25.42,91.9 25.6,91.9 25.73,91.77 25.73,90.68 25.86,90.55 26.04,90.55 26.16,90.68 26.16,91.7 26.29,91.82 26.52,91.82 26.65,91.7 26.65,91.01 26.78,90.88 27.58,90.88 27.69,90.99 28.25,90.99 28.51,90.73 28.73,90.73 28.88,90.88 29.15,90.88 29.32,90.71 30.11,90.71 30.41,90.4 30.74,90.4 30.87,90.27 30.87,90.15 30.64,89.92 30.64,89.74 30.87,89.51 30.87,88.93 31.25,88.55 31.25,87.07 31.35,86.97 31.61,86.97 31.71,87.07 31.71,88.75 31.84,88.88 32.04,88.88 32.16,88.75 32.16,84.45 31.65,83.94 31.47,83.94 31.34,84.06 31.34,84.24 31.81,84.71 31.81,84.89 31.7,85 31.52,85 v1(30.18,83.65)
  BOTTOM w0.149: R36.1 v1(25.3,91.26)
FLASH1_1V8_DATA0: length 24.7
  L05_SIG2 w0.081: v1(29.18,82.65) 29.18,82.97 29.67,83.47 29.67,83.72 31.81,85.85 31.81,86.44 31.63,86.62 31.05,86.62 30.82,86.39 29.81,86.39 29.65,86.54 29.65,87.07 29.83,87.25 30.79,87.25 30.92,87.38 30.92,87.58 30.79,87.71 29.85,87.71 29.73,87.84 29.73,88.01 29.85,88.14 30.76,88.14 30.86,88.24 30.86,88.47 30.76,88.57 30.18,88.57 30.06,88.7 30.06,90.25 29.93,90.38 29.75,90.38 29.62,90.25 29.62,88.6 29.5,88.48 29.34,88.48 29.2,88.62 29.2,90.36 29.08,90.48 28.95,90.48 28.82,90.36 28.82,89.26 28.72,89.16 28.58,89.16 28.48,89.26 28.48,90.25 28.08,90.65 26.68,90.65 v1(26.3,90.26)
FLASH1_1V8_DATA1: length 25.1
  L05_SIG2 w0.081: v1(25.3,90.26) 25.53,90.03 25.53,86.31 25.66,86.18 25.84,86.18 25.97,86.31 25.97,88.8 26.07,88.9 26.3,88.9 26.4,88.8 26.4,85.93 26.53,85.8 26.71,85.8 26.83,85.93 26.83,87.89 26.96,88.01 27.14,88.01 27.27,87.89 27.27,85.98 27.4,85.86 27.58,85.86 27.7,85.98 27.7,87.95 27.83,88.08 28.01,88.08 28.14,87.95 28.14,86.2 28.37,85.97 29.09,85.97 29.24,85.81 29.24,85.39 28.61,84.76 28.61,83.08 v1(28.18,82.65)
FLASH1_1V8_DATA2: length 25.8
  L05_SIG2 w0.081: v1(27.3,91.26) 28.71,91.26 29.29,91.85 29.62,91.85 29.75,91.72 29.75,91.19 29.88,91.06 30,91.06 30.13,91.19 30.13,91.97 30.23,92.07 30.41,92.07 30.51,91.97 30.51,90.91 30.61,90.81 31.06,90.81 31.2,90.67 31.2,89.1 31.32,88.97 31.46,88.97 31.56,89.07 31.56,89.38 31.69,89.5 31.93,89.5 32.49,88.94 32.49,84.91 32.63,84.77 32.81,84.77 32.93,84.89 32.93,88.21 33.05,88.34 33.2,88.34 33.3,88.24 33.3,84.78 32.75,84.23 32.75,83.62 32.18,83.05 v1(32.18,82.65)
  BOTTOM w0.149: R34.1 v1(27.3,91.26)
FLASH1_1V8_DATA3: length 25.6
  L05_SIG2 w0.081: v1(29.18,83.65) 29.4,83.88 29.4,83.99 31.44,86.03 31.44,86.17 31.34,86.27 31.18,86.27 29.25,84.34 29.07,84.34 28.94,84.46 28.94,84.62 30.06,85.73 30.06,85.88 29.95,85.99 29.59,85.99 29.32,86.26 29.32,87.99 29.2,88.11 29.06,88.11 28.94,87.99 28.94,86.46 28.81,86.33 28.63,86.33 28.51,86.46 28.51,88.32 28.12,88.7 28.12,89.23 28,89.36 27.79,89.36 27.67,89.23 27.67,88.39 27.57,88.29 27.31,88.29 27.21,88.39 27.21,89.13 27.08,89.26 26.02,89.26 25.89,89.39 25.89,89.61 26.02,89.74 28,89.74 28.12,89.87 28.12,90.14 28,90.26 v1(27.3,90.26)
  BOTTOM w0.149: R35.1 27.08,89.82 27.08,90.04 v1(27.3,90.26)
FLASH1_1V8_RESETN: length 26
  L05_SIG2 w0.081: v1(33.18,83.65) 33.18,84.08 33.83,84.74 33.83,84.99 33.66,85.16 33.66,88.49 33.48,88.67 32.93,88.67 32.82,88.78 32.82,88.92 32.95,89.05 33.51,89.05 33.62,89.16 33.62,89.3 33.51,89.41 32.49,89.41 32.22,89.69 32.22,90.69 32.11,90.8 31.98,90.8 31.88,90.7 31.88,89.94 31.78,89.84 31.63,89.84 31.53,89.94 31.53,91.42 30.49,92.46 30.09,92.46 29.91,92.28 29.74,92.28 29.61,92.41 29.61,92.58 29.51,92.68 28.97,92.68 28.84,92.8 28.84,93.04 28.74,93.14 28.6,93.14 28.5,93.04 28.5,92.5 28.76,92.23 28.76,91.85 28.61,91.69 28.25,91.69 28.15,91.79 28.15,93.22 28.03,93.34 27.89,93.34 27.77,93.22 27.77,91.9 27.64,91.77 27.14,91.77 26.7,92.21 26.7,92.67 v1(27.3,93.26)
  BOTTOM w0.149: R37.1 v1(27.3,93.26)
FLASH_IMAGE_SEL0: length 27.5
  TOP w0.149: J105.1 49.41,65.48 v1(40.33,65.48) R848.2
  L05_SIG2 w0.081: v1(26.18,69.65) 26.66,69.17 27.36,69.17 27.74,68.79 27.74,68.53 28.12,68.15 32.75,68.15 33.49,67.41 38.1,67.41 38.71,66.79 39.02,66.79 v1(40.33,65.48)
FLASH_IMAGE_SEL1: length 19.9
  TOP w0.149: J106.1 42.91,64.32 v1(40.33,64.32) R849.2
  L05_SIG2 w0.081: v1(26.18,68.65) 26.56,68.65 27.08,68.13 27.36,68.13 28.06,67.43 29.31,67.43 29.72,67.02 31.29,67.02 31.64,67.37 32.04,67.37 33.25,66.16 38.96,66.16 40.33,64.79 v1(40.33,64.32)
FPGA_1V2_AVSTX16_CLK: length 116.6
  L05_SIG2 w0.081: v1(25.79,64.85) 30.56,60.07 32.05,60.07 32.37,59.76 32.37,58.32 32.67,58.02 32.67,56.97 34.55,55.1 34.55,52.71 35.59,51.67 35.74,51.67 35.86,51.8 35.86,51.94 34.98,52.83 34.98,52.97 35.11,53.1 35.25,53.1 37.36,50.99 37.36,50.84 37.23,50.72 37.09,50.72 36.41,51.39 36.27,51.39 36.14,51.26 36.14,51.12 38.63,48.62 38.78,48.62 38.91,48.75 38.91,48.9 37.83,49.98 37.83,50.12 37.96,50.25 38.1,50.25 40.62,47.73 40.62,47.59 40.49,47.46 40.35,47.46 39.39,48.41 39.25,48.41 39.12,48.28 39.12,48.14 40.28,46.98 44.3,46.98 44.4,47.08 44.4,47.27 44.3,47.37 41.13,47.37 41.03,47.47 41.03,47.65 41.13,47.75 45.42,47.75 45.78,48.11 46.64,48.11 46.84,47.91 46.84,47.5 47.09,47.25 48.24,47.25 48.67,46.82 48.67,44.89 48.78,44.77 50.49,44.77 50.6,44.66 50.6,44.5 50.49,44.39 48.78,44.39 48.67,44.27 48.67,44.11 48.78,44 50.49,44 50.6,43.89 50.6,43.73 50.49,43.62 48.78,43.62 48.67,43.5 48.67,43.34 48.78,43.23 50.49,43.23 50.6,43.12 50.6,42.96 50.49,42.84 48.78,42.84 48.67,42.73 48.67,42.57 48.78,42.46 50.49,42.46 50.6,42.34 50.6,42.18 50.49,42.07 48.78,42.07 48.67,41.96 48.67,41.76 48.77,41.66 57.53,41.66 58.27,42.4 68.14,42.4 68.25,42.52 69.77,42.52 70.44,41.85 74.58,41.85 74.84,41.59 79.94,41.59 80.22,41.32 87.58,41.32 87.8,41.54 87.8,41.72 v1(88.22,42.15)
  BOTTOM w0.149: R71.2 v1(25.79,64.85)
FPGA_1V2_AVSTX16_D0: length 124.3
  L05_SIG2 w0.081: v1(95.39,41.69) 93.51,39.8 91.95,39.8 90.51,38.37 90.51,37.39 90.07,36.95 89.35,36.65 87.61,36.65 86.52,37.75 85.81,37.75 85.64,37.58 83.03,37.58 82.83,37.38 80.52,37.38 80.06,36.92 78.85,36.92 78.39,36.46 77.79,36.46 77.39,36.87 75.97,36.87 75.22,37.62 72.69,37.62 72.18,38.13 70.07,38.13 66.99,36.86 64.09,36.86 63.53,36.3 46.5,36.3 45.6,35.93 43.17,35.93 41.69,37.41 39.95,37.41 39.15,36.61 34.24,36.61 30.27,40.57 30.27,42.28 29.43,43.12 29.43,45.76 26.91,48.28 26.91,52 26.6,52.3 22.13,52.3 21.56,52.87 21.56,54.09 21.47,54.18 21.21,54.18 21.12,54.09 21.12,52.77 22.41,51.48 22.41,51.33 22.28,51.2 22.13,51.2 20.69,52.65 20.69,53.75 19.75,54.68 18.5,57.71 18.5,62.51 17.99,63.02 17.99,64.01 17.15,64.85 17.15,65.74 16.26,66.63 16.26,69.95 18.56,72.25 20.29,72.25 20.69,71.85 20.69,71.14 v1(21.18,70.65)
FPGA_1V2_AVSTX16_D1: length 124
  L05_SIG2 w0.081: v1(94.6,42.15) 94.6,41.9 93.24,40.54 91.65,40.54 90.15,39.04 89.97,39.04 89.67,38.74 89.67,38.28 89.31,37.92 88.12,37.92 87.63,38.42 85.91,38.42 85.54,38.79 82.77,38.79 82.35,38.37 72.86,38.37 72.33,38.9 70.23,38.9 66.95,37.54 61.88,37.54 61.29,36.95 55.19,36.95 53.97,38.18 53.02,38.18 51.83,36.99 45.81,36.99 45.48,36.65 43.43,36.65 41.86,38.23 38.65,38.23 38.47,38.41 36.31,38.41 35.45,39.27 35.45,39.72 34.32,40.85 31.82,40.85 31.73,40.93 31.73,41.18 31.82,41.27 32.92,41.27 33.01,41.36 33.01,41.57 32.92,41.66 32.59,41.66 32.52,41.73 32.52,42.36 31.43,43.45 31.43,43.64 31.55,43.76 31.7,43.76 32.91,42.56 32.91,42.1 33,42.01 33.18,42.01 33.27,42.1 33.27,42.95 32.09,44.12 31.6,44.12 31.28,44.44 31.28,45.76 28.09,48.95 28.09,52.48 26.31,54.27 24.31,54.27 22.99,55.59 22.99,55.75 23.1,55.86 23.26,55.86 24.15,54.97 24.31,54.97 24.43,55.08 24.43,55.24 22.35,57.32 22.19,57.32 22.08,57.2 22.08,57.04 22.84,56.28 22.84,56.14 22.71,56.01 22.57,56.01 21.68,56.9 21.68,58.6 20.15,60.13 19.99,60.13 19.88,60.02 19.88,59.86 20.36,59.38 20.36,59.22 20.25,59.1 20.09,59.1 19.48,59.71 19.48,63.77 18.12,65.13 18.12,66.03 17.61,66.54 17.61,69.9 18.36,70.65 v1(19.18,70.65)
FPGA_1V2_AVSTX16_D2: length 125.1
  L05_SIG2 w0.081: v1(20.18,70.65) 19.67,71.16 18.15,71.16 17.23,70.24 17.23,66.4 17.61,66.02 17.61,65.06 18.96,63.71 18.96,57.63 19.4,56.57 20.03,55.94 21.69,55.94 22.68,54.95 22.68,54.81 22.19,54.31 22.19,54.17 22.37,53.99 22.51,53.99 23,54.48 23.15,54.48 23.6,54.03 23.6,53.89 23.19,53.47 23.19,53.33 23.37,53.15 23.52,53.15 23.93,53.56 24.07,53.56 24.35,53.28 26.6,53.28 27.5,52.38 27.5,48.61 30.41,45.69 30.41,43.62 31.32,42.71 31.32,40.82 31.82,40.32 34.34,40.32 35.11,39.55 35.11,39.03 35.38,38.76 35.38,38.09 35.6,37.87 36.78,37.87 36.88,37.77 36.88,37.58 36.78,37.48 35.14,37.48 35.04,37.38 35.04,37.2 35.14,37.1 38.83,37.1 38.93,37.2 38.93,37.38 38.83,37.48 37.62,37.48 37.51,37.58 37.51,37.77 37.62,37.87 41.74,37.87 43.31,36.3 45.6,36.3 45.94,36.64 52.1,36.64 53.31,37.85 53.78,37.85 55,36.63 63.09,36.63 63.67,37.21 67,37.21 70.14,38.51 72.26,38.51 72.78,37.99 76.03,37.99 76.56,37.45 79.37,37.45 79.87,37.95 82.5,37.95 83.01,38.46 85.36,38.46 85.75,38.07 86.8,38.07 87.87,37.01 89.31,37.01 89.69,37.39 89.69,37.75 90.02,38.08 90.02,38.38 91.85,40.2 93.39,40.2 94.98,41.8 94.98,42.67 95.39,43.08 v1(95.39,43.53)
FPGA_1V2_AVSTX16_D3: length 123.9
  L05_SIG2 w0.081: v1(94.6,43.07) 94.24,42.71 94.24,42.58 93.85,42.19 93.68,42.19 93.25,41.75 93.25,41.25 92.92,40.92 91.48,40.92 89.98,39.42 89.3,39.42 88.72,38.84 86,38.84 85.72,39.11 82.54,39.11 82.14,38.71 72.98,38.71 72.46,39.23 70.18,39.23 66.98,37.91 61.04,37.91 60.41,37.28 55.59,37.28 54.35,38.53 52.84,38.53 51.64,37.33 45.67,37.33 45.32,36.99 43.59,36.99 41.99,38.59 40.63,38.59 40.23,38.99 39.95,38.99 39.54,38.58 39.38,38.58 39.26,38.71 39.26,38.87 39.61,39.22 39.61,39.38 39.48,39.51 39.32,39.51 38.73,38.92 38.57,38.92 38.44,39.04 38.44,39.2 39.03,39.79 39.03,40.29 37.69,41.63 35.34,41.63 34.51,42.46 34.35,42.46 34.24,42.35 34.24,42.19 35.14,41.28 35.14,41.12 35.03,41.01 34.87,41.01 33.73,42.15 33.73,43.07 32.35,44.46 32.35,44.62 32.46,44.73 32.62,44.73 34.2,43.15 34.36,43.15 34.48,43.26 34.48,43.42 31.43,46.47 31.43,46.63 31.54,46.74 31.7,46.74 32.77,45.67 32.93,45.67 33.05,45.78 33.05,45.94 30.59,48.39 30.43,48.39 30.32,48.28 30.32,48.12 31.17,47.27 31.17,47.11 31.05,47 30.89,47 28.61,49.28 28.61,49.44 28.73,49.55 28.89,49.55 29.76,48.68 29.92,48.68 30.03,48.79 30.03,48.95 28.63,50.35 28.63,52.88 26.12,55.39 25.1,55.39 22.35,58.14 22.35,59.09 20.37,61.07 20.37,63.56 18.7,65.23 18.7,69.18 v1(19.18,69.65)
FPGA_1V2_AVSTX16_D4: length 124.6
  L05_SIG2 w0.081: v1(93.8,41.69) 94.12,42.01 94.12,42.2 94.49,42.57 94.62,42.57 95,42.94 95,43.72 95.19,43.91 95.6,43.91 95.78,43.72 95.78,41.53 93.7,39.45 93.16,39.45 92.84,39.32 92.12,38.6 91.6,38.38 90.94,37.72 90.94,37.32 90.3,36.67 89.39,36.3 86.45,36.3 85.47,36.71 83.24,36.71 82.57,36.99 82.08,36.99 78.47,36.14 77.73,36.14 73.27,37.03 71.6,37.72 69.93,37.72 67,36.51 63.68,35.97 46.86,35.97 41,33.55 37.41,33.55 37.13,33.66 36.81,33.88 33.4,36.67 29.86,40.22 29.38,40.94 29.04,41.74 28.02,44.82 27.19,46.85 26.63,47.68 24.94,49.37 23.58,49.93 21.19,51.21 20.27,51.83 19.67,52.43 19.51,52.8 19.51,53.54 19.23,54.95 18.09,57.71 17.91,58.61 17.91,60.16 17.82,61.07 17.48,62.79 15.92,66.55 15.92,70.07 18.88,73.03 20.46,73.03 20.62,72.88 20.62,72.54 21.01,72.15 24.21,72.15 24.56,72.51 24.56,73.27 v1(24.18,73.65)
FPGA_1V2_AVSTX16_D5: length 126.2
  L05_SIG2 w0.081: v1(93,42.15) 93.34,42.49 93.44,42.72 93.7,42.98 93.97,43.09 94.31,43.43 94.38,43.58 94.84,44.04 95.21,44.2 95.74,44.2 96.1,43.84 96.1,41.42 96.07,41.36 94.16,39.44 94.07,39.22 93.24,38.4 91.9,37.29 90.09,36.09 88.52,35.44 86.79,35.44 86.53,35.54 86.34,35.73 86.17,35.8 85.58,35.8 85.24,35.66 83.17,35.66 82.81,36.02 82.81,36.32 82.51,36.63 82.15,36.63 78.63,35.81 77.58,35.81 73.28,36.67 71.56,37.39 69.97,37.39 66.96,36.14 63.8,35.64 47.11,35.64 41.1,33.15 37.01,33.15 36.51,33.32 30.35,38.24 26.48,40.52 26.1,40.9 24.49,43.3 22.45,48.23 22.02,48.88 20.06,51.26 17.14,54.19 16.82,54.95 16.82,63.17 15.76,65.74 14.88,66.62 14.76,66.9 14.76,68.25 15.56,70.19 18.6,73.23 22.96,73.23 v1(24.18,72.65)
FPGA_1V2_AVSTX16_D6: length 126.5
  TOP w0.149: v1(19.18,67.65) 19.63,68.1 21.37,68.1 21.68,68.41 21.68,70.15 U5.N14
  L05_SIG2 w0.081: v1(19.18,67.65) 19.18,65.29 21.14,63.33 21.14,61.31 21.33,61.12 21.88,61.12 22.21,60.78 22.21,60.31 22.92,59.6 22.92,58.52 25.48,55.96 26.47,55.96 29.08,53.35 29.08,53.06 29.19,52.95 29.53,52.95 29.64,52.84 29.64,52.53 29.53,52.42 29.19,52.42 29.08,52.31 29.08,51.7 29.27,51.51 29.27,51.2 29.08,51.01 29.08,50.69 31.65,48.12 31.81,48.12 31.92,48.24 31.92,48.4 30.19,50.13 30.19,50.29 30.3,50.4 30.46,50.4 32.48,48.38 32.48,48.22 32.09,47.84 32.09,47.68 33.09,46.68 33.25,46.68 33.36,46.79 33.36,46.95 32.62,47.7 32.62,47.86 32.73,47.97 32.89,47.97 35.86,45 35.86,44.84 35.75,44.73 35.59,44.73 33.78,46.54 33.62,46.54 33.51,46.42 33.51,46.26 35.45,44.32 35.45,44.16 35.33,44.04 35.17,44.04 33.91,45.3 33.77,45.3 33.67,45.19 33.67,45.02 34.9,43.79 34.9,42.65 35.02,42.54 35.18,42.54 35.29,42.65 35.29,43.57 35.4,43.68 35.56,43.68 35.67,43.57 35.67,42.16 35.78,42.06 37.82,42.06 40.9,38.98 42.09,38.98 43.75,37.32 45.17,37.32 45.55,37.69 51.54,37.69 52.7,38.85 54.51,38.85 55.76,37.6 60.26,37.6 60.9,38.25 66.95,38.25 70.17,39.58 72.57,39.58 73.1,39.05 81.93,39.05 82.32,39.44 85.91,39.44 86.18,39.17 88.59,39.17 89.29,39.87 89.88,39.87 91.3,41.29 92.37,41.29 92.63,41.54 92.63,42.4 92.84,42.61 93.08,42.61 93.41,42.95 93.41,43.14 v1(93.8,43.53)
FPGA_1V2_AVSTX16_D7: length 125.4
  L05_SIG2 w0.081: v1(23.18,69.65) 23.56,70.03 24.48,70.03 24.71,69.8 24.71,69.44 25.07,69.09 25.3,69.09 25.64,68.75 25.64,68.56 26.08,68.13 26.4,68.13 26.71,67.81 26.71,67.38 26.85,67.24 27.59,67.24 28,66.83 29.1,66.83 29.4,66.53 31.56,66.53 32.57,65.52 32.57,63.08 32.68,62.97 33.01,62.97 33.11,63.07 33.11,63.98 33.21,64.08 33.47,64.08 33.57,63.98 33.57,63.1 33.68,63 33.95,63 34.05,63.1 34.05,63.98 34.15,64.08 34.4,64.08 34.5,63.98 34.5,63.08 34.6,62.97 34.81,62.97 34.91,63.08 34.91,64.98 35.01,65.08 35.2,65.08 35.3,64.98 35.3,62.95 35.4,62.85 35.58,62.85 35.69,62.95 35.69,63.84 35.79,63.94 35.97,63.94 36.07,63.84 36.07,62.95 36.17,62.85 36.36,62.85 36.46,62.95 36.46,64.79 36.56,64.9 36.74,64.9 36.84,64.79 36.84,62.95 36.95,62.85 37.13,62.85 37.23,62.95 37.23,64.77 37.33,64.87 37.51,64.87 37.62,64.77 37.62,62.95 37.72,62.85 37.9,62.85 38,62.95 38,64.75 38.1,64.85 38.29,64.85 38.39,64.75 38.39,62.95 38.49,62.85 38.67,62.85 38.77,62.95 38.77,64.74 38.88,64.84 39.06,64.84 39.16,64.74 39.16,62.95 39.26,62.85 39.44,62.85 39.55,62.95 39.55,64.14 39.65,64.25 39.83,64.25 39.93,64.14 39.93,62.95 40.64,62.25 40.78,62.25 40.91,62.38 40.91,62.52 40.28,63.15 40.28,63.29 40.41,63.42 40.55,63.42 42.45,61.53 42.45,61.38 42.32,61.26 42.17,61.26 41.36,62.06 41.22,62.06 41.09,61.94 41.09,61.79 42.01,60.87 43.31,60.87 43.6,60.58 43.6,59.73 45.94,57.39 48.25,57.39 49.65,55.99 51.47,55.99 53.16,54.3 53.16,53.35 53.82,52.69 53.82,48.36 55.59,46.59 55.59,45.76 56.67,44.69 57.85,44.69 58.27,45.11 73.59,45.11 73.88,45.41 73.88,46.19 74.37,46.68 81.22,46.68 81.49,46.41 82.07,46.41 82.3,46.64 82.79,46.64 83.17,46.26 83.62,46.26 84.08,46.72 92.04,46.72 93.39,45.37 93.39,44.34 93,43.95 v1(93,43.07)
FPGA_1V2_AVSTX16_D8: length 124
  L05_SIG2 w0.081: v1(91.41,42.15) 91.41,42.54 91.02,42.94 91.02,43.68 90.67,44.02 90.43,44.02 90,44.45 89.69,44.45 89.14,43.9 88.87,43.9 88.64,43.67 88.64,42.9 88.33,42.6 88.08,42.6 87.64,42.16 87.27,42.16 86.86,41.75 86.49,41.75 86.12,42.12 85.67,42.12 85.33,41.78 84.79,41.78 84.51,42.06 84.03,42.06 83.73,41.76 83.15,41.76 82.89,42.02 82.46,42.02 82.19,41.76 81.49,41.76 81.21,42.04 80.89,42.04 80.66,41.81 80.1,41.81 79.97,41.94 79.14,41.94 78.9,42.18 70.59,42.18 69.91,42.86 67.95,42.86 67.82,42.73 57.98,42.73 57.24,41.99 51.68,41.99 51.06,42.61 51.06,47 50.02,48.05 50.02,49.51 49.93,49.6 49.47,49.6 49.38,49.51 49.38,47.85 49.29,47.77 48.64,47.77 48.55,47.85 48.55,49.87 48.47,49.96 46.28,49.96 45.93,49.6 44.86,49.6 43.56,48.31 41.29,48.31 41.19,48.41 41.19,48.59 41.29,48.69 43.27,48.69 43.37,48.8 43.37,48.98 43.27,49.08 42.51,49.08 42.4,49.19 42.4,50 42.28,50.12 42.12,50.12 42.01,50 42.01,49.19 41.9,49.08 41.74,49.08 41.62,49.19 41.62,49.5 41.51,49.61 41.35,49.61 41.24,49.5 41.24,49.19 41.12,49.08 40.97,49.08 40.35,49.69 40.21,49.69 40.08,49.56 40.08,49.42 40.7,48.8 40.7,48.66 40.57,48.53 40.42,48.53 39.52,49.44 39.52,49.58 39.92,49.98 39.92,50.22 39.75,50.38 38.65,50.38 37.08,51.96 37.08,52.1 37.21,52.23 37.35,52.23 38.58,51.01 38.72,51.01 38.85,51.14 38.85,51.28 36.12,54.01 35.98,54.01 35.85,53.88 35.85,53.74 36.9,52.69 36.9,52.54 36.77,52.41 36.62,52.41 34.98,54.06 34.98,54.2 35.57,54.78 35.57,55.2 33.38,57.38 33.38,59.88 33.11,60.16 32.61,60.16 32.1,60.66 31.62,60.66 29.61,62.68 29.46,62.68 29.33,62.55 29.33,62.41 30.78,60.96 30.78,60.82 30.65,60.69 30.43,60.69 26.19,64.93 26.19,65 25.97,65.23 25.55,65.23 25.3,64.98 22.81,64.98 21.27,66.53 21.27,67.19 21.55,67.47 21.55,68.2 21.68,68.33 21.68,69.15 v1(21.18,69.65)
FPGA_1V2_AVSTX16_D9: length 125
  TOP w0.149: U5.M14 22.68,70.15 22.68,68.15 v1(22.18,67.65)
  L05_SIG2 w0.081: v1(92.21,43.53) 92.21,44.62 91,45.83 88.8,45.83 88.34,45.37 88.05,45.37 87.59,44.91 87.23,44.91 86.79,44.46 86.52,44.46 85.99,43.93 85.59,43.93 85.15,43.49 84.83,43.49 84.34,43 81.31,43 80.7,43.61 79.99,43.61 79.64,43.97 76.87,43.97 75.84,42.94 73.75,42.94 73.64,42.83 71.27,42.83 70.57,43.52 67.2,43.52 67.07,43.39 57.07,43.39 56.36,42.68 55.24,42.68 55.13,42.78 55.13,43.13 55.03,43.23 54.85,43.23 54.75,43.13 54.75,42.86 54.65,42.76 54.46,42.76 54.36,42.86 54.36,44.43 54.26,44.53 54.08,44.53 53.98,44.43 53.98,42.87 53.87,42.77 53.65,42.77 53.55,42.87 53.55,43.91 53.45,44.01 53.25,44.01 53.15,43.91 53.15,42.86 53.05,42.76 52.81,42.76 52.64,42.93 52.64,44.54 52.36,44.82 52.03,44.82 51.73,45.11 51.73,47.43 50.96,48.21 50.96,49.66 49.65,50.96 49.65,51.44 48.5,52.59 48.5,55.57 47.85,56.22 44.34,56.22 44.24,56.12 44.24,55.64 44.14,55.54 43.93,55.54 43.83,55.64 43.83,56.12 43.73,56.22 43.13,56.22 43.03,56.12 43.03,54.81 42.9,54.68 38.64,54.68 38.54,54.78 38.54,54.96 38.64,55.06 42.55,55.06 42.65,55.17 42.65,55.35 42.55,55.45 38.49,55.45 38.39,55.55 38.39,55.74 38.49,55.84 42.5,55.84 42.6,55.94 42.6,56.12 42.5,56.22 39.11,56.22 38.57,56.77 38.57,57.47 37.04,59.01 36.89,59.01 36.06,58.18 35.92,58.18 35.79,58.31 35.79,58.45 36.62,59.28 36.62,59.42 36.49,59.55 36.35,59.55 35.73,58.94 35.59,58.94 35.46,59.07 35.46,59.21 35.61,59.36 35.61,59.57 33.45,61.73 32.09,61.73 30.36,63.45 28.71,63.45 28.02,64.14 28.02,64.34 27.34,65.03 27.34,65.89 27.03,66.2 26.47,66.2 26.22,65.94 25.33,65.94 25.01,66.26 22.81,66.26 22.37,66.7 22.37,67.46 v1(22.18,67.65)
FPGA_1V2_AVSTX16_D10: length 125.5
  L05_SIG2 w0.081: v1(91.41,43.07) 91.78,43.43 91.78,44.17 91.5,44.45 90.89,44.45 89.98,45.37 89.68,45.37 89.22,44.91 88.73,44.91 88.37,44.55 88.13,44.55 87.59,44.01 87.17,44.01 86.78,43.62 86.46,43.62 85.9,43.06 85.62,43.06 85.12,42.56 84.79,42.56 84.49,42.27 83.96,42.27 83.6,42.63 83.25,42.63 82.89,42.27 82.34,42.27 82.02,42.59 81.64,42.59 81.32,42.27 80.76,42.27 80.54,42.48 80.06,42.48 79.46,43.08 76.79,43.08 76.22,42.51 70.81,42.51 70.12,43.19 67.58,43.19 67.44,43.05 57.61,43.05 56.88,42.33 52.12,42.33 51.39,43.06 51.39,47.19 50.54,48.03 50.54,49.55 49.62,50.47 46.19,50.47 45.87,50.14 42.96,50.14 42.86,50.25 42.86,53.86 42.76,53.96 42.57,53.96 42.47,53.86 42.47,51.5 42.37,51.4 42.19,51.4 42.09,51.5 42.09,53.84 41.99,53.94 41.8,53.94 41.7,53.84 41.7,50.19 41.6,50.09 41.42,50.09 41.31,50.19 41.31,53.82 41.21,53.92 41.03,53.92 40.93,53.82 40.93,51.54 40.83,51.44 40.64,51.44 40.54,51.54 40.54,53.81 40.44,53.91 40.26,53.91 40.16,53.81 40.16,51.16 40.05,51.06 39.87,51.06 39.77,51.16 39.77,53.93 39.67,54.03 39.49,54.03 39.38,53.93 39.38,52.09 39.28,51.99 39.1,51.99 39,52.09 39,53.98 38.9,54.08 38.71,54.08 38.61,53.98 38.61,52.89 38.51,52.79 38.33,52.79 38.23,52.89 38.23,54.34 38.14,54.43 37.87,54.43 37.78,54.34 37.78,53.66 37.69,53.57 37.51,53.57 37.42,53.66 37.42,54.74 36.96,55.2 36.58,55.2 34.4,57.38 34.4,59.88 33.05,61.22 31.84,61.22 30.03,63.03 28.57,63.03 26.75,64.85 26.75,65.18 26.37,65.56 25.33,65.56 25.12,65.35 22.97,65.35 21.62,66.7 21.62,67.13 21.81,67.32 21.81,67.8 22.18,68.18 v1(22.18,68.65)
FPGA_1V2_AVSTX16_D11: length 124
  L05_SIG2 w0.081: v1(90.61,41.69) 89.6,40.68 89.07,40.68 88.24,39.85 86.53,39.85 86.28,40.09 81.94,40.09 81.58,39.73 73.34,39.73 72.7,40.36 70.36,40.36 66.99,38.97 59.85,38.97 59.15,38.27 56.1,38.27 54.86,39.5 52.25,39.5 51.14,38.4 46.73,38.4 45.17,39.96 43.77,39.96 43.55,39.74 41.3,39.74 40.98,40.05 40.98,42.36 40.25,43.09 40.09,43.09 39.98,42.97 39.98,42.81 40.47,42.33 40.47,42.17 40.35,42.06 40.19,42.06 38.38,43.87 38.38,44.03 38.49,44.15 38.65,44.15 39.57,43.23 39.73,43.23 39.84,43.34 39.84,43.5 37.74,45.6 37.58,45.6 37.46,45.49 37.46,45.33 38.16,44.64 38.16,44.48 38.05,44.36 37.89,44.36 35.3,46.95 35.3,47.11 35.41,47.22 35.57,47.22 36.65,46.14 36.81,46.14 36.93,46.25 36.93,46.41 34.21,49.13 34.05,49.13 33.94,49.02 33.94,48.86 35.08,47.71 35.08,47.55 34.97,47.44 34.81,47.44 31.94,50.31 31.94,50.47 32.05,50.58 32.21,50.58 33.46,49.33 33.62,49.33 33.74,49.45 33.74,49.61 32.13,51.21 32.13,52.03 30.53,53.64 30.53,54.19 28.42,56.3 28.07,56.3 26.21,58.16 26.21,58.32 26.32,58.43 26.48,58.43 27.46,57.45 27.62,57.45 27.74,57.56 27.74,57.72 25.28,60.18 25.12,60.18 25,60.06 25,59.9 25.98,58.93 25.98,58.77 25.87,58.65 25.71,58.65 23.34,61.03 23.34,61.19 23.45,61.3 23.61,61.3 24.39,60.52 24.55,60.52 24.66,60.64 24.66,60.8 23.9,61.56 23.9,61.93 23.63,62.2 23.45,62.2 19.87,65.79 19.87,68.2 19.78,68.28 19.78,69.25 v1(20.18,69.65)
FPGA_1V2_AVSTX16_D12: length 123.3
  L05_SIG2 w0.081: v1(89.82,42.15) 88.89,42.15 87.75,41 80.14,41 79.93,41.21 74.44,41.21 74.12,41.53 70.27,41.53 69.62,42.18 68.63,42.18 68.52,42.07 58.49,42.07 57.62,41.2 50.95,41.2 50.84,41.09 50.84,39.65 50.72,39.54 50.43,39.54 50.31,39.65 50.31,41.09 50.2,41.2 49.95,41.2 49.84,41.09 49.84,39.67 49.72,39.56 49.48,39.56 49.37,39.67 49.37,41.09 49.26,41.2 48.99,41.2 48.87,41.09 48.87,39.66 48.76,39.55 48.45,39.55 48.35,39.65 48.35,46.21 48,46.56 46.35,46.56 45.38,46.16 43.06,46.16 42.95,46.04 42.95,44.87 42.83,44.76 42.67,44.76 42.56,44.87 42.56,46.04 42.45,46.16 42.29,46.16 42.17,46.04 42.17,45.18 42.06,45.07 41.9,45.07 41.79,45.18 41.79,46.41 41.68,46.52 41.43,46.52 41.32,46.41 41.32,45.59 41.2,45.48 41.04,45.48 40.93,45.59 40.93,46.04 40.82,46.16 40.66,46.16 40.55,46.04 40.55,45.58 40.43,45.47 40.27,45.47 40.16,45.58 40.16,46.34 39.48,47.02 39.29,47.02 38.16,48.16 38,48.16 37.88,48.04 37.88,47.88 38.85,46.91 38.85,46.75 38.74,46.64 38.58,46.64 36.35,48.86 36.35,49.02 36.47,49.14 36.63,49.14 37.43,48.34 37.59,48.34 37.7,48.45 37.7,48.61 35.41,50.9 35.25,50.9 35.14,50.78 35.14,50.62 36.19,49.58 36.19,49.42 36.07,49.31 35.91,49.31 33.49,51.73 33.49,51.89 33.6,52 33.76,52 34.7,51.07 34.86,51.07 34.97,51.18 34.97,51.34 34.15,52.16 34.15,54.4 34.04,54.51 33.88,54.51 33.76,54.4 33.76,52.96 33.65,52.84 33.49,52.84 33.38,52.96 33.38,55.27 32.04,56.6 32.04,57.57 31.49,58.13 31.49,58.52 25.62,64.38 22.86,64.38 20.78,66.46 20.78,68.26 v1(21.18,68.65)
FPGA_1V2_AVSTX16_D13: length 125.3
  L05_SIG2 w0.081: v1(20.18,68.65) 20.18,65.99 23.46,62.71 23.96,62.71 24.88,63.63 25.04,63.63 25.18,63.49 25.18,63.33 24.35,62.5 24.35,62.34 24.48,62.2 24.64,62.2 25.51,63.07 25.67,63.07 25.81,62.94 25.81,62.78 24.86,61.83 24.86,61.67 24.99,61.55 25.18,61.55 26.18,62.55 26.36,62.55 26.49,62.42 26.49,62.26 25.66,61.43 25.66,61.27 25.77,61.16 25.93,61.16 26.8,62.02 26.96,62.02 27.07,61.9 27.07,61.74 26.62,61.29 26.62,61.13 26.73,61.02 26.89,61.02 27.36,61.49 27.52,61.49 27.63,61.38 27.63,61.22 26.88,60.46 26.88,60.3 26.99,60.19 27.15,60.19 27.89,60.93 28.05,60.93 28.16,60.82 28.16,60.66 26.99,59.48 26.99,59.32 27.1,59.21 27.26,59.21 28.42,60.37 28.58,60.37 28.7,60.26 28.7,60.1 27.55,58.95 27.55,58.79 27.67,58.68 27.83,58.68 29.02,59.87 29.16,59.87 30.7,58.34 30.7,56.98 30.31,56.59 30.31,55.15 30.42,55.03 30.58,55.03 30.69,55.15 30.69,56.25 30.81,56.37 30.97,56.37 31.08,56.25 31.08,53.78 31.19,53.67 31.35,53.67 31.47,53.78 31.47,55.45 31.58,55.56 31.74,55.56 31.85,55.45 31.85,53 32.62,52.23 32.62,51.3 38.85,45.06 39.46,45.06 39.66,44.87 39.66,44.44 41.31,42.79 41.47,42.79 41.58,42.9 41.58,43.06 40.67,43.97 40.67,44.13 40.79,44.24 40.95,44.24 42.01,43.18 42.01,40.58 42.35,40.24 45.65,40.24 47.13,38.75 51,38.75 52.12,39.87 55.12,39.87 56.36,38.63 58.2,38.63 58.84,39.28 59.7,39.28 59.89,39.46 64.02,39.46 64.16,39.33 65.79,39.33 66.92,39.8 67.66,40.54 68.7,40.54 69.03,40.87 73.57,40.87 74.37,40.07 81.35,40.07 81.7,40.41 86.48,40.41 86.71,40.19 88.04,40.19 88.99,41.14 89.5,41.14 90.33,41.97 90.33,42.3 90.03,42.6 89.61,42.6 89.37,42.83 89.37,43.25 89.65,43.53 v1(90.61,43.53)
FPGA_1V2_AVSTX16_D14: length 125.3
  L05_SIG2 w0.081: v1(89.82,43.07) 90.63,43.07 90.96,42.73 90.96,42.02 91.08,41.9 91.08,41.56 89.77,40.25 89.17,40.25 88.43,39.52 86.36,39.52 86.11,39.76 82.13,39.76 81.76,39.39 73.22,39.39 72.67,39.94 70.18,39.94 67.06,38.64 60.16,38.64 59.45,37.93 55.96,37.93 54.71,39.18 52.38,39.18 51.24,38.03 45.4,38.03 45.02,37.65 43.88,37.65 42.19,39.33 41.11,39.33 40.34,40.11 40.34,41.37 38.45,43.26 38.29,43.26 38.18,43.15 38.18,42.99 39.3,41.87 39.3,41.71 39.18,41.59 39.02,41.59 37.75,42.87 37.75,43.68 37.63,43.79 37.47,43.79 37.36,43.68 37.36,42.6 37.25,42.49 37.09,42.49 36.97,42.6 36.97,44.53 36.86,44.64 36.7,44.64 36.59,44.53 36.59,42.6 36.47,42.49 36.32,42.49 36.2,42.6 36.2,45.28 31.17,50.31 31.17,51.59 30.99,51.77 30.83,51.77 30.18,51.13 30.02,51.13 29.89,51.25 29.89,51.41 30.54,52.06 30.54,52.22 30.07,52.69 30.07,54.02 29.26,54.83 28.77,54.83 25.51,58.09 25.35,58.09 25.24,57.98 25.24,57.82 26.2,56.86 26.2,56.7 26.09,56.58 25.93,56.58 23.4,59.11 23.4,59.27 23.51,59.38 23.67,59.38 24.68,58.37 24.84,58.37 24.96,58.49 24.96,58.65 22.16,61.45 22.16,62.9 19.57,65.49 19.57,69.74 20.08,70.25 21.38,70.25 21.59,70.46 22.49,70.46 23.19,71.17 24.43,71.17 24.58,71.33 24.58,72.16 24.78,72.36 24.78,73.25 v1(25.18,73.65)
FPGA_1V2_AVSTX16_D15: length 122.5
  L05_SIG2 w0.081: v1(89.02,41.69) 87.94,40.61 86.91,40.61 86.78,40.74 81.5,40.74 81.2,40.44 80.24,40.44 79.79,40.88 78.41,40.88 78.3,40.77 78.3,40.54 78.18,40.43 78.02,40.43 77.91,40.54 77.91,40.77 77.8,40.88 77.64,40.88 77.52,40.77 77.52,40.54 77.41,40.43 77.25,40.43 77.14,40.54 77.14,40.77 77.02,40.88 76.86,40.88 76.75,40.77 76.75,40.54 76.64,40.43 76.48,40.43 76.36,40.54 76.36,40.77 76.25,40.88 76.09,40.88 75.98,40.77 75.98,40.54 75.87,40.43 75.71,40.43 75.59,40.54 75.59,40.77 75.48,40.88 74.16,40.88 73.84,41.2 68.89,41.2 68.56,40.87 67.54,40.87 67.06,40.4 66.56,40.4 66.35,40.62 65.62,40.62 65.43,40.44 65.43,40 65.11,39.67 64.32,39.67 64.22,39.77 64.22,40.87 64.12,40.97 63.86,40.97 63.76,40.87 63.76,39.91 63.66,39.8 62.29,39.8 62.19,39.91 62.19,40.87 62.08,40.97 61.81,40.97 61.7,40.87 61.7,39.93 61.6,39.83 60.54,39.83 60.43,39.93 60.43,40.85 60.33,40.95 60.13,40.95 60.03,40.85 60.03,39.91 59.93,39.8 59.19,39.8 58.51,40.48 57.78,40.48 57.52,40.22 57.52,39.55 57.43,39.46 57.24,39.46 57.15,39.55 57.15,40.77 57.04,40.88 56.88,40.88 56.77,40.77 56.77,39.38 56.66,39.26 56.5,39.26 56.38,39.38 56.38,40.04 56.28,40.15 56.1,40.15 56,40.04 56,39.97 55.88,39.85 55.72,39.85 55.61,39.97 55.61,40.67 55.5,40.78 55.34,40.78 55.22,40.67 55.22,40.33 55.11,40.21 54.95,40.21 54.84,40.33 54.84,40.67 54.73,40.78 54.57,40.78 54.45,40.67 54.45,40.37 54.34,40.26 54.18,40.26 54.07,40.37 54.07,40.67 53.95,40.78 53.79,40.78 53.68,40.67 53.68,40.38 53.57,40.27 53.41,40.27 53.29,40.38 53.29,40.67 53.18,40.78 53.02,40.78 52.91,40.67 52.91,40.37 52.79,40.26 52.64,40.26 52.52,40.37 52.52,40.67 52.41,40.78 52.25,40.78 52.14,40.67 52.14,40.37 52.02,40.26 51.86,40.26 51.75,40.37 51.75,40.67 51.64,40.78 51.48,40.78 51.36,40.67 51.36,39.6 50.9,39.14 47.29,39.14 47.19,39.24 47.19,39.38 47.29,39.48 47.89,39.48 48,39.59 48,39.73 47.89,39.83 46.59,39.83 46.49,39.93 46.49,40.08 46.59,40.18 47.89,40.18 48,40.28 48,40.71 47.84,40.87 45.7,40.87 45.38,40.55 42.9,40.55 42.61,40.84 42.61,43.64 41.19,45.06 40.06,45.06 39.54,45.59 38.95,45.59 33.12,51.42 33.12,52.47 32.32,53.27 32.32,55.65 31.46,56.51 31.46,57.34 31.13,57.68 31.13,58.39 25.51,64.01 24.49,64.01 23.84,63.36 23.39,63.36 20.45,66.29 20.45,68.25 20.68,68.47 20.68,69.85 20.86,70.03 22.97,70.03 23.21,70.27 24.52,70.27 24.79,70.55 24.79,71.95 25.18,72.34 v1(25.18,72.65)
FPGA_1V2_AVSTX16_READY: length 119.9
  L05_SIG2 w0.081: v1(24.18,69.65) 23.71,69.19 23.08,69.19 22.74,68.86 22.74,67.59 23.14,67.2 24.6,67.2 25.5,66.3 26.02,66.3 26.27,66.55 27.22,66.55 28.2,65.57 29.1,65.57 32.53,62.15 33.71,62.15 35.97,59.89 36.11,59.89 36.24,60.02 36.24,60.16 35.42,60.98 35.42,61.13 35.55,61.26 35.69,61.26 37.6,59.35 37.96,59.35 38.06,59.45 38.06,60.91 38.16,61.01 38.35,61.01 38.45,60.91 38.45,58.94 38.55,58.84 38.73,58.84 38.83,58.94 38.83,60.91 38.94,61.01 39.12,61.01 39.22,60.91 39.22,59.45 39.32,59.35 40.85,59.35 41.63,58.57 41.63,57.47 42.5,56.6 42.65,56.6 42.78,56.73 42.78,56.87 41.98,57.67 41.98,57.81 42.11,57.94 42.25,57.94 43.6,56.59 48.05,56.59 49.32,55.32 51.16,55.32 51.56,54.93 51.56,52.77 51.72,52.62 52.23,52.62 52.33,52.51 52.33,52.32 52.23,52.22 50.42,52.22 50.32,52.12 50.32,51.94 50.42,51.83 52.85,51.83 52.95,51.73 52.95,51.55 52.85,51.45 50.25,51.45 50.15,51.35 50.15,51.16 50.25,51.06 52.82,51.06 52.93,50.96 52.93,50.78 52.82,50.68 50.79,50.68 50.69,50.57 50.69,50.39 50.79,50.29 52.34,50.29 52.45,50.18 52.45,49.93 52.35,49.83 51.43,49.83 51.33,49.73 51.33,49.49 51.43,49.39 52.78,49.39 52.89,49.29 52.89,49.11 52.78,49.01 51.43,49.01 51.33,48.9 51.33,48.72 51.43,48.62 52.01,48.62 52.11,48.52 52.11,48.34 52.01,48.23 51.82,48.23 51.72,48.13 51.72,47.95 51.82,47.85 52.17,47.85 52.39,47.63 52.39,47.07 54.87,44.6 55.62,44.6 56.5,43.72 64.04,43.72 64.14,43.82 64.14,43.96 64.04,44.06 62.73,44.06 62.63,44.17 62.63,44.31 62.73,44.41 65.89,44.41 65.99,44.31 65.99,44.17 65.89,44.06 64.8,44.06 64.7,43.96 64.7,43.82 64.8,43.72 66.77,43.72 66.95,43.89 73.3,43.89 73.81,43.39 75.32,43.39 75.7,43.77 75.7,44.4 76.21,44.91 79.69,44.91 80.14,44.45 80.42,44.45 81.26,43.61 82.65,43.61 82.73,43.53 v1(84.24,43.53)
FPGA_1V2_AVSTX16_VALID: length 124.3
  L05_SIG2 w0.081: v1(23.18,68.65) 23.71,68.12 25.06,68.12 26.27,66.91 27.41,66.91 28.05,66.27 28.92,66.27 29.99,65.19 30.13,65.19 30.3,65.36 30.45,65.36 30.58,65.23 30.58,65.09 30.41,64.92 30.41,64.78 30.54,64.65 30.68,64.65 31.32,65.29 31.46,65.29 31.59,65.16 31.59,65.01 30.95,64.37 30.95,64.23 31.08,64.1 31.23,64.1 31.42,64.3 31.57,64.3 31.69,64.17 31.69,64.02 31.5,63.83 31.5,63.68 32.61,62.58 33.99,62.58 34.91,61.65 37.09,61.65 37.2,61.75 37.2,61.94 37.09,62.04 35.04,62.04 34.94,62.14 34.94,62.32 35.04,62.42 39.75,62.42 39.85,62.32 39.85,62.14 39.75,62.04 37.77,62.04 37.67,61.94 37.67,61.75 37.77,61.65 40.67,61.65 40.77,61.55 40.77,61.37 40.67,61.27 39.72,61.27 39.62,61.16 39.62,60.98 39.72,60.88 40.82,60.88 41.14,60.57 41.14,59.97 42.6,58.51 42.74,58.51 42.87,58.64 42.87,58.78 42.07,59.58 42.07,59.73 42.2,59.86 42.34,59.86 44.48,57.72 44.48,57.58 44.35,57.45 44.21,57.45 43.35,58.31 43.2,58.31 43.07,58.18 43.07,58.04 44.07,57.04 48.07,57.04 49.45,55.66 51.29,55.66 52.24,54.7 52.24,53.22 53.46,52 53.46,47.94 55.23,46.18 55.23,46.04 55.1,45.91 54.95,45.91 53.08,47.78 52.94,47.78 52.81,47.65 52.81,47.5 54.88,45.43 55.47,45.43 56.75,44.15 58.12,44.15 58.27,44.31 58.27,44.63 58.4,44.75 58.55,44.75 58.66,44.65 58.66,44.18 58.76,44.08 58.94,44.08 59.04,44.18 59.04,44.65 59.14,44.75 60.06,44.75 60.16,44.65 60.16,44.16 60.26,44.06 61.98,44.06 62.09,44.16 62.09,44.3 61.98,44.4 60.71,44.4 60.6,44.51 60.6,44.65 60.73,44.77 70.12,44.77 70.49,44.4 73.43,44.4 73.82,44.01 74.49,44.01 75.85,45.37 80.32,45.37 80.7,44.99 81.19,44.99 81.69,44.48 82.13,44.48 82.43,44.78 82.76,44.78 83.27,45.29 83.52,45.29 83.95,45.72 85.4,45.72 85.9,46.22 91.66,46.22 92.61,45.27 92.61,43.29 92.34,43.02 92,43.02 91.78,42.8 91.78,42.11 v1(92.21,41.69)
FPGA_1V2_LED0: length 276.2
  L03_SIG1 w0.081: v1(217.3,100.03) 217.72,99.61 217.72,83.36 219.23,81.84 219.23,66.6 218.1,65.47 218.1,58.59 218.95,57.74 218.95,43.64 217.65,42.33 217.65,36.12 217.89,35.88 217.89,33.56 221.22,30.22 221.22,26.53 221.92,25.82 221.92,22.98 222.18,22.72 222.18,19.79 221.75,19.36 221.75,17.73 v1(221.24,17.22)
  L07_SIG3 w0.089: v1(83.44,42.15) 82.59,42.15 82.2,41.76 81.65,41.76 78.98,39.1 77.52,39.1 75.51,37.09 75.51,29.27 73.79,27.55 73.79,27.17 73.58,26.97 72.9,26.97 71.89,25.95 71.89,23.32 70.49,21.92 70.49,17.73 74.91,13.31 81.47,13.31 82.77,12.02 127.95,12.02 128.59,12.65 135.14,12.65 136.41,13.92 218.7,13.92 221.24,16.46 v1(221.24,17.22)
  BOTTOM w0.149: U87.2 217.58,99.75 v1(217.3,100.03)
FPGA_1V2_LED1: length 277.6
  L03_SIG1 w0.081: v1(221.24,18.11) 221.24,19.26 221.83,19.84 221.83,22.41 220.3,23.93 220.3,26.12 220.67,26.48 220.67,30.32 217.42,33.57 217.42,38.46 217.18,38.7 217.18,39.12 217.42,39.36 217.42,41.18 217.15,41.44 217.15,41.94 217.42,42.2 217.42,42.74 218.72,44.04 218.72,57.41 217.56,58.57 217.56,65.64 218.9,66.98 218.9,81.03 216.8,83.14 216.8,100.54 v1(217.3,101.04)
  L07_SIG3 w0.089: v1(84.24,41.69) 84.11,41.56 83.01,41.56 82.77,41.32 81.66,41.32 78.95,38.61 77.8,38.61 76.02,36.84 76.02,29.13 75.44,28.55 75.44,27.27 75.13,26.96 74.84,26.96 74.59,26.7 74.59,26.32 74.43,26.16 74.04,26.16 73.79,25.9 73.79,25.61 72.83,24.65 72.83,23.17 70.98,21.33 70.98,17.75 74.99,13.74 82.04,13.74 83.26,12.52 127.9,12.52 128.38,13.01 134.74,13.01 136.09,14.35 157.54,14.35 158,14.81 160.54,14.81 160.86,14.49 181.95,14.49 182.15,14.68 183.8,14.68 184,14.49 218.38,14.49 220.73,16.84 220.73,17.6 v1(221.24,18.11)
  BOTTOM w0.149: U87.3 217.99,100.15 217.43,100.71 217.43,100.92 v1(217.3,101.04)
FPGA_1V2_LED2: length 280.3
  L03_SIG1 w0.081: v1(217.3,102.06) 216.87,101.63 216.26,101.63 215.86,101.22 215.86,81.66 218.52,79 218.52,67.85 217.08,66.4 217.08,58.52 218.47,57.13 218.47,44.81 216.03,42.37 216.03,36.83 217.05,35.82 217.05,33.48 220.18,30.35 220.18,26.77 219.95,26.53 219.95,23.75 221.42,22.28 221.42,20.07 220.23,18.87 v1(220.23,17.22)
  L07_SIG3 w0.089: v1(85.04,43.07) 84.6,42.63 84.6,41.96 84.7,41.86 84.7,41.51 84.42,41.23 83.09,41.23 82.75,40.89 81.66,40.89 78.19,37.42 77.55,37.42 76.35,36.22 76.35,28.8 75.83,28.28 75.83,27.14 75.39,26.7 75.39,26.4 75.15,26.16 74.84,26.16 74.59,25.9 74.59,25.6 74.35,25.36 73.95,25.36 73.15,24.56 73.15,22.4 71.95,21.2 71.95,17.29 75.11,14.13 84.46,14.13 85.43,13.16 112.15,13.16 112.4,12.91 127.77,12.91 128.15,13.29 134.49,13.29 135.99,14.79 156.95,14.79 157.36,15.19 161.04,15.19 161.39,14.85 181.3,14.85 181.64,15.19 184.31,15.19 184.65,14.85 217.85,14.85 v1(220.23,17.22)
  BOTTOM w0.149: v1(217.3,102.06) 217.81,101.55 217.81,100.79 218.05,100.55 U87.4
